# Allegro board Dell Latitude 5290 2-IN-1 LA-F371P Boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB20_P1: length 78.9
  IN1 w0.066: v8(59.31,123.64) 59.19,123.64 59.12,123.58 59.12,123.42 59.78,122.77 59.78,121.73 59.05,121.01 57.51,121.01 57.11,120.61 57.11,119.77 55.65,118.3 54.51,118.3 53.87,117.67 53.74,117.67 53.74,117.67 53.4,117.67 53.39,117.67 53.2,117.67 51.96,116.43 45.06,116.43 43.24,114.62 43.24,109.94 39.31,106 39.31,95.53 35.9,92.13 34.99,92.13 34.82,92.29 v7(34.34,92.29)
  IN4 w0.066: v7(34.34,92.29) 34.66,92.29 34.79,92.17 34.79,89.07 35.16,88.7 35.16,86.1 39.62,81.64 39.62,78.56 39,77.93 39,74.75 35.58,71.33 35.01,71.33 33.29,69.61 32.68,69.61 v1(32.54,69.75)
  BOTTOM w0.112: v1(32.54,69.75) 32.58,69.8 ML7.4
USB20_P1_R: length 3.1
  BOTTOM w0.076: UT1.L5 35.13,67.4 35.13,67.78 35.14,67.8 35.14,67.86 35.16,67.87 35.16,67.88
  BOTTOM w0.112: ML7.3 34.79,69.8 34.94,69.65 34.94,69.5 35.28,69.16 35.28,68.19 35.16,68.07 35.16,67.88
USB20_P2: length 119.6
  TOP w0.112: JIO2.11 75.25,58.15 75.27,58.17 v7(75.69,58.17)
  IN1 w0.066: v8(57.36,122.58) 57.11,122.32 57.11,121.43 56.34,120.66 56.34,120.12 55.7,119.48 55.7,119.11 55.54,118.95 55.17,118.95 54.9,118.68 54.15,118.68 53.95,118.48 53.66,118.19 52.98,118.19 51.74,116.95 44.84,116.95 43.78,115.9 43.78,115.89 42.72,114.83 42.72,110.96 38.79,107.02 38.79,104.66 38.23,104.1 38.23,96.33 36.43,94.53 35.57,94.53 v7(35.33,94.29)
  IN3 w0.081: v6(45.69,55.56) 45.75,55.62 45.75,56.2 45.8,56.25 47.54,57.99 75.51,57.99 v7(75.69,58.17)
  IN4 w0.066: v7(35.33,94.29) 35.57,94.53 35.77,94.53 35.83,94.47 35.83,89.5 36.2,89.14 36.2,86.54 39.87,82.86 40.39,82.86 40.85,82.39 40.85,72.62 45.56,67.92 45.56,57.92 45.78,57.71 45.78,55.64 v6(45.69,55.56)
USB20_P3: length 126.6
  IN1 w0.066: v8(55.28,119.38) 55.38,119.58 55.35,119.68 55.26,119.72 55.17,119.71 54.63,119.17 54.02,119.17 53.83,118.98 53.56,118.71 52.76,118.71 51.53,117.47 44.62,117.47 42.2,115.05 42.2,111.19 38.27,107.25 38.27,104.89 37.64,104.27 37.64,103.53 37.22,103.11 37.22,102.65 37.57,102.3 37.57,97.22 36.17,95.82 35.65,95.82 35.46,95.63 34.79,94.96 34.6,94.96 v7(34.4,94.76)
  IN4 w0.066: v7(34.4,94.76) 34.6,94.96 34.71,94.96 34.78,94.9 34.78,93.95 35.31,93.41 35.31,89.28 35.68,88.92 35.68,86.32 40.33,81.66 40.33,72.2 44.64,67.89 44.64,53.77 50.67,47.74 50.67,37.78 50.39,37.5 50.39,28.77 49.64,28.02 49.64,23.94 49.1,23.39 49.1,21.27 49.99,20.38 49.99,17.61 49.89,17.5 49.58,17.5 49.47,17.62 49.47,17.84 v1(49.57,17.94)
  BOTTOM w0.112: ML14.4 49.67,17.84 v1(49.57,17.94)
USB20_P3_R: length 2.9
  BOTTOM w0.076: UT2.L5 53.77,17.6 53.85,17.68 53.85,17.77 53.77,17.85 53.41,17.85 53.24,17.68 53.12,17.68 53.11,17.7 53.09,17.7
  BOTTOM w0.112: 53.09,17.7 51.99,17.7 51.85,17.84 ML14.3
USB20_P4: length 77.7
  TOP w0.112: v8(31.67,110.15) L10.1
  IN1 w0.066: v8(31.67,110.15) 31.36,110.15 31.24,110.03 31.24,109.94 31.65,109.54 31.65,108.59 32.19,108.04 35.75,108.04 36.3,108.58 36.3,109.99 35.35,110.93 35.35,111.15 35.63,111.42 35.85,111.42 37.52,109.75 37.61,109.75 37.75,109.89 37.75,109.99 35.38,112.35 35.38,112.57 36.05,113.24 36.05,113.33 35.71,113.68 35.71,113.9 35.94,114.13 36.15,114.13 36.5,113.78 36.59,113.78 36.73,113.92 36.73,114.01 35.7,115.05 35.7,115.27 35.93,115.5 36.14,115.5 37.18,114.46 37.27,114.46 37.41,114.6 37.41,114.69 35.96,116.14 35.96,116.36 36.19,116.59 36.41,116.59 37.86,115.14 37.95,115.14 38.09,115.28 38.09,115.37 36.64,116.82 36.64,117.04 36.87,117.27 37.09,117.27 38.83,115.52 38.93,115.52 39.07,115.66 39.07,115.76 37.32,117.5 37.32,117.72 37.55,117.95 37.77,117.95 39.52,116.2 39.62,116.2 39.76,116.34 39.76,116.43 38,118.18 38,118.4 38.23,118.63 38.45,118.63 39.6,117.48 39.69,117.48 39.83,117.62 39.83,117.71 38.68,118.86 38.68,119.08 38.91,119.31 39.13,119.31 40.63,117.81 40.72,117.81 40.86,117.95 40.86,118.04 39.63,119.28 39.63,119.49 39.86,119.72 40.07,119.72 41.42,118.38 41.8,118.38 43.28,119.86 50.25,119.86 51.52,121.13 55.86,121.13 55.86,121.13 56.03,121.13 56.17,121.27 56.17,122.88 56.15,122.9 56.15,123.3 56.17,123.32 56.44,123.59 56.56,123.59 57.64,123.59 58.08,123.15 58.85,123.15 59.14,122.86 59.14,122.64 59.21,122.58 v8(59.31,122.58)
USB20_P4_CONN: length 2.9
  TOP w0.112: JNGFF1.7 31.38,113.86 31.24,113.71 31.24,113.53 31.37,113.4 31.37,112.42 31.67,112.12 L10.2
USB20_P5: length 61.1
  TOP w0.076: UCPU1.AJ2 54.56,119.38 54.39,119.55 54.39,119.62 54.2,119.81 54.13,119.81 53.35,120.59 v8(52.96,120.59)
  TOP w0.112: ML3.1 v8(29.93,104.19)
  IN1 w0.066: v8(52.96,120.59) 52.22,120.59 50.82,119.18 43.34,119.18 39.99,115.83 39.99,115.61 40.49,115.11 40.49,115.02 40.35,114.88 40.26,114.88 39.75,115.38 39.54,115.38 39.31,115.15 39.31,114.93 40.49,113.75 40.49,113.66 40.35,113.52 40.26,113.52 38.77,115 38.55,115 38.33,114.78 38.33,114.56 39.56,113.32 39.56,113.23 39.42,113.09 39.33,113.09 38.09,114.32 37.87,114.32 37.65,114.1 37.65,113.88 40.01,111.51 40.01,111.42 39.87,111.28 39.78,111.28 37.41,113.64 37.19,113.64 36.93,113.38 36.93,113.16 39.28,110.81 39.28,110.69 39.08,110.48 38.98,110.48 36.82,112.64 36.61,112.64 36.38,112.41 36.38,112.19 38.54,110.04 38.54,109.94 36.55,107.96 36.55,105.92 36.05,105.41 33.72,105.41 32.8,104.49 31.09,104.49 30.43,103.84 30,103.84 29.93,103.9 v8(29.93,104.19)
USB20_P5_CONN: length 17.6
  TOP w0.112: ML3.2 27.55,104.19 v11(26.85,103.49) 26.62,103.26 26.58,103.22 25.46,102.1 25.46,101.82 25.45,101.8 25.45,101.25 25.46,101.23 25.46,100.64 25.72,100.38 v7(26.38,100.38) ; JIR1.9 15.8,99.75 v3(15.95,99.9)
  IN2 w0.081: v4(16.24,99.66) 16,99.9 v3(15.95,99.9)
  IN3 w0.081: v4(16.24,99.66) 16.32,99.75 18.79,99.75 19.13,100.08 24.83,100.08 25.14,100.38 v7(26.38,100.38)
USB20_P7: length 103.6
  IN1 w0.066: v10(43.24,80.3) 43.14,80.2 42.74,80.2 40.63,78.1 31.57,78.1 29.53,80.14 29.53,81.87 33.79,86.13 33.79,93.49 33.46,93.82 33.46,97.51 34.72,98.78 34.72,99.89 36.01,101.18 36.01,102.86 36.4,103.24 36.56,103.24 37.06,103.74 37.06,104.5 37.74,105.19 37.74,107.47 41.68,111.4 41.68,115.27 44.41,117.99 51.31,117.99 52.55,119.23 53.44,119.23 53.69,119.47 53.84,119.63 54.54,119.63 54.71,119.8 54.71,119.98 54.77,120.04 v8(54.96,120.04)
  IN2 w0.081: v7(37.5,55.33) 37.31,55.52 37.31,55.75 35.19,57.87 35.19,61.86 36.07,62.74 38.07,62.74 40.93,65.6 40.93,68.78 43.81,71.66 43.81,80.03 43.63,80.21 43.33,80.21 v10(43.24,80.3)
  BOTTOM w0.112: v7(37.5,55.33) 37.31,55.14 37.31,54.71 37.47,54.55 ML8.4
USB20_P7_R: length 2.8
  TOP w0.112: v7(37.51,51.72) 37.32,51.91 37.32,52.12 37.47,52.27 JNGFF3.3
  BOTTOM w0.112: v7(37.51,51.72) 37.33,51.9 37.33,52.53 37.47,52.68 ML8.3
USB20_P9: length 40.6
  IN1 w0.066: v8(54.63,120.7) 54.45,120.7 54.33,120.59 54.33,120.45 54.17,120.29 53.87,120.29 53.64,120.07 53.33,119.75 52.33,119.75 51.1,118.51 43.9,118.51 41.16,115.77 41.16,111.62 37.22,107.68 37.22,105.61 34.85,103.24 34.25,103.24 34.14,103.13 34.14,102.79 34.18,102.74 35.3,102.74 35.46,102.59 35.46,102.27 35.3,102.11 33.93,102.11 33.86,102.05 33.86,101.85 33.93,101.78 35.25,101.78 35.4,101.63 35.4,101.31 35.25,101.15 33.93,101.15 33.86,101.09 33.86,100.12 33.97,100.02 34.12,100.02 34.19,100.08 34.19,100.26 v8(34.19,100.26)
USB20_P9_CONN: length 26.1
  IN3 w0.081: JUSB1.3 8.81,102.84 8.9,102.94 9.36,102.94 9.46,102.84 9.46,102.26 9.94,101.78 11.7,101.78 12.49,101 12.77,101 12.95,101.17 13.06,101.17 13.23,101 13.23,100.89 13.06,100.71 13.06,100.43 13.35,100.14 13.63,100.14 13.81,100.31 13.92,100.31 14.1,100.14 14.1,100.02 13.92,99.85 13.92,99.56 14.21,99.27 14.5,99.27 14.67,99.45 14.79,99.45 14.96,99.27 14.96,99.16 14.78,98.98 14.78,98.7 15.04,98.44 21.2,98.44 22.66,96.98 22.66,95.53 v5(22.42,95.3)
  BOTTOM w0.112: ML6.3 24.34,97.01 24.69,96.66 24.69,96.46 24.62,96.39 23.82,96.39 23.5,96.71 22.97,96.71 22.64,96.38 22.64,96.14 22.42,95.92 v5(22.42,95.3)
USB20_P9_PS: length 8.3
  TOP w0.112: v7(26.39,99.78) 26.53,99.64 27.31,99.64 28.22,100.55 30.09,100.55 30.37,100.26 US1.10
  BOTTOM w0.112: v7(26.39,99.78) 26.34,99.73 25.73,99.73 25.37,100.09 24.92,100.09 24.63,99.8 24.63,99.5 24.34,99.21 ML6.4
USB20_P10: length 116.9
  TOP w0.112: v3(132.81,93.48) 132.85,93.43 JIO1.28
  IN1 w0.066: v7(53.27,116.6) 53.46,116.79 53.99,116.79 54.83,117.63 55.71,117.63 56.13,118.05 56.67,118.05 57.15,118.52 57.15,119.07 57.78,119.7 57.78,120.22 v8(58.01,120.44)
  IN2 w0.081: v4(132.88,93.04) 132.71,93.21 132.71,93.38 v3(132.81,93.48)
  IN3 w0.081: v7(53.27,116.6) 53.46,116.79 53.64,116.79 53.74,116.68 53.74,114.65 56.28,112.11 57.96,112.11 60.21,109.86 61.35,109.86 v6(61.47,109.74) ; v4(132.88,93.04) 132.78,92.95 v6(132.78,92.67)
  IN4 w0.066: v6(132.78,92.67) 132.64,92.82 132.64,93.19 131.97,93.86 128.91,93.86 128.42,94.35 127.15,94.35 126.8,94.71 123.16,94.71 122.49,94.04 111.76,94.04 110.78,93.07 108.08,90.36 104.19,90.36 103.78,89.95 95.79,89.95 95.09,90.65 82.51,90.65 81.93,91.23 77.63,91.23 74.64,88.24 66.19,88.24 64.12,90.31 64.12,104.18 62,106.3 62,108.51 61.15,109.36 61.15,109.79 61.22,109.86 61.35,109.86 v6(61.47,109.74)
USB_DET#: length 17.1
  TOP w0.112: T42.1 12.78,105.93 10.58,108.13 8.87,108.13 JUSB1.10
  IN3 w0.066: JUSB1.10 9.26,108.52 10.31,108.52 10.57,108.78 12.17,108.78 13.28,107.66 13.28,105.32 13.79,104.81 17.31,104.81 v5(17.35,104.78)
USB_ILIM_SEL1: length 3
  TOP w0.112: v2(36.55,101.78) 35.99,101.22 R54.2 35.98,100.76 US1.4
USB_OC0#: length 3.4
  TOP w0.112: UCPU1.A9 58.63,136.94 v2(58.5,137.07) 58.17,137.4 RC13.1
USB_OC1#: length 6.8
  TOP w0.076: 58.95,136.21 58.88,136.13 58.88,134.58 58.87,134.58 58.87,133.76 UCPU1.C9
  TOP w0.112: 58.95,136.21 59.05,136.31 RC11.1 59.05,138.08 59.5,138.52 59.5,139.82 v2(59.59,139.9)
USB_OC2#: length 88.9
  TOP w0.076: UCPU1.D9 59.03,133.27 59.03,135.65 59.59,136.21
  TOP w0.112: US1.13 v3(31.89,97.74) ; v3(59.94,138.04) 59.79,137.88 v2(59.79,137) 59.79,136.4 59.59,136.21
  IN2 w0.066: v4(56.64,138.27) 57.11,138.27 57.71,138.88 59.11,138.88 v3(59.94,138.04) ; v3(31.89,97.74) v4(31.89,98.07)
  IN3 w0.066: v6(51.66,92.11) 51.55,92.22 47.95,92.22 46.77,93.41 45.75,93.41 41.76,97.4 36.25,97.4 35.02,98.62 32.79,98.62 32.23,98.07 v4(31.89,98.07) ; v4(56.64,138.27) 56.64,137.83 54.07,135.27 54.07,134.41 v6(53.03,133.36)
  IN4 w0.066: v6(51.66,92.11) 51.75,92.2 51.75,100.93 51.09,101.59 51.09,104.95 49.58,106.47 49.58,108.79 50.23,109.44 50.23,114.91 49.57,115.58 49.57,115.82 49.57,116.19 48.22,117.53 48.22,117.76 48.22,119.04 47.63,119.63 47.63,120.58 47.35,120.86 46.56,120.86 46.31,121.11 46.31,121.44 45.73,122.02 45.73,123.42 45.54,123.61 45.54,124.17 45.83,124.46 45.83,128.11 50.38,132.65 52.31,132.65 v6(53.03,133.36)
USB_POWERSHARE_EN#: length 36.1
  TOP w0.112: v2(36.54,103.44) v3(35.46,103.44) 33.13,103.44 32.89,103.2 US1.6
  IN2 w0.066: v4(33.76,116.73) 33.78,116.73 33.78,116.12 33.93,115.97 34.65,115.97 35.79,114.82 35.79,105.75 35.46,105.42 v3(35.46,103.44)
  IN3 w0.066: v5(24.04,111.59) 23.63,112.01 23.63,115.01 24.89,116.28 25.89,116.28 26.37,116.76 27.12,116.76 27.21,116.67 28.94,116.67 29.07,116.54 33.57,116.54 v4(33.76,116.73)
  BOTTOM w0.076: v5(24.04,111.59) 24.21,111.42 24.21,111.01 23.93,110.73 UE3.J3
USB_POWERSHARE_VBUS_EN: length 61.8
  TOP w0.112: v3(36.3,102.48) v2(35.43,102.48) 34.82,102.48 R51.2 33.39,101.96 US1.5
  IN2 w0.066: v4(36.02,102.76) v3(36.3,102.48)
  IN3 w0.066: v4(36.02,102.76) 36.09,102.83 v6(36.78,102.83) ; v5(21.68,107.34) 21.6,107.25 19.47,107.25 18.75,107.97 15.73,107.97 v6(15.64,107.88)
  IN4 w0.066: v6(36.78,102.83) 36.78,103.76 36.7,103.84 36.7,107.72 36.42,108 36.42,108.64 36,109.06 36,109.56 36.01,109.56 36.01,112.04 34.76,113.28 34.76,113.79 34.22,114.33 34.22,116.23 33.46,117 33.46,117.34 31.85,118.95 31.85,119.23 31.85,119.49 31.7,119.64 31.7,119.67 31.39,119.98 30.79,119.98 30.42,119.61 30.42,118.87 30.07,118.51 30.07,118.31 28.77,117.01 28.45,117.01 28.43,116.99 27.91,116.99 27.91,117 25.85,119.05 22.48,119.05 22.36,119.17 21.75,119.17 20.14,117.57 20.14,116.93 19.96,116.75 19.61,116.75 18.72,115.86 18.72,113.9 18.36,113.54 18.36,111.47 18.36,110.3 15.94,107.88 v6(15.64,107.88)
  BOTTOM w0.076: UE3.J2 23.64,109.89 23.01,109.89 22.84,109.72 22.84,109.5 22.51,109.16 22.28,109.16 22.02,108.9 22.02,108.6 22.2,108.42 22.2,107.85 v5(21.68,107.34)
USBC1_BN2_L: length 52.6
  IN3 w0.081: v5(15.81,42.42) 15.72,42.33 15.53,42.33 15.41,42.46 15.41,42.78 17.16,44.53 17.16,50.25 17.36,50.45 17.36,63.22 17.9,63.76 17.9,67.74 19.2,69.04 22.64,69.04 22.83,68.85 24.84,68.85 25.03,69.04 29.17,69.04 30.45,70.32 33.66,70.32 34.26,69.72 34.26,66.92 35.02,66.16 36.47,66.16 36.78,66.47 36.78,67 36.58,67.2 36.33,67.2 v5(36.19,67.34)
  BOTTOM w0.112: ML9.1 15.38,42.48 15.52,42.34 15.74,42.34 v5(15.81,42.42)
USBC1_BOT_DN2: length 9.2
  BOTTOM w0.112: JUSBC1.B7 6.13,40.82 6.29,40.82 6.71,41.24 6.71,41.59 7.58,42.46 8.36,42.46 8.38,42.44 10.59,42.44 10.7,42.34 12.49,42.34 D72.2 12.91,42.34 13.16,42.34 13.31,42.48 ML9.2
USBC1_BOT_DP2: length 9.2
  BOTTOM w0.112: JUSBC1.B6 6.02,40.57 6.02,40.58 6.05,40.6 6.38,40.6 6.92,41.15 6.92,41.5 7.26,41.83 7.65,42.23 v11(8.09,42.23) 10.5,42.23 10.61,42.12 12.49,42.12 D73.2 12.91,42.12 13.16,42.12 13.31,41.98 ML9.3
USBC1_BP2_L: length 52.6
  IN3 w0.081: v5(15.81,42.04) 15.72,42.13 15.45,42.13 15.2,42.37 15.2,42.86 16.96,44.61 16.96,50.33 17.16,50.53 17.16,63.3 17.7,63.84 17.7,67.83 19.11,69.24 22.72,69.24 22.91,69.05 24.76,69.05 24.95,69.24 29.08,69.24 30.36,70.52 33.75,70.52 34.46,69.81 34.46,67 35.1,66.36 36.39,66.36 36.58,66.55 36.58,66.91 36.49,66.99 36.35,66.99 v5(36.19,66.84)
  BOTTOM w0.112: v5(15.81,42.04) 15.73,42.12 15.51,42.12 15.37,41.98 ML9.4
USBC1_CC1: length 93.6
  IN2 w0.254: v3(7.11,41.5) 7.02,41.59 v4(7.02,41.92)
  IN3 w0.381: v6(47.58,38.7) 45.85,38.7 45.01,37.86 45.01,37.17 44.35,36.51 42.72,36.51 39.85,39.38 38.52,39.38 38.1,38.97 36,38.97 34.75,40.22 30.45,40.22 27.29,37.06 26.56,37.06 25.65,37.96 23.97,37.96 23.67,37.66 16.51,37.66 13.06,34.2 11.58,34.2 10.67,35.12 10.67,38.75 v6(10.71,38.79) ; v4(8.94,44.9) 8.13,44.9 7.65,44.41 7.65,42.55 v4(7.02,41.92) ; v6(9.85,44.45) 9.85,44.83 v4(9.92,44.9)
  IN4 w0.381: v6(9.85,44.45) 10.14,44.45 10.71,43.88 v6(10.71,38.79) ; v6(47.58,38.7) 47.58,46.93 42.08,52.43 42.08,56.54 41.26,57.35 41.26,59.23 39.76,60.73 39.76,64.76 39.64,64.89 38.91,64.89 38.18,65.62 38.18,68.8 v1(38.44,69.07)
  vias: v3(9.4,44.9)
USBC1_CC2: length 92.4
  IN3 w0.381: v6(48.11,38.17) 46.02,38.17 45.75,37.89 45.75,37.1 44.68,36.03 41.88,36.03 41.38,36.54 39.9,36.54 37.95,38.49 35.79,38.49 34.59,39.69 30.6,39.69 27.49,36.58 26.23,36.58 25.35,37.45 24.64,37.45 24.15,37.45 23.87,37.17 16.89,37.17 13.44,33.72 10.61,33.72 v5(8.06,36.26) 7.99,36.18 7.02,36.18 6.01,35.17 3.99,35.17 3.57,35.59 3.57,39.3 4.22,39.95 JUSBC1.B5
  IN4 w0.381: v1(39.33,69.07) 39.33,67.79 40.35,66.78 40.35,66.27 40.32,66.24 40.32,65.76 40.31,65.75 40.31,60.86 41.74,59.43 41.74,57.55 42.56,56.74 42.56,52.63 48.07,47.12 48.07,39.21 48.11,39.17 v6(48.11,38.17)
USBC1_RX1N: length 29.4
  IN2 w0.081: JUSBC1.B10 5.1,42.52 5.43,42.85 6.08,42.85 6.42,43.19 6.59,43.19 7.22,43.82 10.02,43.82 11.57,45.36 11.57,45.74 12.14,46.32 13.33,46.32 14.68,44.96 14.68,40.61 12.56,38.5 12.37,38.5 v7(12.12,38.75)
  BOTTOM w0.112: UV1.31 19.55,38.8 19.46,38.71 19.21,38.71 18.92,38.42 18.92,38.13 18.68,37.89 18.53,37.89 18.41,38 D70.1 18.14,37.95 17.97,37.95 17.76,37.74 17.1,37.74 17.08,37.73 16.3,37.73 v11(16.01,38.02) 15.52,38.51 12.36,38.51 v7(12.12,38.75)
USBC1_RX1P: length 29.4
  IN2 w0.081: JUSBC1.B11 5.2,43.05 5.99,43.05 6.33,43.39 6.51,43.39 7.14,44.02 9.94,44.02 11.36,45.45 11.36,45.83 12.06,46.52 13.41,46.52 14.88,45.05 14.88,40.53 12.65,38.29 12.24,38.29 v7(12.12,38.17)
  BOTTOM w0.112: v7(12.12,38.17) 12.24,38.29 15.43,38.29 15.65,38.07 15.65,38.05 16.04,37.66 16.06,37.66 16.21,37.51 17.17,37.51 17.17,37.51 17.33,37.51 17.33,37.51 v11(17.37,37.51) 17.84,37.51 18.06,37.73 18.24,37.73 18.38,37.59 D68.1 18.5,37.67 18.77,37.67 19.14,38.04 19.14,38.33 19.3,38.49 19.49,38.49 19.58,38.4 UV1.30
USBC1_RX2N: length 18.5
  TOP w0.112: v3(8.7,37.84) 8.43,37.57 8.29,37.57 8.18,37.68 8.18,38.62 7.94,38.86 7.75,38.86 7.61,39 JUSBC1.A10
  IN2 w0.081: v3(8.7,37.84) 8.95,37.59 11.29,37.59 11.71,37.17 13.41,37.17 18.03,41.8 18.03,43.09 v7(17.91,43.22)
  BOTTOM w0.112: UV1.39 19.64,42 19.46,42.18 18.9,42.18 17.91,43.17 v7(17.91,43.22)
USBC1_RX2P: length 18.5
  TOP w0.112: v3(8.7,37.08) 8.43,37.35 8.2,37.35 7.96,37.59 7.96,38.53 7.85,38.64 7.68,38.64 7.54,38.5 JUSBC1.A11
  IN2 w0.081: v3(8.7,37.08) 8.7,37.31 8.78,37.39 11.21,37.39 11.63,36.97 13.5,36.97 18.24,41.71 18.24,43.04 18.41,43.22 v7(18.47,43.22)
  BOTTOM w0.112: v7(18.47,43.22) 18.47,42.94 19.01,42.4 UV1.40
USBC1_SBU1: length 82.6
  IN2 w0.081: v7(12.18,35.94) 12.18,35.92 11.94,35.68 6.51,35.68 6.27,35.91 6.27,36.13 6.36,36.21 9.29,36.21 9.37,36.29 9.37,36.52 9.27,36.63 7.21,36.63 7.11,36.72 7.11,36.92 7.19,37 7.44,37 7.57,37.12 7.57,37.3 7.49,37.38 7.19,37.38 7.11,37.46 v3(7.11,40)
  IN3 w0.081: v5(37.57,69.84) 37.31,69.84 37.22,69.92 37.22,70.85 36.28,71.79 29.72,71.79 28.38,70.46 26.87,70.46 26.74,70.59 18.78,70.59 16.5,68.31 16.5,64.32 15.96,63.79 15.96,51.18 15.72,50.94 15.72,45.23 13.98,43.49 13.98,36.79 13,35.8 12.32,35.8 v7(12.18,35.94)
  BOTTOM w0.112: v7(12.18,35.94) 12.43,35.69 12.86,35.69 13.05,35.88 13.78,35.88 D51.1 14.31,35.99 15.06,35.99 v11(15.3,35.75) 16.06,34.98 16.09,34.98 16.48,34.59 16.48,34.57 16.63,34.42 17.67,34.42 17.82,34.26 18.5,34.26 RV95.2
USBC1_SBU2: length 82.1
  IN2 w0.081: v7(12.19,35.37) 12.09,35.47 6.42,35.47 6.24,35.65 6.13,35.65 5.78,35.31 3.75,35.31 3.3,35.75 3.3,40.07 4.78,41.55 JUSBC1.B8
  IN3 w0.081: v7(12.19,35.37) 12.42,35.6 13.08,35.6 14.19,36.7 14.19,43.41 15.93,45.15 15.93,50.85 16.17,51.09 16.17,63.7 16.7,64.24 16.7,68.23 18.86,70.38 26.66,70.38 26.78,70.26 28.47,70.26 29.8,71.59 36.2,71.59 37.02,70.77 37.02,69.92 36.94,69.84 v5(36.68,69.84)
  BOTTOM w0.112: v7(12.19,35.37) 12.29,35.47 12.95,35.47 13.14,35.66 13.99,35.66 D69.2 14.31,35.77 14.94,35.77 15.33,35.39 15.35,35.39 v11(16.12,34.62) 16.54,34.2 17.58,34.2 17.73,34.04 18.5,34.04 RV96.2
USBC1_TN1_L: length 54.1
  IN3 w0.081: v5(15.8,39.87) 15.05,39.87 14.58,40.34 14.58,43.08 16.34,44.84 16.34,50.71 16.56,50.92 16.56,63.54 17.11,64.09 17.11,68.07 19.01,69.98 26.43,69.98 26.57,69.84 28.61,69.84 29.89,71.11 33.99,71.11 35.05,70.05 35.05,67.54 35.3,67.28 35.63,67.28 v5(35.69,67.34)
  BOTTOM w0.112: ML10.4 15.43,39.95 15.46,39.92 15.75,39.92 v5(15.8,39.87)
USBC1_TOP_DN1: length 8.3
  IN2 w0.081: v7(12.08,39.9) 11.89,40.1 11.37,40.1 9.87,41.59 8.11,41.59 7.79,41.27 7.79,40.87 7.54,40.63 7.24,40.63 v3(7.11,40.5)
  BOTTOM w0.112: v7(12.08,39.9) 12.28,40.11 12.47,40.11 D75.1 12.7,39.88 12.9,40.08 13.2,40.08 13.33,39.95 ML10.3
USBC1_TOP_DP1: length 8.3
  IN2 w0.081: v7(12.08,40.49) 11.89,40.3 11.46,40.3 9.96,41.8 8.03,41.8 7.58,41.35 7.58,40.96 7.45,40.83 7.28,40.83 v3(7.11,41)
  BOTTOM w0.112: ML10.2 13.32,40.45 13.17,40.3 12.92,40.3 D74.1 12.51,40.32 12.24,40.32 v7(12.08,40.49)
USBC1_TP1_L: length 54.1
  IN3 w0.081: v5(35.69,66.84) 35.71,66.86 35.71,66.99 35.62,67.08 35.22,67.08 34.85,67.45 34.85,69.97 33.91,70.91 29.97,70.91 28.7,69.64 26.48,69.64 26.34,69.78 19.1,69.78 17.31,67.99 17.31,64 16.76,63.46 16.76,50.84 16.55,50.62 16.55,44.75 14.78,42.99 14.78,40.43 15.14,40.07 15.62,40.07 15.8,40.25 v5(15.8,40.37)
  BOTTOM w0.112: v5(15.8,40.37) 15.8,40.26 15.67,40.13 15.55,40.13 15.23,40.45 ML10.1
USBC1_TX1N: length 16.8
  TOP w0.112: JUSBC1.A3 7.62,42.5 7.73,42.61 7.92,42.61 8.15,42.85 8.15,43.64 8.22,43.71 8.42,43.71 D49.1 8.98,43.97 9.16,43.97 9.27,43.86 9.27,43.56 v7(9.16,43.44)
  BOTTOM w0.112: v7(9.16,43.44) 9.33,43.62 9.33,43.89 9.53,44.09 10.83,44.09 11.1,43.82 11.1,43.14 11.21,43.03 11.62,43.03 12.03,43.44 13.13,43.44 13.21,43.36 15.99,43.36 16.43,42.92 16.43,41.57 16.45,41.55 16.45,41 16.43,40.98 16.43,40.67 v11(16.91,40.18) 17.32,39.78 17.58,39.78 CV31.2
USBC1_TX1N_C: length 1.9
  BOTTOM w0.112: CV31.1 18.54,39.73 18.84,39.73 19.01,39.9 19.52,39.9 19.61,40 UV1.34
USBC1_TX1P: length 16.8
  TOP w0.112: v7(9.74,43.44) 9.49,43.7 9.49,43.94 9.25,44.18 8.59,44.18 D48.1 8.34,43.97 8.18,43.97 7.94,43.73 7.94,42.94 7.83,42.83 7.73,42.83 7.56,43 JUSBC1.A2
  BOTTOM w0.112: v7(9.74,43.44) 9.55,43.63 9.55,43.8 9.62,43.87 10.74,43.87 10.88,43.73 10.88,43.05 11.12,42.81 11.7,42.81 12.12,43.22 13.04,43.22 13.12,43.14 15.9,43.14 16.21,42.83 v11(16.21,41.28) 16.21,40.58 16.55,40.24 16.55,40.21 16.94,39.82 16.97,39.82 17.23,39.56 17.49,39.56 CV33.2
USBC1_TX1P_C: length 1.9
  BOTTOM w0.112: CV33.1 18.54,39.52 18.93,39.52 19.1,39.69 19.55,39.69 19.64,39.6 UV1.33
USBC1_TX2N: length 22
  IN2 w0.081: v7(12.32,44.46) 12.32,44.69 12.5,44.87 12.7,44.87 12.83,44.74 12.83,43.63 11.75,42.56 6.46,42.56 6.26,42.36 6.26,39.08 5.84,38.66 5.42,38.66 5.1,38.98 JUSBC1.B3
  BOTTOM w0.112: v7(12.32,44.46) 12.32,44.62 12.61,44.91 13.37,44.91 14.5,43.78 v11(15.99,43.78) 16.7,43.78 16.85,43.63 16.85,43.59 17.25,43.19 17.25,42.46 D76.2 17.17,42.33 17.35,42.33 17.45,42.23 17.45,41.9 17.18,41.63 CV29.2
USBC1_TX2N_C: length 3.6
  BOTTOM w0.112: CV29.1 17.19,40.93 17.19,40.62 17.45,40.36 18.2,40.36 18.48,40.65 18.59,40.76 19.48,40.76 19.52,40.8 UV1.36
USBC1_TX2P: length 22
  IN2 w0.081: v7(12.32,45.2) 12.45,45.07 12.78,45.07 13.03,44.83 13.03,43.55 11.84,42.36 6.55,42.36 6.46,42.27 6.46,39 5.93,38.46 5.21,38.46 JUSBC1.B2
  BOTTOM w0.112: CV27.2 17.67,41.75 17.67,42.24 D78.2 17.46,42.67 17.46,43.32 v11(17.26,43.52) 16.79,43.99 16.28,43.99 16.26,44.01 15.71,44.01 15.7,43.99 14.59,43.99 13.46,45.12 12.4,45.12 v7(12.32,45.2)
USBC1_TX2P_C: length 3.6
  BOTTOM w0.112: UV1.37 19.54,41.2 19.34,40.99 v11(18.91,40.99) 18.53,40.99 18.11,40.58 17.54,40.58 17.4,40.71 17.4,40.92 17.54,41.05 CV27.1
USBC2_BN2_L: length 51.4
  IN2 w0.081: v7(15.9,28.08) 16.03,27.95 16.43,27.95 17.07,27.32 17.07,24.37 16.76,24.07 16.76,20.05 19.65,17.17 42.41,17.17 45.05,19.81 54.18,19.81 v4(54.27,19.9)
  IN3 w0.081: v4(54.27,19.9) 54.11,19.74 53.91,19.74 53.71,19.54 53.71,18.67 v5(53.63,18.6)
  BOTTOM w0.112: ML11.1 15.4,28.33 15.65,28.08 v7(15.9,28.08)
USBC2_BOT_DN2: length 11.6
  BOTTOM w0.112: ML11.2 13.38,28.33 13.24,28.19 12.94,28.19 D83.2 12.52,28.19 11.75,28.19 9.85,30.09 8.69,30.09 7.72,29.12 v11(7.72,28.41) 7.72,28 7.01,27.29 6.64,26.92 6.64,26.41 6.53,26.3 6.05,26.3 JUSBC2.B7
USBC2_BOT_DP2: length 11.6
  BOTTOM w0.112: ML11.3 13.46,27.83 13.32,27.97 12.94,27.97 D84.2 12.52,27.97 11.66,27.97 9.76,29.88 8.81,29.88 v11(8.44,29.51) 7.96,29.03 7.96,27.93 7.16,27.13 7.16,27.13 6.86,26.83 6.86,26.33 6.62,26.09 6.14,26.09 JUSBC2.B6
USBC2_BP2_L: length 51.4
  IN2 w0.081: v7(15.93,27.52) 16.15,27.75 16.35,27.75 16.87,27.23 16.87,24.46 16.56,24.15 16.56,19.97 19.57,16.97 42.49,16.97 45.14,19.61 54.03,19.61 v4(54.27,19.37)
  IN3 w0.081: v5(54.13,18.6) 54.04,18.6 53.91,18.73 53.91,19.45 53.99,19.54 54.11,19.54 v4(54.27,19.37)
  BOTTOM w0.112: v7(15.93,27.52) 15.85,27.52 15.42,27.95 15.12,27.95 ML11.4
USBC2_CC1: length 60.6
  IN1 w0.381: v7(14.22,31.87) 14.22,32.2 13.21,33.21 10.92,33.21 8.69,30.98 8.69,30.18 v3(8.95,29.91)
  IN2 w0.381: v3(8.95,29.91) 8.6,29.55 8.6,28.69 7.11,27.2 v3(7.11,26.9)
  IN3 w0.381: v7(50.93,27.52) 50.5,27.09 36.58,27.09 33.99,29.68 27.36,29.68 27.05,29.99 24.09,29.99 23.58,29.48 21.21,29.48 20.21,30.48 17.85,30.48 17.83,30.51 17.38,30.51 17.35,30.48 15.51,30.48 15.47,30.52 15.46,30.52 14.22,31.75 v7(14.22,31.87)
  IN4 w0.381: v7(50.93,27.52) 50.8,27.4 50.8,23.45 50.47,23.12 50.47,21.27 50.93,20.82 50.93,20.17 50.76,20 v1(50.67,20)
  BOTTOM w0.127: v2(51.71,27.51) 51.42,27.21 51.24,27.21 v7(50.93,27.52)
USBC2_CC2: length 64.9
  IN3 w0.381: v6(15.58,31.09) 15.71,30.96 17.15,30.96 17.18,30.99 18.03,30.99 18.05,30.96 20.41,30.96 20.57,30.8 20.57,30.8 21.41,29.96 23.34,29.96 23.85,30.47 27.25,30.47 27.53,30.19 34.16,30.19 36.73,27.62 50.22,27.62 v7(50.39,27.8)
  IN4 w0.381: v7(50.39,27.8) 50.32,27.73 50.32,23.65 49.95,23.29 v1(49.95,22.96) ; JUSBC2.B5 3.81,25.35 3.43,25.73 3.43,31.31 3.81,31.69 5.97,31.69 7.11,30.55 v5(7.94,30.55) 8.26,30.55 9.91,32.2 10.92,32.2 12.06,33.34 13.72,33.34 14.99,32.07 14.99,31.69 v6(15.58,31.09)
  BOTTOM w0.127: v2(50.51,28.32) 50.51,27.94 50.39,27.83 v7(50.39,27.8)
USBC2_RX1N: length 25.3
  IN2 w0.081: v7(17.21,23.93) 17.21,23.79 17.34,23.66 18,23.66 18.29,23.95 18.29,27.27 15.11,30.44 12.77,30.44 12.13,31.08 8.16,31.08 7.35,30.28 7.35,29.17 6.46,28.28 5.47,28.28 5.1,27.92 JUSBC2.B10
  BOTTOM w0.112: v7(17.21,23.93) 17.21,23.83 17.34,23.7 18.11,23.7 D81.1 18.41,24 18.72,23.7 18.87,23.7 19.62,24.45 UV2.31
USBC2_RX1P: length 25.3
  IN2 w0.081: v7(17.19,23.29) 17.36,23.46 18.09,23.46 18.49,23.86 18.49,27.35 15.2,30.65 12.85,30.65 12.21,31.29 8.07,31.29 7.15,30.36 7.15,29.26 6.38,28.49 5.16,28.49 JUSBC2.B11
  BOTTOM w0.112: UV2.30 19.53,24.05 18.96,23.48 18.53,23.48 D80.1 18.3,23.49 17.39,23.49 v7(17.19,23.29)
USBC2_RX2N: length 25.2
  TOP w0.112: JUSBC2.A10 7.62,24.4 7.75,24.27 7.96,24.27 8.27,23.95 8.27,22.78 8.39,22.65 8.65,22.65 8.83,22.83 v3(8.83,22.99)
  IN2 w0.081: v7(12.1,29.29) 12.24,29.42 12.42,29.42 13.54,28.3 13.54,23.72 12.3,22.48 9.01,22.48 8.83,22.67 v3(8.83,22.99)
  BOTTOM w0.112: UV2.39 19.85,27.65 19.11,28.39 19.11,29.03 v11(18.89,29.25) 18.18,29.97 16.64,29.97 16.62,29.95 16.07,29.95 16.05,29.97 15.8,29.97 15.41,29.57 12.36,29.57 12.1,29.31 v7(12.1,29.29)
USBC2_RX2P: length 25.3
  TOP w0.112: JUSBC2.A11 7.18,23.9 7.58,23.9 7.73,24.05 7.87,24.05 8.05,23.86 8.05,22.69 8.31,22.43 8.62,22.43 v3(8.83,22.23)
  IN2 w0.081: v7(12.1,29.87) 12.35,29.63 12.5,29.63 13.74,28.39 13.74,23.64 12.38,22.28 8.88,22.28 v3(8.83,22.23)
  BOTTOM w0.112: v7(12.1,29.87) 12.19,29.78 15.32,29.78 15.71,30.18 v11(16.34,30.18) 18.27,30.18 18.83,29.61 18.86,29.61 19.33,29.15 19.33,28.48 19.76,28.05 UV2.40
USBC2_SBU1: length 58.6
  IN2 w0.081: v3(7.11,25.4) 6.97,25.26 6.97,23.86 7.68,23.15 7.68,21.96 7.76,21.88 9.72,21.88 9.8,21.8 9.8,21.64 9.72,21.56 6.57,21.56 6.49,21.48 6.49,21.21 6.58,21.11 9.85,21.11 11.43,19.52 12.11,19.52 v7(12.32,19.73)
  IN3 w0.081: v5(20.03,19.6) 20.18,19.75 20.18,19.98 20.36,20.16 21.17,20.16 22.04,19.28 25.93,19.28 27.28,20.64 30.92,20.64 31.39,21.11 35.7,21.11 38.99,24.4 41.41,24.4 41.62,24.61 48.16,24.61 48.35,24.8 48.59,24.8 v5(48.67,24.88)
  BOTTOM w0.112: v5(48.67,24.88) 48.74,24.8 48.96,24.8 49.38,25.22 49.62,25.22 RT121.2 ; v5(20.03,19.6) 20.21,19.41 20.21,19.22 20.07,19.08 19.08,19.08 18.69,19.46 14.26,19.46 D57.1 13.72,19.69 13.51,19.48 12.57,19.48 v7(12.32,19.73)
USBC2_SBU2: length 58.4
  IN2 w0.081: v7(12.32,19.12) 12.11,19.32 11.35,19.32 9.76,20.91 6.24,20.91 5.51,20.77 4.05,20.77 3.55,21.26 3.55,25.7 4.8,26.95 JUSBC2.B8
  IN3 w0.081: v5(20.61,19.6) 20.38,19.83 20.38,19.89 20.44,19.95 21.08,19.95 21.96,19.08 26.01,19.08 27.37,20.44 31.01,20.44 31.48,20.91 35.78,20.91 39.08,24.2 41.49,24.2 41.7,24.41 48.24,24.41 48.43,24.6 48.57,24.6 48.67,24.51 v5(48.67,24.5)
  BOTTOM w0.112: v7(12.32,19.12) 12.47,19.26 13.51,19.26 13.72,19.05 D79.2 14.22,19.24 18.6,19.24 18.99,18.86 20.16,18.86 20.43,19.13 20.43,19.41 v5(20.61,19.6) ; RT122.2 49.62,25.01 49.47,25.01 49.05,24.59 48.76,24.59 v5(48.67,24.5)
USBC2_TN1_L: length 48.4
  IN2 w0.081: v7(16.13,23.38) 16.13,23.64 15.85,23.92 15.45,23.92 15.32,23.78 15.32,20.14 18.88,16.58 42.71,16.58 45.3,19.17 50.34,19.17 51.49,18.02 52.37,18.02 52.55,18.2 v4(52.55,18.33)
  IN3 w0.081: v4(52.55,18.33) 52.55,18.2 52.73,18.02 53.06,18.02 53.4,17.68 53.63,17.68 53.79,17.85 53.79,17.94 v5(53.63,18.1)
  BOTTOM w0.112: v7(16.13,23.38) 16.13,23.65 16,23.77 15.76,23.77 15.63,23.64 ML12.4
USBC2_TOP_DN1: length 9
  IN2 w0.081: v3(7.11,25.9) 7.14,25.93 7.31,25.93 7.39,25.85 7.39,24.74 8.01,24.12 10.02,24.12 10.25,23.89 11.79,23.89 v7(12.08,23.6)
  BOTTOM w0.112: ML12.3 13.9,23.64 13.76,23.78 12.83,23.78 D86.1 12.42,23.78 12.26,23.78 v7(12.08,23.6)
USBC2_TOP_DP1: length 9
  IN2 w0.081: v7(12.08,24.18) 11.99,24.09 10.34,24.09 10.11,24.32 8.09,24.32 7.59,24.82 7.59,25.93 7.39,26.14 7.37,26.14 v3(7.11,26.4)
  BOTTOM w0.112: ML12.2 13.97,24.14 13.82,24 12.83,24 D85.1 12.41,23.99 12.27,23.99 v7(12.08,24.18)
USBC2_TP1_L: length 48.6
  IN2 w0.081: v7(16.13,24.2) 16.05,24.12 15.37,24.12 15.11,23.86 15.11,20.05 18.79,16.38 42.79,16.38 45.38,18.97 50.25,18.97 51.4,17.82 52.35,17.82 v4(52.53,17.64)
  IN3 w0.081: v4(52.53,17.64) 52.7,17.82 52.98,17.82 53.32,17.48 53.71,17.48 53.99,17.76 53.99,17.96 v5(54.13,18.1)
  BOTTOM w0.112: v7(16.13,24.2) 15.93,23.99 15.75,23.99 15.6,24.14 ML12.1
USBC2_TX1N: length 14.8
  TOP w0.112: v7(9.71,29.3) 9.56,29.15 9.56,28.69 9.28,28.41 8.78,28.41 D56.1 8.56,28.2 8.41,28.35 8.13,28.35 7.89,28.11 7.75,28.11 7.54,27.9 JUSBC2.A3
  BOTTOM w0.112: CV54.2 17.66,25.64 17.39,25.64 17.17,25.41 16.21,25.41 16.19,25.43 15.64,25.43 15.62,25.41 11.81,25.41 10.44,26.79 10.44,27.83 9.5,28.78 9.5,29.08 v7(9.71,29.3)
USBC2_TX1N_C: length 1.9
  BOTTOM w0.112: UV2.34 19.59,25.65 19.49,25.55 18.75,25.55 CV54.1
USBC2_TX1P: length 14.7
  TOP w0.112: v7(9.13,29.3) 9.34,29.08 9.34,28.78 9.19,28.62 8.78,28.62 D55.1 8.48,28.83 8.22,28.56 8.04,28.56 7.8,28.32 7.58,28.32 7.5,28.4 JUSBC2.A2
  BOTTOM w0.112: v7(9.13,29.3) 9.28,29.14 9.28,28.69 10.22,27.75 10.22,26.7 11.72,25.2 v11(15.91,25.2) 17.26,25.2 17.48,25.42 17.66,25.42 CV56.2
USBC2_TX1P_C: length 1.8
  BOTTOM w0.112: CV56.1 18.58,25.34 19.49,25.34 19.59,25.25 UV2.33
USBC2_TX2N: length 22.3
  IN2 w0.081: v7(12.12,26.4) 12.16,26.45 12.69,26.45 13,26.76 13,27.7 12.47,28.23 11.87,28.23 11.28,28.83 11.28,29.61 10.19,30.7 8.64,30.7 7.84,29.89 7.84,29.05 6.27,27.48 6.27,24.74 6.01,24.47 5.18,24.47 JUSBC2.B3
  BOTTOM w0.112: CV48.2 D87.2 17.02,26.74 16.69,26.74 16.28,26.33 v11(15.29,26.33) 14.52,26.33 14.44,26.4 v7(12.12,26.4)
USBC2_TX2N_C: length 2
  BOTTOM w0.112: UV2.36 19.59,26.45 19.49,26.54 19.2,26.54 18.91,26.82 18.67,26.82 CV48.1
USBC2_TX2P: length 22.3
  IN2 w0.081: JUSBC2.B2 5.1,23.91 5.46,24.27 6.1,24.27 6.48,24.65 6.48,27.4 8.04,28.96 8.04,29.81 8.72,30.49 10.1,30.49 11.07,29.52 11.07,28.74 11.79,28.03 12.39,28.03 12.8,27.62 12.8,26.84 12.61,26.65 12.43,26.65 v7(12.12,26.96)
  BOTTOM w0.112: CV46.2 17.82,27.29 D88.2 16.8,26.95 16.6,26.95 16.19,26.54 15.58,26.54 15.57,26.56 15.02,26.56 15,26.54 14.61,26.54 14.53,26.62 12.46,26.62 v7(12.12,26.96)
USBC2_TX2P_C: length 2
  BOTTOM w0.112: CV46.1 18.66,27.04 19,27.04 19.29,26.75 19.49,26.75 19.59,26.85 UV2.37
USBCOMP: length 3.2
  TOP w0.305: UCPU1.AB6 56.71,123.17 v7(56.64,123.1)
  BOTTOM w0.127: RC137.1 v2(55.07,124.17)
  BOTTOM w0.305: v7(56.64,123.1) 56.61,123.13 RC137.1
USH_DET: length 31.8
  IN3 w0.066: v5(28.73,118.05) 29.64,118.05 29.74,117.95 32.34,117.95 32.47,118.08 39.99,118.08 41.63,116.44 41.63,112.43 44.7,109.36 45.59,109.36 v6(46.61,108.35)
  IN4 w0.066: v6(46.61,108.35) 46.79,108.17 v1(46.79,105.86)
  BOTTOM w0.076: UE3.C13 v5(28.73,118.05)
  BOTTOM w0.112: v2(47.09,103.3) 46.71,103.68 Q31.1 45.42,104.26 R474.2 45.95,105.02 v1(46.79,105.86)
USH_DET#: length 150.2
  TOP w0.076: v3(54.63,118.05) 54.37,118.05 53.94,118.48 52.45,118.48
  TOP w0.112: 52.45,118.48 52.31,118.48 51.66,117.83 49.88,117.83 49.23,118.48 47.81,118.48 47.49,118.79 45.87,118.79 45.62,119.04 45.62,120.27 v2(45.27,120.62) 44.83,121.06 RH7.1 ; JIO1.40 130.45,93.63 130.34,93.75 130.15,93.75 129.08,92.67 129.08,91.94 129.21,91.81 129.21,91.3 v7(129.13,91.23)
  IN2 w0.066: v3(54.63,118.05) 54.41,118.28 v4(54.39,118.28) ; v7(129.13,91.23) 128.07,90.16 123.23,90.16 121.56,91.83 116.88,91.83 111.34,86.29 95.72,86.29 95.17,86.44 92.53,87.07 82.51,87.07 80.34,84.89 v4(79.45,84.89)
  IN3 w0.066: v4(54.39,118.28) 55.18,117.48 55.18,117.23 55.88,116.53 55.88,115.25 56.68,114.45 56.68,113.95 57.19,113.44 59.67,113.44 v6(60.01,113.1) ; v4(79.45,84.89) 79.45,84.26 77.68,82.49 73.25,82.49 71.63,84.11 71.62,84.11 70.94,84.79 61.69,84.79 v6(61.63,84.85) ; v6(60.05,93.89) 59.89,93.89 57.75,96.03 54.43,96.03 53.29,97.16 51.59,97.16 50.92,97.83 47.92,97.83 45.47,100.28 v5(45.22,100.28)
  IN4 w0.066: v6(60.01,113.1) 60.01,110.95 59.74,110.68 59.74,108.05 59.41,107.73 59.41,105.31 58,103.9 58,101 58.24,100.76 58.24,99.56 59.8,98 59.8,97.37 60.18,96.99 60.18,94.53 60.05,94.4 v6(60.05,93.89) 60.05,93.23 60.54,92.74 60.54,92.17 60.93,91.78 60.93,89.24 61.65,88.53 61.65,87.45 61.5,87.29 61.5,84.98 v6(61.63,84.85)
  BOTTOM w0.112: v5(45.22,100.28) 45.71,100.28 R480.2
USH_PWR_STATE#: length 159
  TOP w0.112: RE122.2 139.18,94.39 139.76,93.8 139.76,88.33 v2(139.47,88.03) 139.23,87.8 134.62,87.8 v7(133.98,88.43) 134.05,88.5 JIO1.21
  IN3 w0.066: v6(69.28,81.73) 69.23,81.68 66.73,81.68 65.71,82.7 48.21,82.7 46.3,84.61 45.11,84.61 42.13,87.59 39.65,87.59 v6(39.45,87.8) ; v5(25.02,109.18) 25.33,109.18 25.79,108.73 26.09,108.73 26.2,108.61 27.7,108.61 27.96,108.35 29.11,108.35 30.12,109.36 30.12,109.63 30.63,110.13 32,110.13 32.74,109.4 32.74,109.18 32.74,108.14 32.92,107.95 36.06,107.95 v6(36.14,108.04)
  IN4 w0.066: v6(36.14,108.04) 36.45,107.74 36.45,103.75 36.52,103.68 36.52,102.72 36.67,102.57 36.67,102.57 37.28,101.96 37.28,100.58 39.6,98.26 39.6,98.14 39.61,98.14 39.61,97.92 39.6,97.92 39.6,96.56 39.26,96.22 39.26,93.67 39.53,93.39 39.53,93.18 39.43,93.08 39.43,91.15 38.42,90.15 38.42,88.32 38.95,87.8 v6(39.45,87.8) ; v6(69.28,81.73) 69.01,81.99 69.01,82.37 69.69,83.05 69.69,84.04 69.78,84.13 70.1,84.13 70.89,84.92 74.73,84.92 78.71,88.9 94.37,88.9 94.83,88.45 110.08,88.45 113.91,92.28 122.15,92.28 123.25,91.17 126.44,91.17 127.84,89.78 127.84,89.58 128.42,88.99 133.86,88.99 133.98,88.86 v7(133.98,88.43)
  BOTTOM w0.076: v5(25.02,109.18) 24.73,109.48 UE3.H2
USH_RST#: length 151.8
  TOP w0.112: JIO1.19 134.45,88.6 v7(134.62,88.43)
  IN2 w0.066: v7(134.62,88.43) 134.6,88.43 132.43,90.6 130.29,90.6 129.29,91.61 128.91,91.61 127.79,90.49 123.6,90.49 121.8,92.29 116.66,92.29 111.11,86.73 95.31,86.73 95.25,86.75 92.57,87.39 82.06,87.39 80.11,85.43 v4(79.44,85.43)
  IN3 w0.066: v6(17.99,94.23) 18.11,94.35 21.03,94.35 21.32,94.06 26.21,94.06 28.26,96.12 39.71,96.12 44.13,91.7 45.87,91.7 46.56,92.39 47.25,92.39 47.8,91.85 56.33,91.85 57.1,91.07 57.1,90.46 58.54,89.03 64.07,89.03 64.25,88.84 66.94,88.84 68.72,87.07 72.46,87.07 73.91,85.62 77.64,85.62 78.07,85.19 79.2,85.19 v4(79.44,85.43)
  IN4 w0.066: v13(17.65,112.21) 17.74,112.12 17.74,110.7 15.32,108.29 15.32,103.91 14.82,103.41 14.82,97.98 16.93,95.87 16.93,95.29 v6(17.99,94.23)
  BOTTOM w0.112: v2(134.26,87.86) 134.62,88.22 v7(134.62,88.43)
USH_RST#_L: length 4.9
  BOTTOM w0.076: 19.9,112.36 20,112.36 20.09,112.45 20.29,112.45 20.38,112.36 20.77,112.36 21.15,111.98 21.15,111.97 21.41,111.72 21.64,111.72 22.04,112.11 22.04,112.12 22.33,112.41 UE3.L6
  BOTTOM w0.112: RE47.2 19.75,112.21 19.9,112.36
UV1_SBU1: length 5.1
  BOTTOM w0.112: RV95.1 19.44,34.27 19.63,34.27 19.74,34.37 19.74,34.62 19.61,34.75 19.61,34.98 RV18.1 19.67,35.57 19.67,35.88 19.91,36.11 21.03,36.11 21.28,36.37 21.28,36.57 21.1,36.75 UV1.27
UV1_SBU2: length 5.2
  BOTTOM w0.112: RV96.1 19.46,34.05 19.72,34.05 19.95,34.28 19.95,34.71 19.82,34.84 19.82,35.04 RV17.1 19.89,35.38 19.89,35.79 20,35.9 21.12,35.9 21.5,36.28 UV1.26
UV2_SBU1: length 3.5
  BOTTOM w0.112: UV2.27 21.23,22.27 21.29,22.2 21.29,22.05 20.68,21.43 20.51,21.43 20.27,21.19 20.27,21.06 RV47.1 20.21,20.54 20.21,20.36 RV97.1
UV2_SBU2: length 3.5
  BOTTOM w0.112: RV98.1 20.42,20.37 20.42,20.52 RV46.1 20.48,20.94 20.48,21.1 20.6,21.21 20.79,21.21 v11(21.21,21.63) 21.51,21.93 21.51,22.21 21.63,22.33 UV2.26
VCI_IN1#: length 10.7
  IN3 w0.066: v5(36.86,108.22) 36.45,108.62 36.22,108.62 35.72,108.12 32.99,108.12 32.91,108.21 32.91,108.58 32.91,108.58 32.91,109.46 32.91,109.55 31.94,110.52 31.94,111.23 v5(32,111.29)
  BOTTOM w0.076: 31.24,111.28 30.7,111.28 30.45,111.52 30.18,111.52 29.69,112 UE3.B5
  BOTTOM w0.112: 31.24,111.28 31.99,111.28 v5(32,111.29)
VCI_IN2#: length 6.9
  BOTTOM w0.076: UE3.D4 27.79,111.06 27.42,111.06 27.25,110.89 27.25,110.69 27.41,110.52 27.41,110.28 27.25,110.12 26.85,110.12 26.77,110.03 26.77,109.33 27.01,109.09 27.25,109.09 27.41,108.92 27.41,108.67 28.8,107.28 28.8,106.9 RE142.1
VID0_PRIM_CORE: length 3.5
  TOP w0.254: PU801.9 51.55,143.97 51.94,143.58 PR822.2 ; PR818.2 PR822.2 ; PR822.2 PR821.1
VID0_VCCIO: length 4.9
  TOP w0.112: v2(128.78,124.97) 128.6,124.79 127.27,124.79 126.8,125.26 PR809.1
  TOP w0.254: PU800.9 125.71,126.77 126.3,126.18 PR804.2 PR809.1
VID1_PRIM_CORE: length 3.5
  TOP w0.254: PU801.8 50.28,142.52 PR820.1 PR823.2 PR817.2
VID1_VCCIO: length 3.2
  TOP w0.254: PU800.8 v7(124.53,125.16)
  BOTTOM w0.112: v7(124.53,125.16) v2(124.53,124.58)
  BOTTOM w0.254: PR805.2 PR808.1 124.28,125.4 v7(124.53,125.16)
VIDALERT_N: length 35
  TOP w0.112: v7(90.07,140.22) 89.99,140.15 RC22.2
  IN4 w0.066: v1(61.7,145.48) 62.05,145.12 62.05,143.7 63.8,141.95 73.56,141.95 74.19,142.58 78.71,142.58 79.38,141.92 88.52,141.92 90.07,140.37 v7(90.07,140.22)
  BOTTOM w0.112: PR930.1 61.33,145.48 v1(61.7,145.48) ; RC94.2 90.03,139.57 90.07,139.61 v7(90.07,140.22)
VIDSCLK: length 38.7
  TOP w0.112: v7(89.43,140.25) 89.12,139.93 RC21.2
  IN4 w0.066: v1(63.42,148.64) 61.39,146.61 61.39,142.61 62.72,141.28 69.85,141.28 69.93,141.37 73.99,141.37 74.68,142.05 78.25,142.05 79.03,141.27 88.41,141.27 v7(89.43,140.25)
  BOTTOM w0.112: RC95.2 89.14,139.47 89.43,139.77 v7(89.43,140.25)
VIDSCLK_R: length 12.9
  TOP w0.076: UCPU1.A63 89.88,135.13 89.88,135.61 89.33,136.16 88.9,136.16 88.67,135.93 88.54,135.93 88.44,136.03 88.44,136.38 88.52,136.46 89.1,136.46 89.18,136.54 89.18,136.69 89.1,136.77 88.09,136.77 88.01,136.84 88.01,136.99 88.09,137.07 v2(88.35,137.07) 89.05,137.07 89.13,137.15 89.13,137.3 89.05,137.37 87.83,137.37 87.76,137.45 87.76,137.6 87.83,137.68 89.04,137.68 89.12,137.76 89.12,137.87 89.03,137.96 88.54,137.96 88.44,138.06 88.44,138.17 88.54,138.27 88.99,138.27 89.04,138.32 89.51,138.32 89.59,138.4 89.59,138.85 89.53,138.9 89.34,138.9 RC21.1
VIDSOUT: length 35
  TOP w0.112: RC23.2 90.87,140.06 v7(90.68,140.25)
  IN4 w0.066: v7(90.68,140.25) 90.68,140.53 88.7,142.5 79.75,142.5 79.14,143.12 73.84,143.12 73.25,142.53 63.98,142.53 62.59,143.93 62.59,145.35 61.96,145.98 v1(61.7,145.98)
  BOTTOM w0.112: RC93.2 90.92,140.01 v7(90.68,140.25)
VIDSOUT_R: length 12.9
  TOP w0.076: UCPU1.D64 90.54,133.2 90.61,133.27 90.61,133.38 90.47,133.52 90.15,133.52 90.06,133.61 89.99,133.73 89.99,133.97 90.21,134.19 90.21,135.18 90.6,135.57 90.6,135.98 90.74,136.12 91.15,136.12 91.22,136.2 91.22,136.35 91.15,136.42 90.59,136.42 90.51,136.5 90.51,136.65 90.59,136.73 91.21,136.73 91.29,136.81 91.29,136.96 91.21,137.03 90.59,137.03 90.51,137.11 90.51,137.26 90.59,137.34 91.21,137.34 91.29,137.41 91.29,137.57 91.21,137.64 v2(90.75,137.64) 90.67,137.64 90.45,137.86 90.45,138.09 90.6,138.24 90.78,138.24 90.86,138.16 90.86,138.04 90.96,137.94 91.16,137.94 91.24,138.01 91.24,138.22 91.34,138.32 91.34,139
  TOP w0.112: RC23.1 90.8,138.74 90.8,139.08 90.88,139.16 91.24,139.16 91.34,139.05 91.34,139
VOL_DOWN#: length 51.6
  TOP w0.112: v3(5.84,137.92) v2(6.19,138.27) 6.39,138.47 C20.1 R24.1
  IN2 w0.066: v4(9.94,113.79) 8.58,115.16 8.58,119.93 6.78,121.73 2.9,121.73 2.04,122.59 2.04,126.37 6.02,130.35 6.02,137.75 v3(5.84,137.92)
  IN3 w0.066: v4(9.94,113.79) 10.42,114.27 15.18,114.27 18.09,111.36 v5(18.1,111.36) 19.86,111.36 21.1,110.12 v5(21.23,110.12)
  BOTTOM w0.076: v5(21.23,110.12) 21.64,110.12 21.81,110.28 21.81,110.52 22.04,110.75 22.04,111.32 22.21,111.49 22.66,111.49 22.87,111.7 23.23,111.7 23.62,112.09 23.62,112.5 UE3.J6
VOL_UP#: length 76.6
  TOP w0.112: R23.1 C19.1 v7(6.26,152.27) v2(6.26,151.72)
  IN2 w0.066: v7(6.26,152.27) 6.26,147.53 5.58,146.85 5.58,144.99 4.71,144.11 4.71,136.69 5.85,135.55 5.85,130.42 1.87,126.44 1.87,122.52 2.84,121.56 6.71,121.56 8.42,119.86 8.42,114.75 v4(9.94,113.22)
  IN3 w0.066: v5(28.98,107.76) 28.98,107.89 28.85,108.01 28.52,108.01 27.82,108.01 27.56,108.28 26.02,108.28 25.91,108.39 25.65,108.39 25.29,108.75 24.36,108.75 24.11,109.01 22.81,109.01 21.92,109.89 21.43,109.89 21.37,109.84 21.14,109.84 20.01,110.97 18.1,110.97 17.6,111.47 17.6,111.61 15.12,114.1 10.82,114.1 v4(9.94,113.22)
  BOTTOM w0.076: 29.72,106.75 29.72,107 29.16,107.56 29.16,107.58 v5(28.98,107.76) 28.77,107.96 28.75,107.96 27.93,108.79 UE3.D1
  BOTTOM w0.112: 29.72,106.75 29.72,105.62 29.72,105.62 29.72,105.26 29.53,105.06 29.48,105.06 29.16,104.74 RE64.1
VOLUME_DOWN#: length 4.8
  TOP w0.112: v9(5.77,142.25) D21.1
  TOP w0.254: D21.1 5.8,141 R24.2 5.74,140.15 4.55,138.96 SW2.2
VOLUME_UP#: length 4.3
  TOP w0.112: D20.1 v9(5.64,155.61)
  TOP w0.254: SW1.2 5.19,153.06 5.61,153.48 R23.2 5.68,154.34 D20.1
VR_LPM#: length 3.6
  TOP w0.254: v2(47.45,147.75) PR813.1 PR814.2 49.34,147.26 49.78,146.82 PU801.14
VR_LPM_R#: length 30.7
  IN2 w0.066: v4(49.33,148.1) 49.33,148.66 v3(49.34,148.67)
  IN3 w0.066: v4(49.33,148.1) 50.99,148.1 52.07,149.18 54.35,149.18 54.51,149.02 54.51,145.42 55,144.93 55.4,144.93 55.59,144.75 55.59,140.89 56.4,140.07 v5(56.4,139.85)
  BOTTOM w0.112: U4252.4 69.26,138.51 68.52,139.24 60.54,139.24 59.82,139.96 56.51,139.96 v5(56.4,139.85)
VRA_VDD18: length 3.3
  BOTTOM w0.254: PU900.26 62.56,150.21 PC901.1 63.28,149.67 PR935.2
VRACPU_VINSEN: length 6.2
  BOTTOM w0.112: PR942.1 55.29,159.39 PC911.1 56.83,159.39 PR943.2 56.83,159.26 56.39,158.82 56.39,158.08 56.67,157.8 56.67,156.63 57.33,155.97 PU900.47
VRACPU_VTEMP: length 48.9
  IN1 w0.066: v8(94.65,157.46) 94.28,157.82 92.43,157.82 90.07,160.19 87.4,160.19 85.87,161.72 82.86,161.72 82.45,161.3 82.45,160.69 81.93,160.18 v8(81.74,160.18) 81.71,160.15 80.48,160.15 80.16,159.83 78.97,159.83 78.76,160.04 73.78,160.04 72.06,161.76 65.94,161.76 65.56,161.38 65.56,160.66 v8(65.11,160.21) 65.09,160.19 63.98,160.19 63.67,160.5 62.73,160.5 61.67,159.45 56.52,159.45 55.5,158.43 55.5,156.99 55.24,156.73 v8(55.24,156.68) 55.11,156.68 54.86,156.43 54.86,155.72 v10(54.99,155.59)
  IN2 w0.066: v10(54.99,155.59) 54.71,155.31 v4(54.71,155.28)
  IN3 w0.066: v4(54.71,155.28) v5(54.71,154.93)
VRALERT#: length 18.4
  TOP w0.076: v7(60.73,118.15) 60.71,118.15 UCPU1.AM11
  IN2 w0.066: v3(47.19,121.79) 47.19,122.04 v4(47.12,122.12)
  IN3 w0.066: v7(60.73,118.15) 60.55,118.15 59.68,119.02 58.42,119.02 56.87,120.57 56.43,120.57 55.88,120.57 55.77,120.68 51.06,120.68 50.92,120.68 49.78,121.82 48.26,121.82 47.41,121.82 v4(47.12,122.12)
  BOTTOM w0.112: v7(60.73,118.15) 59.57,118.15 58.99,118.73 v2(58.78,118.73)
VSA_SEN+: length 42.7
  TOP w0.254: v7(65.28,130.53) 65.28,130.5 64.93,130.15 UCPU1.H20
  IN3 w0.254: v5(66.32,155.79) 65.43,154.9 59.77,154.9 59,155.67 57.85,155.67 57.43,155.67 56.21,154.45 56.21,141.6 59.06,138.75 59.65,138.75 60.02,138.38 60.02,135.93 65.28,130.67 v7(65.28,130.53)
  BOTTOM w0.127: RC116.2 v2(64.34,132.91)
  BOTTOM w0.254: RC116.2 64.34,131.7 65.28,130.76 v7(65.28,130.53)
VSA_SEN-: length 41
  TOP w0.254: UCPU1.H21 65.95,130.15 v7(66.24,130.44)
  IN3 w0.254: v7(66.24,130.44) 60.53,136.15 60.53,138.59 59.86,139.26 59.27,139.26 56.72,141.81 56.72,154.24 57.64,155.16 58.79,155.16 59.56,154.4 65.81,154.4 v5(66.32,154.91)
  BOTTOM w0.254: v7(66.24,130.44) 66.24,130.48 v2(65.82,130.89) 65.82,130.96 65.2,131.59 RC115.1
VSET_5105: length 8.2
  BOTTOM w0.076: UE3.C9 29.03,115.51 29.03,116.22 29.23,116.41 29.23,117.71 29.52,118 29.53,118 29.83,118.3 29.83,119.27 29.88,119.32
  BOTTOM w0.112: RE58.1 30.26,122.26 CE30.1 30.28,121.55 30.7,121.13 30.7,120.14 29.88,119.32
WF_HCLK: length 35.2
  TOP w0.112: JWFC1.27 124.42,160.54 124.42,160.54 124.8,160.54 v3(125.19,160.15)
  IN2 w0.066: v4(126.92,160.39) 126.48,160.39 126.24,160.15 v3(125.19,160.15)
  GND3 w0.066: v6(127.04,160) 127.04,160.28 v4(126.92,160.39)
  IN4 w0.066: v5(151.35,149.67) 150.01,151.01 143.41,151.01 142.36,152.06 141.2,153.21 130.08,153.21 128.57,154.72 128.57,157.64 127.04,159.18 v6(127.04,160)
  BOTTOM w0.112: L20.1 151.35,149.2 v5(151.35,149.67)
WF_HCLK_R: length 6.1
  IN3 w0.066: v5(151.64,148.15) 151.35,147.86 v5(151.35,147.26) 151.22,147.13 151.22,143.35 150.63,142.76 v5(150.35,142.76)
WF_I2C_CLK: length 46.3
  TOP w0.112: v3(124.84,159.7) 124.82,159.68 124.81,159.69 124.48,159.69 124.42,159.74 JWFC1.25
  IN2 w0.066: v3(124.84,159.7) 124.89,159.65 124.9,159.65 125.02,159.65 125.05,159.68 125.71,159.68 125.89,159.5 125.89,156.02 125.47,155.6 125.47,153.98 128.51,150.94 143.31,150.94 145.99,148.26 145.99,143.05 147.64,141.39 147.64,139.84 147.33,139.53 147.13,139.53 v4(146.97,139.37)
  IN3 w0.066: v5(149.95,141.96) 149.82,141.96 147.38,139.51 147.11,139.51 v4(146.97,139.37) 146.77,139.57 146.61,139.57 146.47,139.43 145.63,139.43 v5(145.45,139.26)
WF_I2C_DATA: length 46.1
  TOP w0.112: v3(124.84,159.32) 124.44,159.32 124.42,159.34 JWFC1.24
  IN2 w0.066: v4(146.97,139.9) 147.15,139.72 147.25,139.72 147.45,139.92 147.45,141.31 145.8,142.97 145.8,148.18 143.23,150.74 128.43,150.74 125.28,153.9 125.28,155.68 125.7,156.1 125.7,159.42 125.63,159.48 125.13,159.48 125.1,159.46 124.98,159.46 v3(124.84,159.32)
  IN3 w0.066: v5(149.95,142.76) 149.95,142.36 147.3,139.71 147.17,139.71 v4(146.97,139.9) 146.83,139.77 146.53,139.77 146.39,139.63 145.66,139.63 v5(145.45,139.83)
WF_SENSOR_RST#: length 58.1
  TOP w0.112: v2(157,140.46) 157.12,140.59 v7(157.5,140.59) ; v3(126.3,159.39) 126.2,159.49 126.2,159.86 125.51,160.54 R14.2 125.5,160.59 125.28,160.81 125.28,160.85 124.79,161.34 JWFC1.29
  IN2 w0.066: v7(157.5,140.59) 157.15,140.24 155.01,140.24 153.72,141.54 153.72,144.63 150.4,147.95 147.74,147.95 144.3,151.38 128.7,151.38 126.02,154.06 v3(126.02,154.9) 126.02,155.52 126.34,155.83 126.34,159.35 v3(126.3,159.39)
  BOTTOM w0.112: v7(157.5,140.59) 157.81,140.28 157.81,138.5 156.64,137.33 151.45,137.33 R115.1
WF_SENSOR_RST#_R: length 7.8
  IN4 w0.066: v1(150.75,142.36) 151,142.11 151,141.3 152.32,139.97 152.32,137.76 151.65,137.09 150.29,137.09 v1(150.11,136.91)
WF_VSYNC: length 46.4
  TOP w0.112: v7(156.02,140.91) 156.02,140.41 v2(155.75,140.15) ; v3(126.71,159.92) 126.71,160.95 126.43,161.23 C11.1 R11.2
  IN2 w0.066: v7(156.02,140.91) 154.98,140.91 154.16,141.72 154.16,144.82 150.59,148.39 147.92,148.39 144.48,151.83 128.88,151.83 127.12,153.6 127.12,155.98 127.05,156.04 127.05,159.58 v3(126.71,159.92)
  BOTTOM w0.112: R107.1 v7(156.02,140.91)
WFCAM_CSI2_CLKN1: length 70.6
  TOP w0.112: v3(116.88,159.53) 117.44,159.53 R20.1
  IN2 w0.081: v3(72.94,133.85) 72.94,133.76 72.83,133.65 72.72,133.65 72.66,133.71 72.66,134 72.83,134.18 72.97,134.18 73.05,134.26 73.05,135.01 73.44,135.4 73.44,136.5 73.76,136.81 73.76,136.93 72.6,138.08 72.6,138.37 72.89,138.66 73.17,138.66 74.3,137.54 74.48,137.54 74.73,137.79 74.73,137.9 74.54,138.08 74.54,138.41 74.79,138.66 75.12,138.66 75.3,138.48 75.42,138.48 76.38,139.44 76.38,139.55 75.5,140.43 75.5,141.75 75.74,142 87.57,142 87.8,142.23 90.4,142.23 91.23,143.06 107.5,143.06 109.5,145.06 109.5,149.04 113.96,153.5 113.96,154.53 117.4,157.97 117.4,158.15 117.32,158.23 117.04,158.23 116.81,158.46 116.81,158.82 117.04,159.05 117.14,159.05 117.4,159.31 117.4,159.94 117.32,160.02 117.06,160.02 116.88,159.84 v3(116.88,159.53)
WFCAM_CSI2_CLKN1_L: length 3.7
  TOP w0.112: R20.2 118.52,159.53 119.11,159.53 119.44,159.87 119.66,159.87 D17.1 120.12,159.87 120.94,159.87 120.97,159.83 121.22,159.83 121.31,159.74 121.4,159.74 121.4,159.74 JWFC1.8
WFCAM_CSI2_CLKP1: length 70.6
  TOP w0.112: R19.1 117.44,160.38 v3(116.88,160.38)
  IN2 w0.081: v3(72.94,133.2) 72.94,133.47 73.25,133.79 73.25,134.21 73.25,134.92 73.65,135.31 73.65,136.41 73.96,136.73 73.96,137.01 72.8,138.17 72.8,138.28 72.97,138.45 73.09,138.46 74.21,137.33 74.56,137.33 74.93,137.7 74.93,137.98 74.75,138.17 74.75,138.33 74.87,138.46 75.04,138.46 75.22,138.27 75.5,138.27 76.58,139.35 76.58,139.64 75.7,140.52 75.7,141.67 75.83,141.8 87.66,141.8 87.88,142.03 90.48,142.03 91.31,142.85 107.59,142.85 109.7,144.97 109.7,148.95 114.16,153.41 114.16,154.44 117.6,157.88 117.6,158.24 117.4,158.44 117.12,158.44 117.02,158.54 117.02,158.74 117.12,158.84 117.22,158.84 117.6,159.22 117.6,160.02 117.4,160.22 117.04,160.22 v3(116.88,160.38)
WFCAM_CSI2_CLKP1_L: length 3.6
  TOP w0.112: JWFC1.9 121.31,160.14 121.22,160.05 121.06,160.05 121.03,160.09 120.08,160.09 D16.1 119.7,160.09 119.38,160.09 119.08,160.38 118.52,160.38 R19.2
WFCAM_CSI2_DN4: length 70.2
  TOP w0.112: R16.1 117.44,157.5 116.44,157.5 116.33,157.61 116.33,157.78 116.25,157.86 116.08,157.86 v3(115.95,157.74)
  IN2 w0.081: v3(115.95,157.74) 115.77,157.91 114.91,157.91 114.63,157.64 114.63,157.4 114.9,157.13 114.9,156.85 114.61,156.56 114.32,156.56 113.83,157.05 113.71,157.05 113.54,156.88 113.54,156.76 114.04,156.27 114.04,155.99 113.74,155.69 113.46,155.69 113.23,155.92 113.12,155.92 112.98,155.78 112.98,153.9 108.48,149.4 108.48,145.43 107.09,144.03 90.2,144.03 89.43,143.27 87.35,143.27 87.08,143 71.69,143 70.39,141.71 70.39,138.81 72.09,137.12 72.09,133.27 72.24,133.11 72.3,133.11 72.37,133.18 v3(72.37,133.52)
WFCAM_CSI2_DN4_L: length 4.2
  TOP w0.112: JWFC1.5 121.4,158.54 121.4,158.54 121.31,158.54 121.22,158.63 120.85,158.63 120.68,158.46 120.68,158.06 120.44,157.82 120.1,157.82 D13.1 119.68,157.82 119.57,157.82 119.25,157.5 118.52,157.5 R16.2
WFCAM_CSI2_DN5: length 69.5
  TOP w0.112: v3(117.02,154.6) 116.89,154.47 116.39,154.47 116.08,154.78 116.08,155.76 116.25,155.93 116.39,155.93 116.51,155.82 116.51,155.58 116.62,155.47 117.44,155.47 R12.1
  IN2 w0.081: v3(73.5,133.52) 73.5,133.26 73.6,133.16 73.82,133.16 74.35,133.69 74.35,134.96 75.23,135.85 75.23,136.62 75.64,137.03 75.92,137.03 75.99,136.96 76.1,136.96 76.28,137.13 76.28,137.25 76.21,137.32 76.21,137.6 76.47,137.86 76.76,137.86 76.83,137.79 76.94,137.79 77.12,137.96 77.12,138.08 77.04,138.15 77.04,138.43 77.34,138.72 77.62,138.72 77.69,138.65 77.81,138.65 77.98,138.83 77.98,138.94 77.91,139.01 77.91,139.3 78.11,139.5 78.11,139.61 77.84,139.88 77.84,140.21 78.08,140.45 78.41,140.45 78.68,140.19 78.8,140.19 79.42,140.81 86.22,140.81 86.42,140.61 86.42,140.41 86.5,140.32 86.74,140.32 86.82,140.41 86.82,140.61 87.02,140.81 88.08,140.81 88.28,141.01 91.66,141.01 92.53,141.88 108.18,141.88 109.05,142.75 109.33,142.75 109.49,142.6 109.61,142.6 109.78,142.77 109.78,142.88 109.62,143.04 109.62,143.32 109.91,143.62 110.2,143.62 110.35,143.46 110.47,143.46 110.64,143.63 110.64,143.75 110.48,143.9 110.48,144.19 110.72,144.42 110.72,147.85 111.39,148.52 111.39,148.63 111.21,148.8 111.21,149.09 111.57,149.44 111.85,149.44 112.02,149.27 112.14,149.27 112.31,149.44 112.31,149.56 112.14,149.73 112.14,150.01 112.43,150.3 112.71,150.3 112.88,150.13 113,150.13 113.17,150.31 113.17,150.42 113,150.59 113,150.87 113.29,151.17 113.58,151.17 113.75,150.99 113.86,150.99 114.03,151.17 114.03,151.28 113.87,151.45 113.87,151.73 114.16,152.02 114.45,152.02 114.61,151.86 114.72,151.86 114.9,152.03 114.9,152.15 114.73,152.31 114.73,152.59 115.02,152.88 115.31,152.88 115.47,152.72 115.59,152.72 115.76,152.89 115.76,153.01 115.6,153.17 115.6,153.46 115.74,153.6 115.74,153.72 115.42,154.04 115.42,154.32 115.71,154.61 115.99,154.61 116.32,154.29 116.43,154.29 116.56,154.42 116.84,154.42 v3(117.02,154.6)
