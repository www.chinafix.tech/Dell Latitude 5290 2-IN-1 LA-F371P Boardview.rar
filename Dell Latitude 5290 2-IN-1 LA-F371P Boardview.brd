# Allegro board Dell Latitude 5290 2-IN-1 LA-F371P Boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SIO_RCIN#: length 5.7
  TOP w0.112: RC73.2 61.44,109.26 61.44,110.66 61.04,111.06 61.04,113.89 UCPU1.AW13
SIO_SLP_A#: length 98.4
  IN1 w0.066: v14(49.78,115.38) 50.29,115.38 50.49,115.18 52.84,115.18 53.65,116 54.6,116 55.23,116.63 56.29,116.63 58.41,118.75 60.13,118.75 60.48,119.09 61.38,119.09 61.79,118.68 62.76,118.68 63.04,118.4 v8(63.04,117.91)
  GND1 w0.066: v14(49.78,115.38) 49.73,115.33 v4(49.46,115.33)
  IN3 w0.066: v6(22.2,122.59) 22.2,122.69 22.47,122.97 22.74,122.97 22.86,122.85 23.84,122.85 24.49,123.5 28.88,123.5 29.29,123.08 30.69,123.08 30.96,122.81 31.43,122.81 v6(31.46,122.79) 31.51,122.79 31.52,122.78 35.2,122.78 37.69,120.28 41.12,120.28 43.94,117.46 44.96,117.46 46.08,116.35 47.42,116.35 48.02,115.75 48.4,115.75 48.82,115.33 v4(49.46,115.33)
  IN4 w0.066: v1(21.59,121.55) 21.59,121.76 22.2,122.37 v6(22.2,122.59) ; v6(31.46,122.79) 32.74,124.07 32.74,125.54 33.17,125.97 33.17,126.29 33.17,126.3 33.17,127.35 32.31,128.21 32.31,129.27 32.02,129.56 32.02,134.03 31.85,134.2 31.85,135.6 32.18,135.93 32.18,139.18 33.41,140.41 33.41,141.74 33.41,142.15 35.05,143.8 35.05,144.16 37.99,147.1 37.99,155 35.16,157.83 35.16,157.97 35.16,159.89 34.64,160.4 v1(34.64,160.85)
  BOTTOM w0.076: 21.11,119.32 21.11,117.22 UE3.M11
  BOTTOM w0.112: v2(34.43,159.45) 34.64,159.66 v1(34.64,160.85) ; 21.11,119.32 21.11,119.98 21.59,120.46 v1(21.59,121.55)
SIO_SLP_S0#: length 240.9
  TOP w0.076: UCPU1.AT11 60.05,115.96 v7(59.86,116.15)
  TOP w0.112: v7(122.3,132.34) 122.3,132.82 v2(122.15,132.97)
  TOP w0.254: v7(122.3,132.34) PR801.1
  IN1 w0.066: v14(42.95,84.44) 43.37,84.86 43.37,87.26 45.08,88.97 46.18,88.97 47.69,90.48 47.69,90.82 47.96,91.09 49.02,91.09 50.6,92.67 51.47,93.54 51.47,100.87 55,104.4 55.1,104.4 55.24,104.4 55.61,104.77 55.61,107.36 56.56,108.32 56.56,110.33 57.12,110.89 57.12,111.95 56.86,112.22 56.86,112.63 57.01,112.78 57.64,112.78 58.24,113.38 58.24,114.01 59.18,114.95 59.8,114.95 60.22,115.38 60.22,115.77 59.86,116.14 v7(59.86,116.15)
  GND1 w0.066: v4(42.71,84.2) v14(42.95,84.44)
  IN3 w0.066: v7(30.34,160.08) 31.36,160.08 39.75,151.7 39.75,151.16 42.62,148.28 46.74,148.28 46.93,148.1 48.26,148.1 48.66,148.5 51.15,148.5 52.01,149.35 53.3,149.35 53.46,149.51 v5(55.63,149.51) 55.63,149.06 54.76,148.2 54.76,145.4 55.07,145.1 55.47,145.1 55.75,144.82 55.75,140.96 56.71,140.01 56.71,139.42 55.25,137.96 v5(55.25,137.72) 53.16,135.63 53.16,134.5 v6(52.1,133.44) ; v4(42.71,84.2) 41.96,84.95 41.71,84.95 v6(41.61,85.05) 41.5,84.95 40.11,84.95 32.91,92.14 28.85,92.14 v5(28.8,92.19) ; v6(47.2,120.4) 47.52,120.72 49.15,120.72 50.36,119.5 55.28,119.5 55.39,119.4 56,119.4 57.15,118.25 57.15,117.36 58.55,115.95 58.55,115.5 58.8,115.25 59.07,115.25 59.86,116.04 v7(59.86,116.15)
  IN4 w0.066: v6(47.2,120.4) 47.2,120.4 47.2,120.39 46.42,120.39 45.58,121.24 45.58,121.7 45.39,121.88 45.39,123.28 44.93,123.75 44.93,125.92 45.5,126.49 45.5,128.66 50,133.16 51.83,133.16 v6(52.1,133.44) ; v6(41.61,85.05) 41.35,85.31 41.35,85.54 39.91,86.98 39.91,89.45 40.44,89.98 40.44,92.67 40.53,92.76 40.53,93.81 40.44,93.91 40.44,95.98 40.66,96.19 40.66,97.03 v1(40.74,97.12) ; v5(55.25,137.72) 55.85,137.72 56.5,138.37 59.86,138.37 60.14,138.09 63.53,138.09 63.6,138.01 68.04,138.01 v1(68.19,137.86) 68.19,137.18 70.16,135.21 76.9,135.21 78.71,137.02 82.78,137.02 82.88,136.92 87.1,136.92 87.3,137.12 92.41,137.12 93.52,138.22 93.52,138.4 95.62,140.5 107.98,140.5 111.1,137.37 111.1,135.38 113.63,132.86 121.78,132.86 v7(122.3,132.34)
  BOTTOM w0.112: R450.1 32.64,92.65 32.18,92.19 v5(28.8,92.19) ; JAPS1.4 30.14,160.28 v7(30.34,160.08)
SIO_SLP_S3#: length 121.9
  TOP w0.074: v7(62.56,116.95) 62.25,117.26 UCPU1.AP15
  IN3 w0.066: v5(38.35,117.36) 37.64,117.36 37.6,117.4 33.48,117.4 33.12,117.04 29.28,117.04 29.13,117.19 27.41,117.19 27.33,117.26 25.15,117.26 v5(23.39,115.51) ; v6(32.72,129.88) 33.05,129.88 33.12,129.81 40.42,129.81 40.74,129.49 43.34,129.49 46,126.82 46,124.48 46.76,123.73 46.76,123.24 47.84,122.16 48.12,122.16 49.92,122.16 50.44,121.63 55.29,121.63 56.01,120.91 56.29,120.91 57.01,120.91 58.54,119.38 60.66,119.38 60.7,119.34 61.03,119.34 62.05,118.32 62.05,117.7 62.17,117.58 62.17,117.34 v7(62.56,116.95)
  IN4 w0.066: v1(33.81,123.86) 33.81,123.98 33.93,124.1 33.93,126.13 33.5,126.56 33.5,127.78 33.28,128 33.27,128 33.11,128.15 33.11,128.16 33.07,128.21 33.07,129.53 v6(32.72,129.88) 32.72,131.13 32.52,131.32 32.52,134.37 32.36,134.53 32.36,135.34 32.68,135.67 32.68,138.97 33.91,140.2 33.91,141.95 35.55,143.59 35.55,143.95 38.49,146.89 38.49,155.21 36.77,156.93 36.77,160.72 v1(36.64,160.85) ; v1(37.27,123.22) 37.29,123.2 37.29,122.82 37.45,122.66 37.45,122.35 37.45,121.88 37.64,121.68 37.64,120.03 v1(37.9,119.78) 37.97,119.7 37.97,118.22 37.97,117.76 38.12,117.62 38.12,117.6 v5(38.35,117.36)
  BOTTOM w0.076: 21.34,119.32 21.34,118.99 21.63,118.69 21.65,118.69 21.81,118.52 21.81,118.51 21.89,118.44 21.89,118.22 21.89,118.22 21.89,118.11 22.04,117.97 22.04,117.22 22.05,117.21 22.05,117.01 22.04,117 22.04,115.88 22.21,115.72 22.52,115.72 23.04,115.2 UE3.K9 23.39,115.47 v5(23.39,115.51)
  BOTTOM w0.112: U15.1 35.13,123 34.98,123.15 34.65,123.15 34.63,123.17 34.33,123.17 34.33,123.17 33.81,123.69 v1(33.81,123.86) 33.87,123.86 34.29,124.28 34.29,124.8 34.57,125.08 35.64,125.08 36.14,124.58 36.14,123.56 36.4,123.31 37.19,123.31 v1(37.27,123.22) ; RE99.1 22.87,124.16 22.42,123.7 22.42,123.15 22.24,122.97 QE15.2 22.24,120.28 22.09,120.13 21.6,120.13 21.34,119.86 21.34,119.32 ; v1(36.64,160.85) 36.64,160.3 v2(37.35,159.59)
SIO_SLP_S4#: length 145.4
  IN2 w0.066: v4(63.06,112.84) 63.15,112.94 v3(63.15,113.17)
  IN3 w0.066: v4(63.06,112.84) 62.95,112.74 59.97,112.74 59.44,113.27 56.66,113.27 54.83,115.1 54.83,117.13 53.46,118.5 49.94,118.5 49.69,118.75 47.05,118.75 47.05,118.75 46.91,118.75 46.61,118.75 45.66,119.7 45.66,119.77 43.56,121.87 43.56,122.02 43.56,122.1 43.56,126.16 43.56,126.58 43.56,127.06 42.63,127.99 42.27,127.99 36.55,127.99 35.32,127.99 34.77,128.54 33.4,128.54 33.21,128.73 v6(32.59,128.73) ; v6(35.89,123.77) 35.3,123.77 34.52,124.55 v6(33.66,124.55) 33.66,124.14 33.03,123.52 32.08,123.52 31.89,123.71 31.07,123.71 30.98,123.79 29.59,123.79 29.11,124.26 28.97,124.26 24.19,124.26 23.98,124.47 20.15,124.47 19.78,124.1 17.29,124.1 16.71,124.68 15.16,124.68 14.76,124.27 v6(11.42,124.27) ; v6(11.5,116.06) 15.69,116.06 17.04,117.41 17.87,117.41 17.95,117.49 20.37,117.49 v5(20.64,117.22)
  IN4 w0.066: v6(33.66,124.55) 33.71,124.6 33.71,126 33.33,126.37 33.33,127.44 32.51,128.26 32.51,128.65 v6(32.59,128.73) 32.59,129.22 32.19,129.63 32.19,134.15 32.02,134.31 32.02,135.53 32.35,135.86 32.35,139.11 33.58,140.34 33.58,141.81 33.58,142.09 35.22,143.73 35.22,144.09 38.15,147.03 38.15,155.07 35.32,157.9 35.32,159.96 35.14,160.14 v1(35.14,160.85) ; v6(11.42,124.27) 11.42,116.14 v6(11.5,116.06) ; v1(37.66,109.15) 37.37,109.43 37.37,110.84 37.5,110.96 37.5,112.65 37.1,113.05 37.1,113.16 36.33,113.93 36.33,115.31 v1(36.55,115.53) 36.55,115.81 36.88,116.14 36.88,116.98 36.33,117.53 36.33,118.98 36.17,119.13 36.17,119.91 36.55,120.28 36.55,121.25 36.44,121.36 36.44,122.24 35.89,122.79 v6(35.89,123.77)
  BOTTOM w0.076: UE3.N12 20.73,117.31 v5(20.64,117.22)
  BOTTOM w0.112: UC7.1 37.53,114.89 36.88,115.53 v1(36.55,115.53)
SIO_SLP_S5#: length 115.4
  TOP w0.076: UCPU1.AY16 63.35,113.62 v3(63.35,113.53)
  IN2 w0.066: v3(63.35,113.53) 63.61,113.26 63.61,112.47 63.35,112.21 v4(63.06,112.21)
  IN3 w0.066: v6(19.66,129.33) 19.89,129.55 20.55,129.55 21.15,130.15 27.85,130.15 30.28,127.72 32.02,127.72 32.68,128.37 v6(32.78,128.37) 32.87,128.28 34.4,128.28 34.86,127.82 36.48,127.82 36.62,127.82 42.56,127.82 43.39,126.99 43.39,126.85 43.39,126.85 43.39,126.78 43.39,126.58 43.39,126.23 43.39,122.31 43.39,122.17 43.39,122.17 43.39,122.03 43.39,122.03 43.39,121.95 43.39,121.8 45.5,119.7 45.5,119.63 46.54,118.58 46.84,118.58 46.98,118.58 47.12,118.58 49.62,118.58 49.87,118.33 53.39,118.33 54.66,117.06 54.66,115.03 56.65,113.04 59.16,113.04 60,112.21 v4(63.06,112.21)
  IN4 w0.066: v6(19.66,129.33) 19.66,129.25 19.2,128.79 19.2,126.79 18.15,125.73 18.15,125.24 18.77,124.62 18.77,121.33 19.13,120.97 19.74,120.97 20.14,120.56 20.14,118.63 19.51,118 19.51,116.96 18.52,115.97 18.52,115.51 18.24,115.23 17.78,115.23 v1(17.75,115.2) ; v6(32.78,128.37) 32.9,128.5 32.9,129.19 32.36,129.73 32.36,130.65 32.35,130.66 32.35,134.26 32.19,134.42 32.19,135.45 32.51,135.78 32.51,139.04 33.74,140.27 33.74,141.88 33.74,141.88 33.74,142.02 35.38,143.66 35.38,144.02 38.32,146.96 38.32,155.14 36.45,157.01 v1(36.45,159.51)
  BOTTOM w0.076: 19.81,114.64 20.49,114.64 UE3.N8
  BOTTOM w0.112: v1(36.45,159.51) v2(36.03,159.51) 35.64,159.9 JAPS1.15 ; 19.81,114.64 19.41,114.64 18.8,115.25 17.81,115.25 v1(17.75,115.2)
SIO_SLP_SUS#: length 298.7
  TOP w0.074: v7(62.56,117.51) 62.56,117.52 62.17,117.91 UCPU1.AN15
  TOP w0.254: QE13.2 136.22,137.33 135.98,137.09 135.38,137.09 134.89,137.58 v12(134.89,137.66) PR700.1
  IN1 w0.066: v7(48.09,90.7) 48.88,90.7 50.72,92.55 51.64,93.47 51.64,100.8 55.07,104.24 55.34,104.24 55.81,104.71 55.81,107.34 56.73,108.25 56.73,110.26 57.3,110.83 57.3,112.21 58.41,113.31 58.41,113.94 59.21,114.75 60.06,114.75 60.22,114.9 60.53,114.9 61.28,115.64 61.28,115.83 62.17,116.71 62.17,117.11 v7(62.56,117.51)
  IN1 w0.254: v12(134.89,137.66) 134.89,137.82 136.3,139.23 140.43,139.23 142.82,141.62 v8(142.82,142.69)
  GND1 w0.066: v12(134.89,137.66) v4(135.25,137.66)
  IN2 w0.066: v3(51.19,149.54) 51.19,149.18 v4(51.18,149.16)
  IN3 w0.066: v6(36.14,130.14) 36.17,130.11 36.54,130.11 36.62,130.03 40.43,130.03 40.81,129.65 43.41,129.65 46.17,126.89 46.17,124.69 46.17,124.55 46.92,123.79 46.92,123.31 47.91,122.33 48.05,122.33 49.98,122.33 50.49,121.82 50.5,121.82 50.52,121.8 55.36,121.8 56.08,121.07 56.22,121.07 56.22,121.07 57.08,121.07 58.61,119.54 60.73,119.54 60.77,119.51 61.09,119.51 62.22,118.39 62.22,117.85 v7(62.56,117.51) ; v5(21.13,111.6) 22.78,111.6 23.27,111.1 25.08,111.1 26.28,109.9 27.1,109.9 27.21,109.79 28.11,109.79 28.21,109.89 28.26,109.89 28.48,109.89 28.79,109.89 31.67,112.77 34.54,112.77 35.12,113.35 38.15,113.35 v5(38.3,113.2) ; v6(41,150.41) 42.96,148.45 46.81,148.45 47,148.27 48.19,148.27 48.59,148.67 50.69,148.67 v4(51.18,149.16) ; v7(48.09,90.7) 48.39,91 53.41,91 v5(54.48,89.93)
  GND3 w0.066: v15(134.99,138.03) 135.25,137.76 v4(135.25,137.66)
  IN4 w0.066: v15(134.99,138.03) 135.25,138.29 135.25,146.45 135.4,146.6 135.4,148.47 135.42,148.48 135.42,148.7 135.4,148.71 135.25,148.87 134.47,148.87 128.75,148.87 122.11,155.51 122.11,160.97 122.11,161.25 118.04,165.32 106.95,165.32 106.46,164.83 41.43,164.83 40.17,163.56 40.17,163.34 40.17,163.34 40.17,156.66 41,155.82 v6(41,150.41) 41,149.65 40.31,148.96 40.31,145.79 39.8,145.27 39.8,144.81 37.07,142.08 37.07,136.26 36.91,136.1 36.91,132.65 36.14,131.89 v6(36.14,130.14) 36.14,130.06 36.12,130.04 36.12,129.48 36.32,129.28 36.32,125.38 37.01,124.69 37.01,122.86 37.28,122.59 37.28,122.28 37.28,121.73 37.41,121.61 37.41,118.09 37.95,117.55 37.95,113.55 v5(38.3,113.2)
  BOTTOM w0.076: v5(21.13,111.6) 20.48,111.6 19.43,110.56 19.2,110.56 18.92,110.28 18.92,109.41 RE265.1
  BOTTOM w0.112: v5(54.48,89.93) 54.16,89.93 v2(53.98,89.74) R147.1 ; v5(38.3,113.2) 37.91,112.8 UC8.1
SIO_SLP_WLAN#: length 90.9
  IN1 w0.066: v7(26.1,75.93) 26.72,75.31 30.61,75.31 32.22,76.93 40.8,76.93 42.8,78.93 43.76,78.93 46.86,82.03 46.86,83.4 47.24,83.78 47.24,85.72 52.44,90.91 57.14,90.91 63.98,97.74 63.98,98.73 63.86,98.85 63.86,112.05 v8(63.72,112.19)
  IN4 w0.066: v1(19.79,93.91) 20.18,93.52 20.18,90.28 20.01,90.12 20.01,89.86 21.1,88.77 21.1,81.89 25.41,77.59 25.41,77.28 26.1,76.59 v7(26.1,75.93)
  BOTTOM w0.112: v7(26.1,75.93) 26.1,75.94 25.13,76.9 v2(25.08,76.9) ; v1(19.79,93.91) 19.87,93.82 23.5,93.82 23.93,93.38 Q357.1
SKYCAM_I2C_CLK: length 128.6
  TOP w0.112: v7(150.62,139.47) 150.62,140.03 151.27,140.68 R478.1
  IN1 w0.066: v8(59.31,120.44) 59.31,120.43 59.09,120.21 59.09,120.11 59.15,120.05 59.81,120.05 60.67,120.91 62.03,120.91 62.22,120.72 62.97,120.72 62.99,120.74 64.95,120.74 65.08,120.61 67.23,120.61 69.14,122.51 69.14,124.32 70.75,125.94 87.64,125.94 88.21,126.51 95.45,126.51 97.17,124.79 97.35,124.79 v8(97.71,125.16) 98.03,124.84 98.76,124.84 98.96,125.05 98.96,125.85 99.54,126.43 101.37,126.43 101.55,126.61 101.55,127.93 101.96,128.34 103.99,128.34 108.18,132.52 108.84,132.52 109.38,133.06 109.38,139.97 111.49,142.08 112.38,142.08 115.13,144.83 115.13,145.46 115.01,145.59 114.78,145.59 v10(114.73,145.54)
  IN2 w0.066: v7(150.62,139.47) 150.43,139.28 150.43,136.51 150.03,136.1 143.06,136.1 140.47,138.69 130.08,138.69 129.13,137.74 125.01,137.74 124.4,138.35 124.4,144.4 121.85,146.94 120.46,146.94 118.64,148.76 117.98,148.76 117.34,148.12 117,148.12 115.09,146.21 115.09,145.84 114.79,145.54 v10(114.73,145.54)
  BOTTOM w0.112: v7(150.62,139.47) 150.43,139.28 150.43,138.85 RH25.1
SKYCAM_I2C_DATA: length 129.3
  TOP w0.112: R477.1 150.7,140.48 149.99,139.77 v7(149.99,139.47)
  IN1 w0.066: v10(114.73,145.91) 114.86,145.78 115.09,145.78 115.33,145.54 115.33,144.75 112.46,141.89 111.57,141.89 109.57,139.89 109.57,132.98 108.92,132.33 108.26,132.33 104.07,128.14 102.04,128.14 101.74,127.85 101.74,126.53 101.45,126.24 99.62,126.24 99.15,125.77 99.15,124.97 98.84,124.65 98.09,124.65 v8(97.71,124.27) 97.39,124.6 97.09,124.6 95.37,126.31 88.29,126.31 87.72,125.74 70.83,125.74 69.33,124.24 69.33,122.43 67.31,120.42 65,120.42 64.87,120.55 63.07,120.55 63.05,120.52 62.14,120.52 61.95,120.72 60.75,120.72 59.89,119.85 59.07,119.85 58.89,120.03 58.89,120.21 v8(58.66,120.44)
  IN2 w0.066: v10(114.73,145.91) 114.77,145.91 114.9,146.04 114.9,146.29 114.96,146.35 116.92,148.31 117.26,148.31 117.9,148.96 118.72,148.96 120.54,147.13 121.93,147.13 124.59,144.48 124.59,138.43 125.09,137.93 129.05,137.93 130,138.88 140.55,138.88 143.14,136.3 149.95,136.3 150.24,136.59 150.24,139.22 v7(149.99,139.47)
  BOTTOM w0.112: RH26.1 150.19,138.99 150.19,139.27 v7(149.99,139.47)
SLEEVE: length 10.7
  IN3 w1.016: 23.8,152.54 16.48,159.86 16.17,159.86
  vias: v2(15.41,158.97) v5(14.8,159.63) v5(15.13,159.63) v5(15.46,159.63) v5(24.09,151.72) v5(24.33,151.47) v5(24.36,151.89)
SLEEVE_CONN: length 18.1
  BOTTOM w1.016: 14.87,163.32 14.87,164.06 7.04,171.9 4.42,171.9 2.17,174.15 JP1.4
  vias: v2(15.25,160.81)
SLP_WLAN#_GATE: length 34.7
  IN4 w0.066: v1(22.72,116.14) 22.67,116.09 22.29,116.09 21.67,115.47 21.4,115.47 20.42,114.49 20.42,113.72 19.25,112.55 19.25,109.93 16.98,107.67 16.98,107.1 16.72,106.83 16.72,105.35 16.48,105.12 16.48,103.04 17.21,102.31 17.21,98.17 17.66,97.71 17.66,96.79 18.91,95.54 18.91,94.75 19.43,94.24 v1(19.43,94.2)
  BOTTOM w0.076: v1(22.72,116.14) 22.99,116.14 UE3.K10
  BOTTOM w0.112: R5773.2 26.31,94.31 Q357.2 21.21,94.03 21.04,94.2 v1(19.43,94.2)
SM_PG_CTRL: length 12.3
  TOP w0.112: v2(101.74,116.88) 101.66,116.96 R32.2
  TOP w0.254: UC1.4 101.66,117.91 R32.2 102.35,117.91 v8(102.74,118.3)
  IN1 w0.254: v8(102.74,118.3) 103.67,118.3 107.73,122.37 107.73,122.38 v14(108.15,122.79)
  GND1 w0.254: v4(108.55,122.79) v14(108.15,122.79)
  GND3 w0.254: v4(108.55,122.79) v13(109.09,123.33)
SM_RCOMP0: length 4
  TOP w0.254: v7(64.43,116.26) 64.3,116.26 UCPU1.AR18
  BOTTOM w0.305: RC164.1 65.79,113.78 64.92,114.64 64.92,115.11 64.89,115.15 64.89,115.84 64.62,116.11 64.58,116.11 v7(64.43,116.26)
SM_RCOMP1: length 3.1
  TOP w0.254: UCPU1.AT18 64.26,115.65 v7(64.43,115.65)
  BOTTOM w0.305: RC166.1 63.75,114.12 63.94,114.31 63.94,115.16 v7(64.43,115.65)
SM_RCOMP2: length 2.3
  TOP w0.254: v7(64.46,114.95) 64.32,114.95 UCPU1.AU18
  BOTTOM w0.305: v7(64.46,114.95) 64.46,114.43 64.77,114.11 RC165.1
SML1_SMBCLK: length 47.7
  TOP w0.112: v8(52.09,124.08) 52.02,124.14 51.7,124.14 RC55.1
  IN1 w0.066: v10(21.87,118.1) 22.07,118.3 29.36,118.3 32.98,121.92 40.59,121.92 40.62,121.96 42.77,121.96 43.19,122.38 44.71,122.38 45.08,122.74 46.49,122.74 46.93,123.18 47.5,123.18 48.18,123.86 51.87,123.86 v8(52.09,124.08) 52.2,124.19 52.88,124.19 53.19,124.5 54.72,124.5 55.19,124.98 55.29,124.98 55.33,124.96 55.37,124.85 v8(55.28,124.68)
  IN2 w0.066: v4(21.39,118.02) 21.46,118.1 v10(21.87,118.1)
  IN3 w0.066: v6(22.2,118.35) 22.2,118.32 22.02,118.14 21.51,118.14 v4(21.39,118.02)
  IN4 w0.066: v6(22.2,118.35) 22.2,118.35 22.27,118.28 22.44,118.28 22.59,118.43 25.06,118.43 26.15,117.34 26.51,117.34 27.46,116.38 v1(27.7,116.38)
  BOTTOM w0.076: UE3.D8 27.93,114.58 27.64,114.87 27.64,116.32 v1(27.7,116.38)
SML1_SMBDAT: length 44.6
  IN1 w0.066: v8(55.61,125.35) 55.52,125.17 55.42,125.14 55.36,125.17 55.11,125.17 54.64,124.69 53.1,124.69 52.81,124.4 52.02,124.4 51.68,124.05 48.17,124.05 v8(48.09,124.13) 47.99,124.03 47.99,123.94 47.42,123.37 46.85,123.37 46.41,122.94 45,122.94 44.63,122.57 43.11,122.57 42.69,122.15 40.54,122.15 40.51,122.12 32.9,122.12 29.28,118.49 v10(21.86,118.49)
  IN2 w0.066: v10(21.86,118.49) 21.37,118.49 v4(21.31,118.56)
  IN3 w0.066: v6(21.82,118.4) 21.46,118.4 v4(21.31,118.56)
  IN4 w0.066: v1(27.05,116.4) 27.05,116.52 26.43,117.15 26.07,117.15 24.98,118.24 22.67,118.24 22.52,118.09 22.09,118.09 21.82,118.36 v6(21.82,118.4)
  BOTTOM w0.076: UE3.E11 27.13,116.47 v1(27.05,116.4)
SNUB_CHG1: length 1.8
  BOTTOM w0.112: PR316.2 v2(136.14,101.86)
SNUB_CHG2: length 1.8
  BOTTOM w0.112: PR317.2 v2(125.73,119.38)
SP7_SDWP: length 2.3
  BOTTOM w0.112: UR1.29 68.76,30.4 v2(68.34,29.97) 68.2,29.83 QR1.1
SPI_CLK_VROM1: length 15.1
  IN1 w0.066: v8(50.55,106.93) 50.55,106.8 47.52,103.77 47.52,103.77 46.81,103.06 v7(46.81,102.68)
  IN3 w0.066: v5(51.49,100.61) 49.59,102.51 46.98,102.51 v7(46.81,102.68)
  BOTTOM w0.112: UH1.6 54.1,99.43 53.72,99.81 52.87,99.81 52.67,100.01 v9(52.67,100.45) 52.5,100.61 v5(51.49,100.61)
SPI_IO2_VROM1: length 25
  IN1 w0.066: v8(54.48,105.03) 54.48,104.66 50.76,100.94 50.76,100.71 50.76,97.76 47.52,94.53 47.52,91.56 v7(46.69,90.73)
  IN3 w0.066: v7(46.69,90.73) 47.21,91.25 53.73,91.25 53.85,91.12 v5(53.92,91.12)
SPI_IO3_VROM1: length 14.5
  IN1 w0.066: v10(50.08,100.75) 50.08,102 53.43,105.35 54.66,105.35 v8(54.98,105.03)
  IN2 w0.066: v10(50.08,100.75) v4(50.08,100.37)
  IN3 w0.066: v4(50.08,100.37) 50.29,100.16 v5(53.06,100.16)
  BOTTOM w0.112: UH1.7 55.37,99.86 54.86,100.37 v2(54.55,100.37) 53.27,100.37 v5(53.06,100.16)
SPI_SI_VROM1: length 16.6
  IN1 w0.066: v14(47.07,103.69) 47.07,103.96 v8(50.05,106.93)
  GND1 w0.066: v4(46.79,103.42) 47.06,103.69 v14(47.07,103.69)
  IN3 w0.066: v5(52.98,99.3) 52.48,99.3 51.81,99.97 49.62,99.97 49.31,100.28 49.31,101.26 49.03,101.54 47.25,101.54 46.43,102.36 46.43,103.06 v4(46.79,103.42)
  BOTTOM w0.112: v5(52.98,99.3) v9(50.88,99.3)
SPI_SO_VROM1: length 27.4
  IN1 w0.066: v8(53.98,105.03) 53.98,104.44 50.55,101 50.55,97.84 47.99,95.28 47.31,94.6 47.31,93.04 46.13,91.86 v7(46.13,90.73)
  IN3 w0.066: v7(46.13,90.73) 46.93,91.52 54.72,91.52 v5(55.37,90.87)
SPK_-OUT-L+: length 180.6
  IN1 w0.787: 65.21,12.96 64.83,13.34 64.83,14.1 63.42,15.51 63.42,24.1 44.57,42.95 44.57,64.34 41.23,67.68 21.82,67.68 16.77,72.73 16.77,91.67 18.23,93.13 18.23,99.79 12.26,105.75 12.26,117.24 10.45,119.05 10.45,128.21 14.12,131.88 14.12,136.82 19.75,142.44 22.14,142.44 24.12,144.43 26.54,144.43 27.23,145.11 27.23,147.44 27.64,147.84
  BOTTOM w0.127: 65.6,12.64 65.6,12.9 v2(65.43,13.07)
  vias: v7(28.73,147.82) v7(29.31,147.82) v7(65.81,12.53) v7(65.81,11.9)
SPK_-OUT-L-: length 176.8
  IN1 w0.787: 28.18,146.46 28.18,144.59 26.97,143.38 24.55,143.38 22.45,141.29 20.07,141.29 15.17,136.38 15.17,131.45 11.49,127.77 11.49,119.49 13.3,117.67 13.3,106.18 19.27,100.22 19.27,92.7 17.82,91.25 17.82,73.15 22.25,68.72 41.66,68.72 45.61,64.77 45.61,43.38 64.47,24.53 64.47,16.08 65.53,15.01
  BOTTOM w0.127: v2(65.76,14.92) 65.76,14.71 65.82,14.65 v7(65.82,14.31)
  vias: v7(28.7,147.19) v7(29.29,147.19) v7(65.82,13.68)
SPK_-OUT-R+: length 173.9
  IN1 w0.787: 66.23,17.4 66.23,17.72 65.75,18.2 65.75,25.01 46.86,43.9 46.86,65.32 42.21,69.97 22.77,69.97 19.07,73.66 19.07,90.74 20.51,92.18 20.51,100.73 14.55,106.7 14.55,118.58 15.09,119.12 15.09,120.49 14.23,121.35 13.55,121.35 12.74,122.16 12.74,127.26 16.49,131.01 16.49,135.9 20.34,139.74 23.16,139.74 25.54,142.11 27.53,142.11 29.53,144.11 29.53,145.14
  BOTTOM w0.127: v2(65.99,17.34) 66.25,17.07 v7(66.25,16.66)
  vias: v7(29.29,145.92) v7(29.87,145.92) v7(66.25,16.03)
SPK_-OUT-R-: length 170.7
  IN1 w0.787: 30.6,145.68 30.6,143.72 27.96,141.07 25.97,141.07 23.6,138.7 20.77,138.7 17.53,135.47 17.53,130.58 13.78,126.83 13.78,122.72 14.11,122.39 14.66,122.39 16.13,120.92 16.13,118.69 15.59,118.15 15.59,107.13 21.55,101.16 21.55,91.75 20.11,90.31 20.11,77.81 21.73,76.19 21.73,72.48 23.2,71.01 42.65,71.01 47.9,65.75 47.9,44.33 66.79,25.44 66.79,20.07
  vias: v2(67.28,19.38) v7(29.64,146.52) v7(30.23,146.52) v7(66.65,19.34) v7(66.65,18.71)
SPK_ID: length 128.6
  IN1 w0.066: v10(48.75,122.03) 48.92,121.86 50.93,121.86 51.44,122.37 55.12,122.37 55.55,122.8 55.55,123.99 55.83,124.27 59.21,124.27 59.64,123.84 59.64,123.59 59.87,123.36 60.98,123.36 v8(61.26,123.64)
  IN2 w0.066: v4(48.44,122.85) 48.75,122.54 v10(48.75,122.03)
  IN3 w0.066: v4(48.44,122.85) 48.49,122.9 48.74,122.9 v6(48.77,122.87)
  IN4 w0.066: v6(48.77,122.87) 48.77,122.62 51.02,120.36 51.02,118.89 51.02,118.75 51.16,118.61 51.16,117.37 51.84,116.68 51.84,115.87 52.15,115.57 52.15,115.15 52.15,115.15 52.15,110.45 52.6,110 52.6,108.98 52.93,108.65 52.93,106.67 54.5,105.1 54.5,101.67 54.77,101.4 54.77,99.44 57.08,97.13 57.08,91.85 57.51,91.42 57.51,89.53 57.25,89.27 57.25,88.91 57.49,88.67 57.49,84.6 58.93,83.16 58.93,40.6 58.88,40.56 58.88,32.83 66.97,24.74 v7(69.13,24.74)
  BOTTOM w0.112: v7(69.13,24.74) 69.13,23.99 68.91,23.78 v2(68.91,23.29) RA38.2 RA39.2
SPK_L+: length 12.4
  IN2 w0.762: 79.44,5.11 79.44,5.12 71.54,13.02 70.99,13.02
  BOTTOM w0.127: v7(80.37,4.4) v2(80.37,3.71)
  vias: v7(69.82,13.18) v7(69.82,12.6) v7(79.95,4.78)
SPK_L-: length 15.4
  IN2 w0.762: 81.27,4.73 71.78,14.21 70.62,14.21
  BOTTOM w0.127: v2(81.71,4.87) 81.55,4.7 v7(81.55,4.13)
  vias: v7(69.84,14.5) v7(69.84,13.92) v7(81.55,3.54)
SPK_R+: length 16.9
  IN2 w0.762: 70.99,16.19 71.52,16.19 82.63,5.09 82.63,5.07
  BOTTOM w0.127: v7(82.54,3.57) 82.54,3.42 v2(82.18,3.06)
  vias: v7(69.98,16.46) v7(69.98,15.88) v7(82.54,4.15)
SPK_R-: length 19.8
  IN2 w0.762: 70.68,17.78 71.37,17.78 83.65,5.5 83.65,4.89
  BOTTOM w0.127: CA42.1 69.04,19.19 v2(69.23,19.38)
  vias: v7(69.91,18.05) v7(69.91,17.46) v7(83.39,4.19) v7(83.39,3.61)
SPKR: length 73.5
  IN1 w0.066: v8(56.51,114.6) 56.51,115.89 55.94,116.46 55.3,116.46 54.67,115.83 53.8,115.83 53,115.03 v10(53,114.68)
  IN2 w0.066: v10(53,114.68) v4(53,115.06)
  IN3 w0.066: v6(22.23,129.88) 27.84,129.88 30.17,127.55 32.12,127.55 32.54,127.97 34.48,127.97 34.79,127.65 36.41,127.65 36.68,127.65 36.69,127.65 37.48,127.65 37.93,127.21 39.92,127.21 40.04,127.32 41.84,127.32 41.88,127.36 42.54,127.36 43.06,126.85 43.06,124.92 43.06,123.46 43.06,122.45 43.06,122.31 43.06,121.9 43.06,121.89 43.06,121.81 43.06,121.66 45.16,119.56 45.16,119.49 46.82,117.83 49.48,117.83 50.84,116.47 v5(51.38,116.47) 52.78,115.06 v4(53,115.06)
  IN4 w0.066: v6(22.23,129.88) 22.3,129.96 22.3,137.99 23.45,139.14 23.45,140.08 24.16,140.78 24.16,143.45 24.2,143.49 24.2,143.79 25.22,144.8 26.74,144.8 27.02,145.09 27.02,151.51 v1(27.24,151.73)
  BOTTOM w0.112: v5(51.38,116.47) 51.38,116.46 RC158.2 51.98,115.89 v2(52.45,115.42)
SRTCRST#: length 17.8
  TOP w0.102: v7(64.41,117.52) 64.02,117.91 UCPU1.AN18
  TOP w0.112: CC22.1 64.15,105.18 RC85.2 65.21,105.42 65.58,105.42 v7(65.66,105.35)
  IN4 w0.066: v7(65.66,105.35) 65.59,105.42 65.59,106.45 63.63,108.41 63.63,111.83 64.02,112.21 64.02,113.48 64.9,114.37 64.9,117.03 64.41,117.52 v7(64.41,117.52)
  BOTTOM w0.112: v2(67.17,104.59) 66.41,105.35 v7(65.66,105.35)
SS_1.8VA: length 2.8
  TOP w0.112: v2(137.4,138.53) 137.5,138.43 PC726.1
  TOP w0.254: PC726.1 138.33,138.88 138.28,138.93 PU720.9
SS_1.8VU: length 3
  TOP w0.254: PU721.9 108.99,98.31 109.17,98.49 109.98,98.49 110.36,98.11 PC734.1
SS_PRIM: length 1.6
  TOP w0.254: PU801.7 49.78,142.13 PC819.1
SS_VCCIO: length 2.6
  TOP w0.112: PC809.1 v2(124.98,124.6)
  TOP w0.254: PC809.1 123.83,125.22 124.03,125.43 PU800.7
SSD_DEVSLP: length 75.6
  TOP w0.112: v3(53.31,130.07) 53.4,129.99 UCPU1.J1 ; JNGFF2.38 55.25,73.72 55.63,73.34 58,73.34 v7(58.02,73.33)
  IN2 w0.066: v4(52.88,129.36) 52.88,129.64 v3(53.31,130.07)
  IN3 w0.066: v4(52.88,129.36) 53.3,128.95 53.31,128.95 53.39,128.88 v6(53.53,128.88)
  IN4 w0.066: v6(53.53,128.88) 53.53,128.38 52.49,127.34 49.53,127.34 49.12,126.93 48.86,126.93 48.17,126.24 48.17,122.98 50.86,120.3 50.86,118.96 50.86,118.68 50.99,118.54 50.99,117.3 51.67,116.61 51.67,115.8 51.98,115.5 51.98,115.22 51.98,110.36 52.43,109.91 52.43,108.9 52.73,108.6 52.73,106.49 53.99,105.23 53.99,98.19 54.2,97.99 54.2,97.99 54.62,97.57 54.62,95.5 55.76,94.36 55.76,94.08 55.76,91.73 56.46,91.03 56.46,84.17 57.6,83.03 57.6,73.74 v7(58.02,73.33)
  BOTTOM w0.112: T32.1 58.13,73.22 v7(58.02,73.33)
SSD_PEDET: length 9.4
  TOP w0.112: R66.2 58.75,88.08 62.27,88.08 62.55,87.8 62.55,84.02 63,83.57 JNGFF2.69
SSD_PWR_EN: length 61.4
  TOP w0.076: UCPU1.W12 60.61,124.72 v3(60.35,124.98)
  IN2 w0.066: v4(60.2,125.29) 60.2,125.13 v3(60.35,124.98)
  IN3 w0.066: v6(51.05,125.44) 51.16,125.54 54.74,125.54 55.24,126.05 59.19,126.05 59.95,125.29 v4(60.2,125.29)
  IN4 w0.066: v6(51.05,125.44) 50.95,125.34 50.55,125.34 49.53,124.32 49.53,123.87 49.69,123.7 50.25,123.7 52.43,121.52 52.43,119.06 52.88,118.61 52.88,116.32 53.23,115.97 53.23,113.49 53.25,113.47 53.25,113.36 53.26,113.34 53.26,113.3 53.9,112.66 53.9,112.26 53.7,112.05 53.7,110.86 54.87,109.69 54.87,106.5 55.61,105.76 55.61,101.99 55.78,101.82 55.78,99.86 58.09,97.54 58.09,92.27 59.1,91.26 59.1,90.5 58.84,90.23 58.84,88.35 59.32,87.86 59.32,86.56 58.8,86.04 v1(58.8,85.46)
  BOTTOM w0.112: v1(58.8,85.46) 55.49,85.46 54.85,86.09 R151.2 54.43,86.11 54.42,86.09 R150.1
STROBE_IN: length 4.5
  IN4 w0.066: v1(151.55,142.76) 152.45,141.86 152.45,140.93 153.49,139.89 v1(154.36,139.89)
SUS_ON_EC: length 310.2
  TOP w0.112: v7(132.84,88.43) 133.25,88.84 v2(133.25,88.9) JIO1.25
  GND1 w0.066: v12(111.84,123.64) 111.84,123.74 v4(111.63,123.94)
  IN2 w0.066: v4(109.32,126.53) 109.32,126.68 109.58,126.94 113.68,126.94 115.78,124.84 123.46,124.84 124.74,126.12 128.47,126.12 128.9,126.55 128.9,128.67 129.37,129.14 131.27,129.14 131.64,128.77 134.81,128.77 134.87,128.71 v4(134.87,128) 134.87,123.19 141.8,116.27 152.3,116.27 154.14,114.43 154.14,106.79 155.96,104.97 155.96,94.24 149.4,87.68 133.59,87.68 v7(132.84,88.43)
  IN3 w0.066: v4(111.63,123.94) 111.52,124.06 109.78,124.06 109.09,124.74 109.09,126.3 v4(109.32,126.53) ; v4(134.87,128) 134.91,128.04 135.74,128.04 v6(136.02,127.76) ; v6(35.94,124.12) 35.41,124.12 34.65,124.88 31.69,124.88 31.66,124.91 31.44,124.91 v5(31.34,125.01)
  IN4 w0.066: v1(37.66,110.06) 37.67,110.07 37.67,112.71 37.26,113.12 37.26,113.23 36.7,113.8 v1(36.7,114.92) 36.7,115.32 36.81,115.42 36.81,115.57 36.83,115.58 36.83,115.85 37.05,116.07 37.05,117.05 36.53,117.57 36.53,119.11 36.37,119.27 36.37,119.86 36.72,120.21 36.72,121.18 36.72,121.18 36.72,121.32 36.61,121.43 36.61,122.31 36.16,122.76 36.16,123.9 v6(35.94,124.12) 35.94,124.78 35.51,125.21 35.51,127.85 35.51,127.85 35.49,127.85 35.18,128.17 35.18,128.18 34.91,128.45 34.91,131.37 36.4,132.86 36.4,136.31 36.56,136.47 36.56,142.29 39.18,144.91 39.18,145.43 39.81,146.06 39.81,146.71 39.81,149.17 39.99,149.35 39.99,156.01 39.66,156.34 39.66,163.13 39.66,163.77 41.22,165.33 106.25,165.33 106.74,165.82 118.25,165.82 122.61,161.46 122.61,160.76 122.61,155.73 128.97,149.37 135.04,149.37 135.46,149.37 135.92,148.91 135.92,148.27 135.92,148.27 135.92,146.24 135.8,146.12 135.8,132.98 135.59,132.77 135.59,132.37 135.94,132.02 135.94,131.59 135.79,131.43 135.79,128 136.02,127.78 v6(136.02,127.76)
  BOTTOM w0.112: RE36.2 35.1,115.38 36.25,115.38 v1(36.7,114.92) 36.7,114.8 37.26,114.24 UC7.2 ; U4245.1 31.26,124.92 v5(31.34,125.01) ; RE98.2 v1(37.66,110.06)
SUS_ON_EC_R: length 20.7
  IN3 w0.066: v5(30.3,106.66) 29.93,106.29 29.08,106.29 28.83,106.03 28.83,105.56 29.58,104.81 30.75,104.81 31.38,104.17 32.18,104.17 32.31,104.31 32.81,104.31 33.53,105.03 33.84,105.03 34.49,105.68 37.34,105.68 v6(37.39,105.63)
  IN4 w0.066: v6(37.39,105.63) 37.28,105.73 37.28,108.49 36.77,109.01 v1(36.77,109.15)
  BOTTOM w0.076: 30.3,107.33 30.3,107.56 29.59,108.27 29.44,108.27 29.03,108.68 29.03,109.7 28.85,109.89 28.61,109.89 28.32,109.6 UE3.D2
  BOTTOM w0.112: 30.3,107.33 v5(30.3,106.66)
SUS_ON_P: length 208.4
  TOP w0.112: v8(134.68,133.84) 137.04,133.84 138.47,135.27 138.47,136.02 138.72,136.27 139.19,136.27 v2(139.86,135.61) 140.53,134.94 142.75,134.94 143.51,135.7 143.51,141.54 143.26,141.8 PR720.1
  IN1 w0.254: v3(105.36,98.36) 104.78,98.95 104.78,100.85 105.46,101.54 109.66,101.54 110.17,102.05 112.78,102.05 115.27,99.56 115.27,98.03 115.76,97.54 129.88,97.54 130.78,96.64 142.17,96.64 143.46,97.93 143.46,115.75 145.22,117.51 145.22,119.1 147.13,121.01 147.13,121.63 145.44,123.32 142.75,123.32 138.58,127.49 138.58,129.94 v8(134.68,133.84)
  IN2 w0.066: v3(105.36,98.36) 105.23,98.24 105.23,94.4 106.13,93.5 106.13,91.37 102.39,87.62 93.8,87.62 93.51,87.91 81.55,87.91 79.75,86.11 79.02,86.11 v4(78.89,85.98)
  IN3 w0.066: v4(78.89,85.98) 78.89,86.01 78.48,86.43 74.07,86.43 72.77,87.72 68.99,87.72 67.06,89.65 64.82,89.65 63.66,90.8 58.78,90.8 56.51,93.07 51.24,93.07 49.45,94.86 46.2,94.86 41.55,99.51 v6(40.01,99.51)
  IN4 w0.066: v1(38.18,111.85) 38.36,111.67 38.36,108.52 38.53,108.35 38.53,106.66 38.63,106.56 38.63,100.98 40.01,99.61 v6(40.01,99.51)
  BOTTOM w0.112: RE44.1 35.31,113.43 35.47,113.59 UC7.4 ; RE44.1 35.43,112.92 35.43,112.18 35.66,111.95 37.21,111.95 37.4,111.76 UC8.2 ; RE44.1 RE36.1
SUSACK#: length 64.7
  TOP w0.076: UCPU1.AP11 60.38,117.26 v7(60.73,116.91)
  IN3 w0.066: v7(60.73,116.91) 60.33,117.32 60.33,117.48 60.21,117.59 60.21,117.69 60,117.9 59.9,117.9 59.46,118.35 59.46,118.37 59.15,118.68 58.28,118.68 56.73,120.23 56.57,120.23 56.57,120.23 55.74,120.23 55.63,120.34 51.2,120.34 50.78,120.34 49.64,121.49 47.03,121.49 46.23,122.28 46.23,122.41 44.28,124.37 44.28,127.29 42.51,129.06 36.56,129.06 36.01,129.61 30.19,129.61 29.14,130.66 20.38,130.66 v6(19.94,130.21)
  IN4 w0.066: v6(19.94,130.21) 19.94,128.51 19.43,128 19.43,126.68 18.73,125.98 18.73,125.04 18.95,124.82 18.95,121.4 19.21,121.14 20.24,121.14 v1(21.83,119.55)
  BOTTOM w0.112: v1(21.83,119.55) 22.12,119.26 22.12,119.17 22.44,118.85 22.66,118.63 22.66,118.07 UE3.K12
SUSCLK: length 152.5
  TOP w0.112: R65.2 62.05,86.58 v8(62.08,86.6)
  IN1 w0.066: v10(32.44,75.12) 32.89,74.68 44.37,74.68 49.24,79.55 49.24,84.72 52.62,88.1 53.68,88.1 54.14,88.57 59.69,88.57 61.66,86.6 v8(62.08,86.6) 62.14,86.67 62.14,87.02 61.62,87.54 61.62,92.39 64.59,95.36 v10(64.59,95.62) ; v8(63.72,112.85) 63.23,112.35 63.23,111.09 63.12,110.98 63.12,108.98 v3(62.99,108.85)
  IN2 w0.066: v10(64.59,95.62) 64.01,96.2 64.01,96.61 63.81,96.81 63.81,103.65 62.53,104.93 62.53,108.39 v3(62.99,108.85) ; v4(26.44,67.71) 26.81,67.71 32.44,73.34 v10(32.44,75.12) 32.03,75.54 31.9,75.54 31.01,76.43 31.01,83.18 32,84.18 32,88.33 31.78,88.56 31.78,89.37 31.71,89.44 31.71,90.35 31.73,90.38 31.73,96.96 31.39,97.3 31.39,99.24 30.25,100.38 30.25,106.79 29.22,107.83 29.22,114.47 29.09,114.59 29.09,122.64 30.3,123.85 v4(30.3,124.83)
  IN3 w0.066: v4(30.3,124.83) 30,124.83 29.17,125.66 27.19,125.66 27.01,125.85 19.38,125.85 19.06,126.17 18.59,126.17 17.65,125.23 v5(17.65,125.12) ; v5(20.19,68.34) 20.27,68.26 22.64,68.26 23.52,67.38 26.11,67.38 v4(26.44,67.71)
SUSCLK_L: length 6.3
  TOP w0.112: JNGFF1.68 16.13,123.13 16.84,123.84 v3(17.08,123.84)
  IN2 w0.066: v3(17.08,123.84) 17.08,123.95 v4(18.85,125.72)
  IN3 w0.066: v4(18.85,125.72) 18.77,125.72 v5(18.41,125.36)
  BOTTOM w0.112: v5(18.41,125.36) 18.07,125.71 R124.1
SW_1.8VA: length 0.6
  BOTTOM w0.112: v7(140.08,144.78) v2(140.08,145.42)
  vias: v7(139.7,144.34)
SW_DP2_HPD_UV1: length 3.3
  BOTTOM w0.112: RV11.2 16.97,38.95 18.82,38.95 19.07,39.2 UV1.32
SX9306_CS0: length 2.8
  BOTTOM w0.112: U1.A3 116.18,158.83 115.73,159.28 T2.1 116.32,160.29 LS1.2
SYNC: length 56.1
  IN1 w0.066: v8(94.65,157.86) 94.52,157.99 92.5,157.99 90.14,160.35 87.47,160.35 85.94,161.89 82.78,161.89 82.27,161.38 82.27,160.77 82.08,160.58 v8(81.74,160.58) 81.51,160.34 80.44,160.34 80.09,160 79.04,160 78.83,160.21 73.85,160.21 72.13,161.93 65.8,161.93 65.38,161.51 65.38,160.75 65.24,160.61 v8(65.11,160.61) 64.85,160.35 64.09,160.35 63.78,160.67 63.74,160.67 63.74,160.67 63.6,160.67 62.66,160.67 61.6,159.62 56.45,159.62 55.33,158.5 55.33,157.21 v8(55.19,157.08) 54.69,156.57 54.69,154.22 54.86,154.04 54.86,153.15 v10(56.67,151.35)
  IN2 w0.066: v10(56.67,151.35) v4(59.08,151.35)
  IN3 w0.066: v4(59.08,151.35) 59.31,151.12 v5(59.36,151.12)
SYS_PRES#: length 29.3
  TOP w0.112: v2(146.16,120.68) 146.16,120.51 145.68,120.03 PR285.1
  TOP w0.254: PR285.1 146.37,119.64 146.42,119.69 v8(147.18,119.69)
  IN1 w0.254: v8(147.18,119.69) 147.17,119.69 146.23,118.74 146.23,105.35 144.84,103.97 144.84,94.83 v3(145.33,94.34)
SYS_PWROK: length 288.7
  TOP w0.076: v3(54.66,135.65) 55.31,135.01 55.31,134.59 56.05,133.85 UCPU1.B6
  IN2 w0.066: v4(24.69,108.07) 24.71,108.07 25.41,107.37 v3(25.53,107.37) ; v3(54.66,135.65) 54.62,135.65 53.27,137.01 53.27,137.6 v4(53.28,137.61)
  IN3 w0.066: v6(17.91,137.1) 18.8,136.21 24.14,136.21 25.17,135.19 28.52,135.19 29.83,136.49 30.03,136.49 32.62,139.07 33.06,139.51 33.28,139.74 35.31,139.74 35.31,139.74 36.25,139.74 36.64,139.35 41.03,139.35 41.04,139.36 42.24,139.36 43.05,140.18 51.04,140.18 53.28,137.94 v4(53.28,137.61) ; v5(25.73,107.91) 25.35,107.91 25.2,108.07 v4(24.69,108.07) 24.34,108.42 24.22,108.42 23.97,108.67 22.67,108.67 22.18,109.16 21.11,109.16 19.88,110.39 15.09,110.39 13.24,112.24 v6(13.07,112.24)
  IN4 w0.066: v6(13.07,112.24) 13.1,112.27 13.1,118.17 12.54,118.73 12.54,131.73 v6(17.91,137.1) 19.37,138.56 19.37,143.07 21.59,145.29 21.59,149.6 22.25,150.26 23.51,150.26 25.59,152.34 25.59,153.78 27.52,155.72 27.52,161.51 31.69,165.68 36.63,165.68 38.15,167.2 106.02,167.2 106.13,167.3 108.71,167.3 109.18,167.77 109.18,175.01 111.14,176.98 123.24,176.98 127.65,172.57 127.65,170.4 126.1,168.85 126.1,154.83 129.66,151.27 136.26,151.27 140.01,151.27 142.65,148.63 142.65,143.55 143.64,142.56 143.64,140.46 145.4,138.7 v1(145.63,138.7)
  BOTTOM w0.076: UE3.G4 25.76,110.97 25.76,110.58 25.81,110.52 25.81,108.07
  BOTTOM w0.112: RC99.1 149.22,136.12 148.82,136.53 146.02,136.53 145.21,137.34 v9(145.21,137.96) 145.21,138.28 v1(145.63,138.7) ; 25.81,108.07 25.73,107.99 v5(25.73,107.91)
SYS_RESET#: length 72.7
  TOP w0.112: RC38.2 51.84,137.02 52.91,135.96 54.88,135.96 55.89,134.95 55.89,134.53 UCPU1.B5 ; RC38.2 RC36.2 ; RC38.2 50.75,135.45 v8(49.91,134.61)
  IN1 w0.066: v8(49.91,134.61) 49.37,134.61 47.2,136.77 44.19,136.77 42.61,135.19 38.61,135.19 31.75,128.34 v10(31.75,128.13)
  IN2 w0.066: v4(31.39,128.11) 31.72,128.11 v10(31.75,128.13)
  IN3 w0.066: v6(31.65,128.56) 31.65,128.36 v4(31.39,128.11)
  IN4 w0.066: v6(31.65,128.56) 31.4,128.81 31.4,129.98 31.33,130.06 31.33,139.2 32.79,140.66 32.79,142.54 33.71,143.46 33.73,143.46 34.6,144.33 34.6,144.35 37.54,147.28 37.54,154.58 34.54,157.58 34.54,158.17 33.13,159.58 32.91,159.58 32.9,159.58 v1(32.38,159.58)
  BOTTOM w0.112: JAPS1.6 31.14,160.33 31.61,159.86 31.61,159.73 v2(31.74,159.6) 31.76,159.58 v1(32.38,159.58)
SYS_RESET#_R: length 3.1
  TOP w0.112: RC36.1 49.83,138.39 v12(49.89,138.44)
  GND1 w0.066: v4(49.58,138.62) 49.66,138.55 49.78,138.55 v12(49.89,138.44)
  GND3 w0.066: v13(49.66,139.13) 49.66,138.7 v4(49.58,138.62)
  BOTTOM w0.112: v13(49.66,139.13) 49.55,139.13 49.37,138.95 UC3.4
SYSPWR_PRES: length 3.8
  BOTTOM w0.076: 30.4,108.02 30.18,108.23 30.1,108.23 UE3.B1
  BOTTOM w0.112: 30.4,108.02 31.11,107.3 RE154.1 RE152.1
TACH_FAN1: length 221.6
  TOP w0.112: v7(157.36,132.65) 154.45,132.65 D22.2 ; v2(154.64,139.13) 154.51,139.26 153.91,139.26 v8(153.67,139.5)
  IN1 w0.066: v7(157.36,132.65) 156.34,132.65 154.22,134.77 154.22,137.4 153.95,137.67 153.95,139.22 v8(153.67,139.5)
  IN2 w0.066: v4(79.38,83.22) 80.11,83.22 80.73,83.84 80.73,85.03 81.39,85.68 82.6,86.9 92.48,86.9 95.37,86.21 95.67,86.13 95.85,86.07 111.35,86.07 116.94,91.65 120.69,91.65 124.82,87.52 149.47,87.52 158.9,96.95 158.9,103.93 157.02,105.81 157.02,112.79 159.88,115.65 159.88,130.03 157.36,132.55 v7(157.36,132.65)
  IN3 w0.066: v5(26.92,110.83) 27.95,111.86 28.5,111.86 28.62,111.74 28.91,111.74 29.34,112.17 29.34,112.39 30.56,113.61 32.78,113.61 33.02,113.85 33.49,113.85 33.6,113.96 34.06,114.42 34.19,114.42 35.48,114.42 35.8,114.74 38.66,114.74 39.83,113.58 39.83,112.63 44.4,108.06 45.5,108.06 45.98,107.57 50.74,107.57 53.42,104.89 53.61,104.89 57.72,100.78 59.69,100.78 61.91,98.56 v6(62.48,98.56) ; v4(79.38,83.22) 79.38,82.81 78.5,81.93 71.52,81.93 v6(71.5,81.92)
  IN4 w0.066: v6(71.5,81.92) 70.25,80.66 70.04,80.66 69.21,79.83 67.05,79.83 65.6,81.29 65.6,82.75 63.82,84.54 63.82,88.95 63.82,89.09 63.16,89.75 63.16,90.94 63.13,90.97 63.13,98.06 62.95,98.24 62.8,98.24 v6(62.48,98.56)
  BOTTOM w0.076: UE3.E3 26.92,110.61 v5(26.92,110.83)
TBAT_3V3: length 14.8
  TOP w0.508: PR157.1 139.65,105.03 139.21,104.59 139.21,103.64 v7(139.67,103.18)
  IN2 w0.508: v7(139.67,103.18) 141.29,103.18 146.34,98.13 146.34,96.6 v3(145.33,95.59)
  BOTTOM w0.112: v7(139.67,103.18) v2(139.67,103.79)
TCLK_XDP: length 79.3
  TOP w0.076: UCPU1.B61 88.16,134.17 87.9,134.43 87.63,134.43 UCPU1.A59 87.73,135.31 87.73,135.98 v3(87.68,136.03)
  TOP w0.112: v9(85.65,142) 86.11,141.54 RC3.1 86.56,140.41 86.56,136.72 86.92,136.36 87.36,136.36 v3(87.68,136.03)
  IN2 w0.066: v3(87.68,136.03) 87.86,136.21 88.21,136.21 88.39,136.38 97.28,136.38 98.42,137.53 112.9,137.53 116.54,133.89 124.6,133.89 124.79,133.69 130.32,133.69 130.8,134.17 132.43,134.17 133.11,133.5 146.74,133.5 146.82,133.58 150.13,133.58 v4(150.24,133.47)
  IN3 w0.066: v5(150.19,134.05) 150.19,133.52 v4(150.24,133.47)
  BOTTOM w0.112: JXDP1.57 151.24,135.1 v5(150.19,134.05)
TDI_XDP: length 90.1
  TOP w0.074: UCPU1.D59 87.56,133.2 UCPU1.D60
  TOP w0.076: UCPU1.D59 87.09,133.02 87.09,133.1 87.02,133.2 86.95,133.46 86.95,133.58 86.81,134.06 86.81,134.31 86.84,134.4 86.84,134.44 86.85,134.44 86.85,135.03 87.12,135.31 87.12,135.38 87.21,135.46 v3(87.21,135.49)
  TOP w0.112: v2(84.06,141.31) 84.52,140.86 RC2.2 85.56,140.39 85.56,137.68 85.35,137.48 85.35,136.54 85.92,135.98 86.92,135.98 87.1,135.8 87.1,135.59 v3(87.21,135.49)
  IN2 w0.066: v7(157.36,134.62) 155.39,132.66 147.01,132.66 146.55,133.11 132.91,133.11 132.24,133.79 130.96,133.79 130.48,133.31 124.63,133.31 124.44,133.5 116.38,133.5 115.24,134.64 113.54,134.64 110.91,132.01 106.39,132.01 105.59,131.21 101.82,131.21 99.96,133.07 99.96,134.96 98.92,136 88.61,136 88.11,135.49 v3(87.21,135.49)
  BOTTOM w0.112: JXDP1.56 157.17,134.8 v7(157.36,134.62)
TDO_XDP: length 85.1
  TOP w0.076: UCPU1.A61 88.08,134.82 v3(88.01,134.89) 87.93,134.97 87.93,135.15 87.96,135.18 87.96,136.13 87.68,136.41
  TOP w0.112: 87.68,136.41 87.27,136.82 87.06,136.82 86.92,136.96 v2(86.92,137.09) 86.92,137.96 RC19.2
  IN1 w0.066: v8(85.89,134.82) 87.95,134.82 v3(88.01,134.89)
  IN2 w0.066: v3(88.01,134.89) 88.23,134.67 93.34,134.67 94.09,135.42 98.67,135.42 99.32,134.76 99.32,132.81 101.52,130.62 106.81,130.62 107.6,131.4 112.61,131.4 113.33,132.12 113.33,133.69 113.89,134.25 115.08,134.25 116.38,132.96 122.47,132.96 122.92,132.5 123.57,132.5 123.99,132.92 130.92,132.92 131.19,132.65 140.42,132.65 140.99,132.08 145.37,132.08 145.72,131.73 147.43,131.73 147.79,132.08 156.22,132.08 v7(157.36,133.22)
  BOTTOM w0.112: JXDP1.52 156.97,133.6 v7(157.36,133.22)
THERMATRIP1#: length 3.7
  BOTTOM w0.076: 30.28,119.32 30.04,119.08 30.04,118.12 UE3.B12
  BOTTOM w0.112: 30.28,119.32 31.14,120.18 RE246.1
THERMATRIP2#: length 23.5
  IN3 w0.066: v5(25.05,110.73) 25.03,110.73 24.82,110.94 23.2,110.94 22.71,111.43 21.33,111.43 21.23,111.34 21.02,111.34 20.86,111.49 20.86,112.47 22.28,113.89 22.28,114.22 22.13,114.37 21.95,114.37 20.51,115.81 19.41,115.81 v6(18.67,116.55)
  IN4 w0.066: v1(18.49,121.99) 18.49,121.35 19.07,120.77 19.6,120.77 19.91,120.46 19.91,118.9 19.24,118.23 19.24,117.12 v6(18.67,116.55)
  BOTTOM w0.076: UE3.H3 v5(25.05,110.73)
  BOTTOM w0.112: QE16.1 18.22,123.32 RE215.2 CE86.1 18.94,122.43 v1(18.49,121.99)
TMS_XDP: length 85.3
  TOP w0.074: UCPU1.C60 87.48,133.52 UCPU1.C59
  TOP w0.076: UCPU1.C59 87.13,133.63 87.13,133.7 87.06,133.83 86.97,134.08 86.97,134.26 87,134.34 87,134.97 87.14,135.11 87.31,135.11 87.55,135.35 87.55,135.66 v3(87.4,135.8) 87.04,136.17
  TOP w0.112: RC18.2 86.11,137.81 85.7,137.4 v2(85.7,136.63) 85.81,136.51 86.07,136.51 86.41,136.17 87.04,136.17
  IN2 w0.066: v7(157.36,135.38) 154.82,132.85 147.09,132.85 146.63,133.31 133.03,133.31 132.35,133.98 130.88,133.98 130.4,133.5 124.71,133.5 124.52,133.69 116.46,133.69 115.32,134.83 113.43,134.83 110.83,132.23 106.09,132.23 105.54,131.68 105.54,131.67 105.29,131.41 101.93,131.41 100.16,133.18 100.16,135.04 99.01,136.19 88.53,136.19 88.1,135.75 87.45,135.75 v3(87.4,135.8)
  BOTTOM w0.112: JXDP1.58 157.34,135.4 v7(157.36,135.38)
TOUCH_SCREEN_PD#: length 154.6
  TOP w0.112: v3(55.37,138.04) 57.5,135.91 UCPU1.A7
  IN2 w0.066: v4(55.8,138.04) v3(55.37,138.04)
  IN3 w0.066: v6(52.54,133.4) 53.57,134.43 53.57,135.67 55.8,137.9 v4(55.8,138.04)
  IN4 w0.066: v7(76.12,22.49) 76.12,19.1 74.61,17.59 71.37,17.59 69.55,19.41 69.55,20.98 56.29,34.25 56.29,45.38 56.67,45.76 56.67,50.05 55.16,51.56 55.16,61.89 55.65,62.39 55.65,82.46 53.54,84.58 53.54,88.18 53.16,88.56 53.16,89.95 51.3,91.82 51.3,100.33 50.92,100.71 50.92,104.87 49.4,106.39 49.4,108.9 50.06,109.57 50.06,114.84 49.38,115.53 49.38,116.14 48.05,117.46 48.05,117.69 48.05,117.69 48.05,117.83 48.05,117.97 48.05,118.97 47.46,119.56 47.46,120.51 47.28,120.69 46.49,120.69 46.14,121.04 46.14,121.37 45.56,121.95 45.56,123.35 45.26,123.65 45.26,126.02 45.66,126.42 45.66,128.18 50.4,132.91 52.06,132.91 v6(52.54,133.4)
  BOTTOM w0.112: v2(78.13,23.78) 77.79,23.43 R419.1 76.4,22.77 v7(76.12,22.49)
TOUCH_SCREEN_PD#_R: length 6.6
  IN1 w0.066: v8(85.1,23.2) 84.84,23.2 84.84,23.2 79.91,23.2 v7(79.48,22.77)
  BOTTOM w0.112: R419.2 v7(79.48,22.77)
TPM_DET: length 27.2
  TOP w0.112: v8(43.08,127.25) 43.97,126.35 43.97,124.68 44.93,123.71 44.93,123.2 45.06,123.07 45.97,123.07 v2(46.14,122.9) 46.67,122.37 47.4,122.37 47.61,122.15 47.61,120.83 47.92,120.52 RH11.2 RH14.1
  IN1 w0.066: v8(56.64,130.15) 55.76,130.15 55.37,129.76 55.37,129.19 54.81,128.63 54.47,128.63 ; 53.85,128.17 52.8,127.13 47.52,127.13 46.2,128.45 44.28,128.45 v8(43.08,127.25)
  IN1 w0.076: 54.47,128.63 54.3,128.63 53.85,128.17
TPM_LPM: length 3.9
  BOTTOM w0.112: U4246.3 38.52,96.23 39.45,97.16 R460.2 v2(39.79,99.02)
TPM_PIRQ#: length 79.7
  TOP w0.112: RC399.1 45.85,124.13 46.22,123.76 v8(46.44,123.76) RC198.1 46.44,124.41 46.84,124.81 v3(47.46,124.81) ; RC398.1 50.05,115.41 49.3,116.16 v12(49.21,116.16)
  IN1 w0.066: v8(46.44,123.76) 46.39,123.76 46.28,123.87 45.12,123.87 44.55,123.31 v8(44.48,123.31)
  GND1 w0.066: v12(49.21,116.16) 48.42,116.16 v4(48.34,116.23)
  IN2 w0.066: v3(47.46,124.81) 47.68,124.6 v4(47.68,124.47)
  IN3 w0.066: v6(51.56,84.39) 50.65,85.3 45.48,85.3 41.71,89.07 v5(41.43,89.07) ; v4(47.68,124.47) 47.57,124.47 47.24,124.81 47.24,127.67 45.81,129.1 v6(45.81,129.64)
  GND3 w0.066: v4(48.34,116.23) 48.35,116.22 48.54,116.22 v15(48.65,116.33)
  IN4 w0.066: v6(51.56,84.39) 51.62,84.39 52.08,84.86 52.08,90.46 51.11,91.44 51.11,100.25 50.73,100.63 50.73,104.68 49.17,106.24 49.17,108.95 49.87,109.65 49.87,114.76 49.18,115.45 49.18,115.8 v15(48.65,116.33) 48.65,116.57 47.48,117.74 47.48,118.48 44.49,121.47 44.49,128.32 v6(45.81,129.64)
  BOTTOM w0.112: R439.2 42.89,89.31 v2(42.19,89.31) 41.95,89.07 v5(41.43,89.07) 41.43,89.3 40.52,90.21 U4246.18
TPM_PIRQ#_R: length 9.3
  TOP w0.076: 52.45,116.04 53.41,116.04 53.69,116.32 54.62,116.32 54.78,116.48 55.5,116.48 55.64,116.63 55.64,116.85 55.84,117.06 56.34,117.06 56.43,116.97 56.74,116.97 56.96,117.18 57.24,117.18 57.48,116.94 57.8,116.94 58.12,117.26 UCPU1.AP8
  TOP w0.112: 52.45,116.04 50.13,116.04 RC398.2
TRST#_XDP: length 83.3
  TOP w0.076: UCPU1.B59 87.94,134.17 88.07,134.04 88.07,133.82 UCPU1.C61 88.77,133.93 88.77,135.08 v3(88.56,135.29)
  TOP w0.112: v7(157.36,133.8) 155.4,133.8 v2(155.14,133.54)
  IN2 w0.066: v7(157.36,133.8) 156.02,132.46 146.93,132.46 146.47,132.92 132.83,132.92 132.16,133.59 131.04,133.59 130.56,133.12 124.55,133.12 124.36,133.31 116.3,133.31 115.16,134.45 113.71,134.45 111.07,131.81 106.57,131.81 105.77,131.01 101.74,131.01 99.77,132.98 99.77,134.88 98.84,135.8 89.01,135.8 88.56,135.35 v3(88.56,135.29)
  BOTTOM w0.112: JXDP1.54 156.95,134.2 v7(157.36,133.8) RC106.2
TS_ID0: length 33.6
  TOP w0.076: v3(57.69,112.19) 57.67,112.19 57.3,111.83 57.3,111.25 57.91,110.64 57.91,110.43
  TOP w0.112: v3(62.76,88.18) 63.11,87.83 D112.2 ; 57.91,110.43 RC192.1
  IN2 w0.066: v4(63.04,88.53) 63.04,88.46 v3(62.76,88.18) ; v4(57.85,110.94) 57.85,112.03 v3(57.69,112.19)
  IN3 w0.066: v6(60.68,88.76) 60.76,88.69 62.92,88.69 63.04,88.56 v4(63.04,88.53) ; v4(57.85,110.94) 58.14,110.94 59.31,109.77 v6(59.31,109.69)
  IN4 w0.066: v6(59.31,109.69) 59.1,109.48 59.1,109.39 59.1,109.11 59.03,109.04 59.03,105.41 57.63,104.01 57.63,101.08 57.55,101 57.55,99.78 59.46,97.86 59.46,92.78 60.6,91.64 60.6,88.84 v6(60.68,88.76)
TS_ID0_D: length 82
  TOP w0.112: RC393.2 65.3,86.16 65.3,84.91 65.07,84.68 Q351.3 64.39,84.19 64.47,84.11 v8(65.18,84.11)
  IN1 w0.066: v8(65.18,84.11) 65.35,83.94 65.35,81.65 67.18,79.82 67.18,69.71 65.25,67.78 65.25,55.84 67.44,53.66 67.44,45.05 73.91,38.57 73.91,31.15 75.87,29.2 78.89,29.2 80.67,27.42 80.67,25.19 78.59,23.1 78.59,20.28 v7(77.77,19.47)
  BOTTOM w0.112: v7(77.77,19.47) 77.79,19.48 R432.1 77.42,20.09 v2(76.89,20.63)
TS_ID0_M: length 5.2
  TOP w0.112: D112.1 63.11,84.44 63.74,83.81 65.71,83.81 66.29,84.39 Q351.1
TS_ID0_R: length 6.5
  IN2 w0.066: v7(79.4,20.09) 80.01,20.7 v3(84.97,20.7)
  BOTTOM w0.112: R432.2 v7(79.4,20.09)
TS_RST#: length 155.3
  IN1 w0.066: v10(38.48,122.52) 38.57,122.61 41.8,122.61 v8(42.11,122.91) 42.52,123.33 43.22,123.33 43.47,123.58 44.55,123.58 45.04,124.07 47.37,124.07 47.8,124.5 51.77,124.5 51.99,124.73 52.58,124.73 52.78,124.93 54.58,124.93 55.25,125.6 55.87,125.6 56.32,125.16 56.92,125.16 57.13,125.37 57.13,125.55 v8(57.36,125.78) ; v10(36.49,72.44) 36.73,72.2 43.1,72.2 49.5,65.79 49.5,44.69 67.87,26.33 78.87,26.33 79.22,25.97 v7(79.51,25.97)
  IN2 w0.066: v10(36.49,72.44) 37.87,73.83 37.87,78.12 37.31,78.68 37.31,79.8 38.51,80.99 38.51,86.88 41.2,89.57 41.2,102.71 37.65,106.25 37.65,121.54 38.43,122.32 38.43,122.47 v10(38.48,122.52)
  BOTTOM w0.112: R495.1 80.39,22.58 80.39,24.2 80.77,24.57 80.77,26.01 80.66,26.12 v11(80.11,26.12) 79.65,26.12 v7(79.51,25.97)
TS_RST#R: length 16.9
  GND1 w0.066: v12(85.1,23.7) 84.83,23.43 v4(84.8,23.43)
  IN2 w0.066: v4(84.8,23.43) 84.8,23.42 84.55,23.17 v7(76.45,23.17)
  GND3 w0.066: v13(84.48,23.7) 84.75,23.43 v4(84.8,23.43)
  BOTTOM w0.112: v7(76.45,23.17) DI1.2 75.31,23.66 75.31,24.4 R418.2 76.14,26.05 v2(76.3,26.21) ; v13(84.48,23.7) 82.84,22.06 R495.2
TUSB1_USB_EQ0: length 5.8
  BOTTOM w0.112: RV20.1 27.57,48.59 RV27.1 27.36,47.26 27.36,46.73 28.55,45.53 28.78,45.53 v2(28.94,45.37) 28.94,44.58 RV67.2
TUSB1_USB_EQ1: length 6.6
  BOTTOM w0.112: RV68.2 26.44,44.97 26.31,45.1 25.27,45.1 24.89,45.48 v2(24.89,46.01) 24.89,47.31 25.4,47.82 RV28.1 25.91,48.33 26.44,48.86 RV21.1
TUSB2_USB_EQ0: length 3.6
  BOTTOM w0.112: UV2.38 19.5,27.25 18.92,27.83 RV90.1 18.67,27.83 RV35.1 RV34.1
TUSB2_USB_EQ1: length 9.3
  IN3 w0.066: v5(19.48,26.05) 19.48,24.12 17.26,21.9 v5(16.04,21.9)
  BOTTOM w0.112: v5(19.48,26.05) UV2.35 ; RV37.1 15.34,20.78 RV38.1 15.93,22.01 v5(16.04,21.9)
TYPEC_ID: length 7.7
  BOTTOM w0.076: 28,105.86 28,106.07 27.99,106.07 27.99,106.83 26.61,108.21 26.61,108.96 26.33,109.25 UE3.F2
  BOTTOM w0.112: 28,105.86 28,105.32 28.24,105.08 28.24,104.6 27.74,104.1 RE264.1 CE87.1
UART2_CTS#: length 13.9
  TOP w0.076: 52.6,122.89 53.07,122.42 55.54,122.42 UCPU1.AD4
  TOP w0.112: 52.6,122.89 52.44,123.05 50.55,123.05 v3(50.5,123.1)
  IN2 w0.066: v3(50.5,123.1) 50.5,124.54 v4(49.44,125.6)
  IN3 w0.066: v5(49.02,126.48) 49.02,126.02 v4(49.44,125.6)
  BOTTOM w0.112: v5(49.02,126.48) 48.82,126.48 48.44,126.1 48.44,125.65 RC191.2 47.98,125.21 47.69,125.5 47.69,125.53 46.98,126.23 JUART.4
UART2_RTS#: length 13.5
  TOP w0.076: 52.45,122.74 52.92,122.27 55.04,122.27 UCPU1.AD3
  TOP w0.112: v3(45.75,123.49) 46.12,123.49 46.19,123.43 46.7,123.43 47.03,123.76 ; RC196.2 47.03,123.76 ; 47.03,123.76 47.19,123.59 47.19,123.17 v2(47.45,122.91) 47.55,122.81 50.62,122.81 50.64,122.84 52.35,122.84 52.45,122.74
  IN2 w0.066: v3(45.75,123.49) 45.77,123.47 v4(46.13,123.47)
  IN3 w0.066: v4(46.13,123.47) 46.11,123.49 46.11,123.68 v5(45.97,123.81)
  BOTTOM w0.112: JUART.1 46.76,123.83 47.27,124.35 RC190.2
UART2_RXD: length 12.3
  TOP w0.112: UCPU1.AD1 52.79,122.03 52.19,122.63 51.54,122.63 51.28,122.37 50.98,122.37 v8(50.9,122.29)
  IN1 w0.066: v10(47.65,122.19) 47.71,122.19 48.03,122.5 48.68,122.5 49.12,122.06 50.67,122.06 v8(50.9,122.29)
  IN2 w0.066: v4(46.74,122.49) 47.35,122.49 v10(47.65,122.19)
  IN3 w0.066: v4(46.74,122.49) 46.63,122.49 45.53,123.59 v5(45.53,125.44)
  BOTTOM w0.112: JUART.3 45.53,125.43 v5(45.53,125.44)
UART2_TXD: length 17
  IN1 w0.066: v10(44.83,120.59) 45.5,120.59 46.39,121.48 47.38,121.48 v8(48.12,122.21) 48.65,121.68 51.29,121.68 51.64,122.04 53.26,122.04 53.27,122.03 53.85,122.03
  IN1 w0.076: 53.85,122.03 v8(54.63,122.03)
  IN2 w0.066: v4(45.07,121.91) 44.83,121.67 v10(44.83,120.59)
  IN3 w0.066: v5(45.31,121.59) 45.31,121.67 v4(45.07,121.91)
  BOTTOM w0.112: JUART.2 45.74,124.63 45.23,124.12 45.23,123.67 45.61,123.29 45.67,123.29 45.76,123.2 45.76,123.14 45.78,123.12 45.78,121.86 45.52,121.59 v5(45.31,121.59)
UART_MISO: length 71.5
  IN3 w0.066: v5(56.3,16.43) 56.09,16.43 54.74,15.07 48.05,15.07 v6(47.24,15.88) ; v5(29.16,66.94) 30.08,66.03 31.42,66.03 32.61,64.84 v5(33.69,64.84)
  IN4 w0.066: v5(33.69,64.84) 33.92,64.6 33.92,64.3 34.73,63.5 35.88,63.5 36.14,63.23 36.9,63.23 38.1,62.03 38.1,61.05 39.47,59.68 39.47,59.42 40.12,58.76 40.12,55.03 41.58,53.57 41.58,52.47 47.24,46.8 v6(47.24,15.88)
  BOTTOM w0.076: UT2.E2 v5(56.3,16.43)
