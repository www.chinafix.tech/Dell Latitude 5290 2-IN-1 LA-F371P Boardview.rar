# Allegro board Dell Latitude 5290 2-IN-1 LA-F371P Boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D19: length 31.5
  TOP w0.076: UCPU1.AK64 90.06,119.43 v7(89.74,119.11)
  IN4 w0.069: v7(89.74,119.11) 90.02,118.83 90.02,114.81 89.95,114.74 89.67,114.74 89.6,114.67 89.6,114.53 89.67,114.46 89.95,114.46 90.02,114.4 90.02,114.26 89.95,114.19 89.67,114.19 89.6,114.12 89.6,113.98 89.67,113.92 89.95,113.92 90.02,113.85 90.02,113.69 89.74,113.41 89.74,111.55 95.3,105.99 95.3,105.14 96.44,104 96.44,102.46 96.11,102.12 96.11,98.33 96.75,97.69 96.75,97.37 95.76,96.38 95.76,95.25 96.46,94.55 96.98,94.55 v1(97.26,94.27)
DDR_A_D20: length 33
  TOP w0.076: UCPU1.AF66 91.36,121.62 v7(91.14,121.84)
  IN4 w0.069: v1(99.17,95.27) 99.73,95.27 100.46,96 100.46,96.48 100.69,96.71 100.69,101.77 98.62,103.84 98.62,105.39 93.49,110.52 93.49,120.45 92.49,121.45 91.53,121.45 v7(91.14,121.84)
  BOTTOM w0.076: UD4.F11 98.87,95.57 v1(99.17,95.27)
DDR_A_D21: length 33
  TOP w0.076: UCPU1.AF67 92.01,121.63 v7(91.83,121.81)
  IN4 w0.069: v7(91.83,121.81) 92.49,121.81 93.75,120.56 93.75,110.63 98.88,105.49 98.88,103.95 100.95,101.88 100.95,96.6 100.72,96.37 100.72,95.89 99.75,94.92 v1(98.86,94.92)
DDR_A_D22: length 31.7
  TOP w0.076: UCPU1.AK67 92.01,119.37 v7(91.72,119.08)
  IN4 w0.069: v1(97.26,95.57) 97,95.82 97,96.38 97.64,97.02 97.64,97.61 97.75,97.72 97.75,98.28 97.92,98.44 98.13,98.44 98.45,98.76 98.45,102.14 98.26,102.33 97.77,102.33 97.22,102.88 97.22,105.17 92.35,110.04 92.35,112.58 91.97,112.96 91.97,113.33 91.9,113.4 91.44,113.4 91.37,113.47 91.37,113.6 91.44,113.67 91.9,113.67 91.97,113.74 91.97,113.88 91.9,113.95 91.44,113.95 91.37,114.02 91.37,114.15 91.44,114.22 91.9,114.22 91.97,114.29 91.97,114.43 91.9,114.5 91.44,114.5 91.37,114.56 91.37,114.7 91.44,114.77 91.9,114.77 91.97,114.84 91.97,114.98 91.9,115.04 91.44,115.04 91.37,115.11 91.37,118.72 v7(91.72,119.08)
DDR_A_D23: length 31.4
  TOP w0.076: UCPU1.AK66 91.36,119.42 v7(91.05,119.1)
  IN4 w0.069: v1(97.26,94.92) 97.15,94.81 96.71,94.81 96.52,94.99 96.52,95.45 96.77,95.7 96.77,96.51 97.39,97.12 97.39,97.84 97.54,97.99 97.54,98.36 97.78,98.6 97.78,101.78 97.59,101.97 97.59,102.14 96.96,102.77 96.96,105.06 90.55,111.47 90.55,111.8 91.11,112.36 91.11,113.23 91.04,113.3 90.77,113.3 90.7,113.37 90.7,113.51 90.77,113.58 91.04,113.58 91.11,113.65 91.11,113.82 91.04,113.88 90.7,113.88 90.63,113.95 90.63,114.09 90.7,114.16 91.05,114.16 91.12,114.23 91.12,114.36 91.05,114.43 90.62,114.43 90.54,114.51 90.54,118.59 v7(91.05,119.1)
DDR_A_D24: length 38.8
  TOP w0.076: UCPU1.AF70 93.99,121.67 94.39,122.07 95.43,122.07 v7(95.89,121.61)
  IN3 w0.094: v5(97.26,99.47) 97.26,98.78 98.06,97.98 99.31,97.98 99.53,98.2 100.01,98.2 100.26,98.45 101.08,98.45 106.42,103.78 106.42,113.18 97.36,122.25 96.53,122.25 v7(95.89,121.61)
DDR_A_D25: length 38.3
  TOP w0.076: v7(97.08,121.58) 96.17,122.5 94.04,122.5 93.45,121.91 93.12,121.91 92.78,121.57 UCPU1.AF68
  IN3 w0.094: v7(97.08,121.58) 97.08,121.57 105.85,112.8 105.85,104.02 100.85,99.02 100.02,99.02 99.84,98.83 99.23,98.83 98.97,98.57 97.96,98.57 97.81,98.71 97.81,99.87 v5(98.06,100.12)
DDR_A_D26: length 39.9
  TOP w0.076: UCPU1.AH71 94.95,120 95.21,120 v7(95.56,119.65)
  IN3 w0.094: v7(95.56,119.65) 97.65,119.65 99.36,117.94 99.36,109.33 102.49,106.21 102.49,105.69 102.58,105.6 103.67,105.6 103.76,105.5 103.76,105.31 103.67,105.22 102.58,105.22 102.49,105.13 102.49,104.94 102.58,104.84 103.67,104.84 103.76,104.75 103.76,104.56 103.67,104.47 102.58,104.47 102.49,104.37 102.49,104.19 102.58,104.09 103.67,104.09 103.76,104 103.76,103.81 103.67,103.72 102.58,103.72 102.49,103.62 102.49,103.43 102.58,103.34 103.45,103.34 103.54,103.25 103.54,103.06 103.45,102.96 102.58,102.96 102.49,102.87 102.49,102.83 102.37,102.71 102.37,102.58 102.65,102.3 102.65,102.17 102.52,102.03 102.38,102.03 102.1,102.32 101.97,102.32 101.84,102.18 101.84,102.05 102.12,101.77 102.12,101.63 101.99,101.5 101.85,101.5 101.57,101.78 101.44,101.78 101.3,101.65 101.3,101.52 101.59,101.23 101.59,101.1 101.45,100.97 101.32,100.97 101.04,101.25 100.91,101.25 100.77,101.12 100.77,100.99 101.05,100.7 101.05,100.57 100.92,100.44 100.79,100.44 100.51,100.72 100.37,100.72 99.39,99.74 v5(99.27,99.74)
  BOTTOM w0.076: v5(99.27,99.74) 99,99.47 UD4.M11
DDR_A_D27: length 36.9
  TOP w0.076: v7(92.28,120.01) 92.62,120.34 UCPU1.AH68
  IN3 w0.094: v5(97.26,100.77) 97.51,100.52 98.96,100.52 99.78,101.33 99.78,102.52 99.95,102.69 100.95,102.69 101.05,102.79 101.05,102.98 100.95,103.07 99.87,103.07 99.78,103.16 99.78,103.35 99.87,103.45 100.95,103.45 101.05,103.54 101.05,103.73 100.95,103.82 100.68,103.82 100.58,103.91 100.58,104.1 100.68,104.2 100.95,104.2 101.05,104.29 101.05,104.48 100.95,104.57 99.87,104.57 99.78,104.67 99.78,104.85 99.87,104.95 100.95,104.95 101.05,105.04 101.05,105.23 100.95,105.32 99.87,105.32 99.78,105.42 99.78,105.61 99.87,105.7 100.95,105.7 101.05,105.79 101.05,105.98 100.95,106.08 99.95,106.08 99.78,106.25 99.78,107.71 98.51,108.98 98.51,113.02 97.51,114.02 97.51,117.86 97.41,117.95 94.34,117.95 v7(92.28,120.01)
DDR_A_D28: length 39.6
  TOP w0.076: UCPU1.AF71 v7(95.22,121.67)
  IN3 w0.094: v7(95.22,121.67) 96.08,122.53 97.48,122.53 106.71,113.3 106.71,103.67 101.2,98.16 100.38,98.16 100.13,97.91 99.65,97.91 99.4,97.66 98.14,97.66 96.98,98.82 v5(96.98,99.16)
  BOTTOM w0.076: v5(96.98,99.16) 96.67,99.47 UD4.M8
DDR_A_D29: length 39
  TOP w0.076: UCPU1.AF69 93.36,121.57 94.11,122.32 95.79,122.32 v7(96.5,121.61)
  IN3 w0.094: v5(97.26,100.12) 97.59,99.79 97.59,98.7 98,98.28 99.26,98.28 99.52,98.54 99.95,98.54 100.14,98.73 100.97,98.73 106.14,103.9 106.14,113.07 97.24,121.96 96.85,121.96 v7(96.5,121.61)
DDR_A_D30: length 36.7
  TOP w0.076: v7(94.89,119.65) 94.2,120.34 UCPU1.AH70
  IN3 w0.094: v5(98.06,99.47) 98.59,99.47 99.15,100.02 99.28,100.02 101.73,102.48 101.73,102.6 101.82,102.69 102,102.69 102.09,102.79 102.09,102.98 102,103.07 101.82,103.07 101.73,103.16 101.73,104.69 101.82,104.78 102.11,104.78 102.2,104.88 102.2,105.06 102.11,105.16 101.82,105.16 101.73,105.25 101.73,105.44 101.82,105.53 102.11,105.53 102.2,105.63 102.2,105.82 102.11,105.91 101.82,105.91 101.73,106 101.73,106.56 99.08,109.21 99.08,114.23 98.98,114.33 98.17,114.33 98.07,114.42 98.07,114.61 98.17,114.7 98.81,114.7 98.9,114.8 98.9,114.99 98.81,115.08 98.17,115.08 98.07,115.17 98.07,115.36 98.17,115.46 98.81,115.46 98.9,115.55 98.9,115.74 98.81,115.83 98.17,115.83 98.07,115.93 98.07,116.11 98.17,116.21 98.81,116.21 98.9,116.3 98.9,116.49 98.81,116.58 98.17,116.58 98.07,116.68 98.07,116.87 98.17,116.96 98.81,116.96 98.9,117.05 98.9,117.24 98.81,117.34 98.17,117.34 98.07,117.43 98.07,117.62 98.17,117.71 98.81,117.71 98.9,117.81 98.9,118 97.63,119.28 95.26,119.28 v7(94.89,119.65)
DDR_A_D31: length 35.1
  TOP w0.076: UCPU1.AH69 93.31,120.09 v7(93.12,119.91)
  IN3 w0.094: v7(93.12,119.91) 94.28,119.91 94.36,119.83 94.36,119.54 94.27,119.45 93.81,119.45 93.72,119.35 93.72,119.09 93.81,118.99 97.51,118.99 97.65,118.85 97.65,118.72 97.54,118.61 94.58,118.61 94.49,118.52 94.49,118.33 94.58,118.24 97.7,118.24 97.79,118.14 97.79,114.14 97.88,114.04 98.61,114.04 98.79,113.86 98.79,109.09 101.45,106.44 101.45,102.6 98.97,100.12 v5(98.86,100.12)
DDR_A_D32: length 15.9
  TOP w0.076: v3(91.27,112.82) 90.85,112.41 UCPU1.BB65
  IN2 w0.094: v3(98.06,102.07) 98.53,102.53 98.53,103.41 98.1,103.83 98.1,107.6 92.67,113.03 91.48,113.03 v3(91.27,112.82)
DDR_A_D33: length 17.6
  IN2 w0.094: v3(90.85,114.15) 91.14,113.86 93.06,113.86 98.96,107.96 98.96,104.19 99.4,103.75 99.4,101.95 v3(98.86,101.42)
DDR_A_D34: length 17.3
  IN2 w0.076: v3(89.63,114.15) 89.15,113.67 89.15,113.13 90.27,112.02 91.31,112.02
  IN2 w0.094: v3(97.26,101.42) 96.98,101.7 96.98,102.34 96.87,102.45 96.87,107.08 91.93,112.02 91.31,112.02
DDR_A_D35: length 15.8
  TOP w0.076: UCPU1.AY63 89.63,113.47 89.39,113.23 v3(89.39,113.23)
  IN2 w0.076: 91.17,112.25 90.38,112.25 v3(89.39,113.23)
  IN2 w0.094: 91.17,112.25 92.11,112.25 97.15,107.2 97.15,102.57 97.26,102.46 v3(97.26,102.07)
DDR_A_D36: length 15.9
  IN2 w0.094: v3(98.86,102.07) 98.81,102.12 98.81,103.53 98.39,103.95 98.39,107.73 92.79,113.33 91.33,113.33 v3(90.85,112.85)
DDR_A_D37: length 17.7
  TOP w0.076: UD2.C10 98.31,101.67 v3(98.38,101.67)
  IN2 w0.094: v3(98.38,101.67) 98.82,101.67 99.11,101.96 99.11,103.63 98.67,104.07 98.67,107.85 92.83,113.69 91.07,113.69 91.06,113.7 v3(90.85,113.5)
DDR_A_D38: length 14.7
  TOP w0.076: v3(90.1,111.27) 90.1,111.27 90.1,111.4 90.12,111.42 90.12,111.68 89.79,112.01 89.79,112.44 89.53,112.71 UCPU1.BA63
  IN2 w0.094: v3(90.1,111.27) 90.26,111.11 92.02,111.11 96.3,106.84 96.3,102.23 v3(96.46,102.07)
DDR_A_D39: length 15.1
  TOP w0.076: v3(89.85,111.55) 89.85,111.7 89.53,112.02 UCPU1.BB63
  IN2 w0.094: v3(89.85,111.55) 90.17,111.55 90.44,111.28 92.26,111.28 96.58,106.96 96.58,102.49 96.75,102.33 96.75,101.7 v3(96.46,101.42)
DDR_A_D40: length 27.1
  IN2 w0.076: 90.08,110.52 89.24,111.36 89.24,112.11 v3(88.5,112.85)
  IN2 w0.094: v3(96.46,92.97) 96.84,93.35 96.84,93.79 97.15,94.1 97.15,94.6 97.78,95.24 98.75,95.24 98.84,95.33 98.84,96.68 98.59,96.92 97.41,96.92 96.47,97.86 96.47,98.39 95.57,99.29 95.57,100.18 95.33,100.42 95.33,106.44 91.25,110.52 90.08,110.52
DDR_A_D41: length 28.2
  IN2 w0.076: v3(88.4,114.15) 88.75,113.8 88.75,113.16 89.57,112.34 89.57,111.46 90.08,110.95 91.5,110.95 91.5,110.94
  IN2 w0.094: 91.5,110.94 91.63,110.94 95.9,106.67 95.9,100.65 96.21,100.34 96.21,99.29 96.9,98.6 96.9,98.18 97.7,97.38 98.94,97.38 99.41,96.91 99.41,95.09 98.98,94.67 98.02,94.67 97.72,94.37 97.72,94.08 v3(97.26,93.62)
DDR_A_D42: length 30.5
  TOP w0.076: v3(87.76,111.57) 87.61,111.57 87.17,112.01 UCPU1.BB59
  IN2 w0.094: v3(98.86,93.62) 98.66,93.42 98.66,93.2 98.61,93.15 98.61,91.82 97.95,91.16 95.3,91.16 93.52,92.93 93.52,95.61 94.06,96.14 94.06,96.75 93.52,97.29 93.52,105.69 89.7,109.51 89.57,109.51 87.76,111.32 v3(87.76,111.57)
DDR_A_D43: length 30.2
  IN2 w0.076: 88.19,111.37 88.19,111.86 87.17,112.88 v3(87.17,114.15)
  IN2 w0.094: v3(98.06,92.97) 98.21,92.82 98.21,92.06 97.88,91.73 95.53,91.73 94.84,92.42 94.84,95.57 95.23,95.96 95.23,98.02 94.09,99.16 94.09,105.92 90.17,109.85 89.72,109.85 88.19,111.37
DDR_A_D44: length 25.5
  TOP w0.076: v3(88.95,111.83) 88.76,111.83 88.5,112.09 UCPU1.BB61
  IN2 w0.094: v3(88.95,111.83) 88.95,111.37 89.97,110.35 91.02,110.35 95.05,106.32 95.05,100.26 95.25,100.05 95.25,99.23 96.24,98.24 96.24,97.49 96.37,97.36 96.37,97.03 96.81,96.59 97.15,96.59 97.27,96.47 97.27,96.2 97.15,96.08 96.43,96.08 96.34,95.98 96.34,95.72 96.43,95.63 97.36,95.63 97.5,95.49 97.5,95.35 96.87,94.72 96.87,94.52 96.77,94.43 96.55,94.43 96.46,94.33 v3(96.46,93.62)
DDR_A_D45: length 28
  IN2 w0.076: v3(88.4,113.5) 88.59,113.3 88.59,113.1 89.4,112.29 89.4,111.41 90.14,110.68 91.37,110.68
  IN2 w0.094: v3(97.26,92.97) 97.01,93.22 97.01,93.72 97.44,94.15 97.44,94.49 97.9,94.95 98.87,94.95 99.13,95.21 99.13,96.79 98.71,97.21 97.53,97.21 96.7,98.04 96.7,98.49 95.91,99.29 95.91,100.24 95.61,100.53 95.61,106.56 91.49,110.68 91.37,110.68
DDR_A_D46: length 30.7
  TOP w0.076: v3(98.38,93.31) 98.08,93.62 UD2.R10 ; UCPU1.BA59 87.17,112.75 87.53,112.39 87.53,112.14 v3(87.64,112.04)
  IN2 w0.076: v3(87.64,112.04) 87.83,111.84 87.83,111.84 88,111.67 88,111.32
  IN2 w0.094: 88,111.32 89.65,109.68 89.94,109.68 93.81,105.81 93.81,99.04 94.94,97.9 94.94,96.34 94.09,95.48 94.09,92.78 95.42,91.45 97.84,91.45 98.38,91.99 v3(98.38,93.31)
DDR_A_D47: length 31.5
  TOP w0.076: UCPU1.AY59 87.17,113.41 86.82,113.06 v3(86.82,113)
  IN2 w0.076: 87.52,111.36 87.52,111.77 86.82,112.47 v3(86.82,113)
  IN2 w0.094: 87.52,111.36 87.52,111.29 93.24,105.57 93.24,92.82 95.18,90.88 98.07,90.88 98.86,91.67 v3(98.86,92.97)
DDR_A_D48: length 18.6
  TOP w0.076: v7(91.88,116.22) 91.61,115.96 UCPU1.AT66
  IN3 w0.094: v7(91.88,116.22) 91.88,116.19 94.21,113.86 94.21,113.58 97.54,110.25 97.54,108.58 98.81,107.31 98.81,102.51 98.41,102.1 98.41,101.76 v5(98.06,101.42)
DDR_A_D49: length 17.1
  TOP w0.076: v7(91.93,115.49) 91.75,115.31 UCPU1.AU66
  IN3 w0.094: v5(98.06,102.07) 98.06,102.16 98.53,102.63 98.53,107.19 97.26,108.46 97.26,110.13 93.92,113.47 93.92,113.74 92.18,115.49 v7(91.93,115.49)
DDR_A_D50: length 20
  TOP w0.076: v7(90.91,117.55) 90.63,117.26 UCPU1.AP65
  IN3 w0.094: v5(96.46,101.42) 96.73,101.69 96.73,102.34 96.65,102.42 96.65,106.91 95.73,107.83 95.73,109.5 90.93,114.3 90.49,114.3 90.23,114.56 90.23,116.87 v7(90.91,117.55)
DDR_A_D51: length 20
  TOP w0.076: UCPU1.AN65 90.62,117.91 v7(90.91,118.21)
  IN3 w0.094: v5(96.46,102.07) 96.37,102.16 96.37,106.79 95.45,107.71 95.45,109.38 90.72,114.11 90.3,114.11 89.98,114.43 89.98,117.27 v7(90.91,118.21)
DDR_A_D52: length 20.6
  TOP w0.076: v7(91.98,118.1) 91.79,117.91 UCPU1.AN66
  IN3 w0.094: v5(98.86,101.42) 99.38,101.94 99.38,107.54 98.11,108.81 98.11,110.49 94.78,113.82 94.78,115.31 v7(91.98,118.1)
DDR_A_D53: length 19.2
  TOP w0.076: UCPU1.AP66 91.64,117.26 v7(91.9,117.52)
  IN3 w0.094: v5(98.86,102.07) 99.1,102.3 99.1,107.42 97.83,108.69 97.83,110.37 94.49,113.7 94.49,114.93 v7(91.9,117.52)
DDR_A_D54: length 18.6
  TOP w0.076: UCPU1.AT65 90.57,115.96 90.84,116.22 90.86,116.22 v7(90.91,116.28)
  IN3 w0.094: v7(90.91,116.28) 90.56,115.92 90.56,114.61 90.68,114.49 91.15,114.49 96.02,109.62 96.02,107.94 96.93,107.03 96.93,102.58 97.01,102.51 97.01,101.67 v5(97.26,101.42)
DDR_A_D55: length 16.7
  TOP w0.076: v7(90.91,115.56) 90.66,115.31 UCPU1.AU65
  IN3 w0.094: v5(97.26,102.07) 97.26,102.7 97.22,102.74 97.22,107.15 96.3,108.06 96.3,109.74 91.31,114.73 91.31,114.96 90.91,115.36 v7(90.91,115.56)
DDR_A_D56: length 28.2
  TOP w0.076: UCPU1.AT61 88.77,115.96 v7(89.08,116.28)
  IN3 w0.094: v5(99.17,93.43) 99.45,93.71 99.45,95.23 99.28,95.4 99.28,95.96 96.52,98.72 96.52,99.23 96.08,99.67 96.08,99.96 95.68,100.36 95.68,106.51 94.77,107.43 94.77,107.79 90.45,112.11 90.45,113.31 89.49,114.28 89.49,115.87 v7(89.08,116.28)
  BOTTOM w0.076: UD4.C11 v5(99.17,93.43)
DDR_A_D57: length 28.5
  TOP w0.076: UCPU1.AU61 88.81,115.31 v7(89.08,115.59)
  IN3 w0.094: v7(89.08,115.59) 88.71,115.21 88.71,114.66 90.17,113.2 90.17,111.99 94.48,107.68 94.48,107.31 95.4,106.39 95.4,99.99 96.33,99.05 96.33,98.6 98.97,95.97 98.97,95.31 99.28,94.99 99.28,93.92 98.83,93.47 98.83,93.33 98.46,92.97 v5(98.06,92.97)
DDR_A_D58: length 29.8
  TOP w0.076: UCPU1.AP60 87.61,117.26 v7(87.31,117.57)
  IN3 w0.094: v7(87.31,117.57) 86.68,116.94 86.68,114.43 86.88,114.23 86.88,113.93 88.36,112.45 88.36,111.24 92.66,106.94 92.66,106.57 93.59,105.64 93.59,99.24 94.83,98 94.83,96.72 95.38,96.17 95.54,96.17 96.01,95.7 96.01,94.51 96.71,93.81 96.71,93.22 v5(96.46,92.97)
DDR_A_D59: length 30.3
  TOP w0.076: UCPU1.AN60 87.62,117.91 v7(87.31,118.23)
  IN3 w0.094: v5(96.46,93.62) 95.79,94.29 95.79,95.66 95.57,95.89 94.41,95.89 94.06,96.23 94.06,98.32 93.31,99.08 93.31,105.53 92.38,106.45 92.38,106.82 88.08,111.12 88.08,112.33 86.46,113.95 86.46,117.38 v7(87.31,118.23)
DDR_A_D60: length 30.1
  TOP w0.076: UCPU1.AN61 89.02,117.54 v7(89.1,117.54)
  IN3 w0.094: v5(98.86,92.97) 99.14,92.97 99.74,93.57 99.74,95.83 96.71,98.85 96.71,99.44 96.41,99.73 96.41,100.18 95.97,100.63 95.97,106.63 95.05,107.54 95.05,109.12 89.71,114.46 89.71,116.93 v7(89.1,117.54)
DDR_A_D61: length 30.5
  TOP w0.076: v7(88.22,117.6) 88.55,117.26 UCPU1.AP61
  IN3 w0.094: v7(88.22,117.6) 88.55,117.27 88.55,116.3 88.42,116.17 88.42,114.54 89.88,113.08 89.88,111.87 94.18,107.57 94.18,107.2 95.11,106.27 95.11,99.87 96.13,98.85 96.13,98.57 96.31,98.38 96.31,97.84 96.82,97.33 97.36,97.33 98.04,96.65 98.04,95.81 99.11,94.75 99.11,94.07 v5(98.41,93.36)
  BOTTOM w0.076: v5(98.41,93.36) 98.15,93.62 UD4.C10
DDR_A_D62: length 27.7
  TOP w0.076: UCPU1.AT60 87.64,115.96 v7(87.31,116.3)
  IN3 w0.094: v7(87.31,116.3) 86.93,115.92 86.93,114.63 87.16,114.4 87.16,114.05 88.65,112.56 88.65,111.36 92.95,107.06 92.95,106.69 93.88,105.76 93.88,99.35 95.11,98.12 95.11,96.83 96.27,95.68 96.27,94.61 v5(97.26,93.62)
DDR_A_D63: length 27.6
  TOP w0.076: v7(87.28,115.64) 87.61,115.31 UCPU1.AU60
  IN3 w0.094: v7(87.28,115.64) 87.66,115.27 87.66,113.96 88.93,112.68 88.93,111.48 93.23,107.18 93.23,106.81 94.16,105.88 94.16,99.47 95.4,98.23 95.4,96.95 96.51,95.84 96.51,94.88 97.51,93.88 97.51,93.22 v5(97.26,92.97)
DDR_A_DQS0: length 36.2
  TOP w0.076: UCPU1.AM69 v3(92.98,118.1)
  IN2 w0.094: v3(98.06,98.82) 98.14,98.74 98.14,98.55 98.33,98.36 99.12,98.36 101.64,100.88 101.64,105.45 105.45,109.27 105.45,111.85 102.72,114.59 100.87,114.59 100.77,114.68 100.77,114.97 100.87,115.06 101.51,115.06 101.69,115.24 101.69,115.65 101.51,115.84 99.92,115.84 99.82,115.93 99.82,117.42 99.19,118.05 95.46,118.05 95.21,118.3 93.6,118.3 93.4,118.1 v3(92.98,118.1)
DDR_A_DQS1: length 41.9
  TOP w0.076: UD2.L10 97.99,96.22 v7(97.66,95.88) ; v7(96.45,115.51) 96.4,115.51 95.99,115.92 95.92,115.92 95.81,116.03 95.09,116.03 94.56,115.82 94.36,115.74 94.15,115.74 93.94,115.79 93.73,115.79 93.63,115.89 UCPU1.AT70
  IN4 w0.069: v7(97.66,95.88) 97.92,95.88 97.98,95.82 97.98,95.57 97.6,95.19 97.6,94.12 97.86,93.85 99.45,93.85 100.11,93.2 101.76,93.2 103.64,95.08 103.64,97.15 102.87,97.92 102.87,105.14 102.58,105.42 102.3,105.42 102.01,105.13 101.91,105.13 101.77,105.27 101.77,105.39 102.06,105.68 102.06,105.96 101.58,106.45 100.63,106.45 97.58,109.5 97.58,112.08 97.44,112.23 97,112.23 96.93,112.29 96.93,112.5 97,112.57 97.44,112.57 97.58,112.71 97.58,113.03 97.44,113.17 97,113.17 96.93,113.24 96.93,113.45 97,113.51 97.44,113.51 97.58,113.66 97.58,113.97 97.44,114.12 97,114.12 96.93,114.18 96.93,114.39 97,114.46 97.44,114.46 97.58,114.6 97.58,114.93 97.38,115.13 96.49,115.13 96.39,115.23 96.39,115.46 v7(96.45,115.51)
DDR_A_DQS2: length 34.6
  TOP w0.076: UCPU1.AH65 90.71,120.61 v7(90.43,120.88)
  IN4 w0.069: v7(90.43,120.88) 90.75,120.57 90.75,120.57 90.8,120.52 90.8,119.76 91.06,119.51 92.27,119.51 92.34,119.44 92.34,118.81 92.49,118.67 92.66,118.67 92.72,118.6 92.72,118.39 92.66,118.32 92.49,118.32 92.34,118.18 92.34,117.87 92.49,117.72 92.66,117.72 92.72,117.65 92.72,117.45 92.66,117.38 92.49,117.38 92.34,117.23 92.34,116.92 92.49,116.78 92.66,116.78 92.72,116.71 92.72,116.5 92.66,116.43 92.49,116.43 92.34,116.29 92.34,115.98 92.49,115.83 92.66,115.83 92.72,115.76 92.72,115.56 92.66,115.49 92.49,115.49 92.34,115.34 92.34,115.03 92.49,114.89 92.66,114.89 92.72,114.82 92.72,114.61 92.66,114.54 92.49,114.54 92.34,114.4 92.34,114.09 92.49,113.94 92.66,113.94 92.72,113.87 92.72,113.67 92.66,113.6 92.49,113.6 92.34,113.45 92.34,113.14 92.49,113 92.66,113 92.72,112.93 92.72,110.19 97.6,105.32 97.6,103.05 97.94,102.7 98.69,102.7 99.19,102.2 99.19,101.74 99.93,101 99.93,99.31 99.17,98.55 98.84,98.55 98.1,97.81 98.1,97.2 98.32,96.98 98.32,96.48 v1(98.06,96.22)
DDR_A_DQS3: length 38.5
  TOP w0.076: UCPU1.AG70 93.63,120.92 93.71,120.84 93.9,120.84 94.15,120.75 94.37,120.74 94.52,120.78 94.69,120.78 94.93,121.02 95.64,121.02 95.64,121.02 95.78,121.02 96.06,120.74 96.06,120.5 96.19,120.37 v7(96.42,120.37)
  IN3 w0.094: v7(96.42,120.37) 96.24,120.37 96.06,120.53 96.06,120.71 96.11,120.76 96.22,120.86 97.01,120.86 105.3,112.57 105.3,107.89 105.2,107.8 103.42,107.8 103.23,107.61 103.23,107.2 103.42,107.02 105.2,107.02 105.3,106.93 105.3,104.25 100.62,99.57 99.79,99.57 99.61,99.38 98.92,99.38 98.65,99.11 98.65,98.95 98.51,98.82 v5(98.06,98.82)
DDR_A_DQS4: length 18
  IN2 w0.094: v3(98.06,100.77) 98.18,100.77 98.27,100.86 98.27,101.06 97.85,101.48 97.85,101.63 97.66,101.82 97.66,102.5 97.55,102.6 97.55,107.37 92.5,112.42 90.45,112.42 90.24,112.62 90.24,112.76 89.94,113.07 89.94,113.47 v3(90.29,113.82)
DDR_A_DQS5: length 30.1
  IN2 w0.094: v3(98.06,94.27) 98.44,94.27 98.53,94.17 98.53,94.04 97.66,93.16 97.66,92.38 97.56,92.28 96.03,92.28 95.94,92.38 95.94,94.57 96.06,94.69 96.06,95.32 95.94,95.44 95.94,95.82 95.8,95.96 95.8,98.23 94.65,99.39 94.65,106.15 90.63,110.18 89.85,110.18 88.6,111.43 88.6,112.01 87.96,112.65 87.96,112.79 88.27,113.1 88.27,113.28 88.06,113.48 87.93,113.48 87.84,113.38 v3(87.84,113.17)
DDR_A_DQS6: length 20.3
  TOP w0.076: v7(90.94,116.89) 90.66,116.61 UCPU1.AR65
  IN3 w0.094: v5(98.06,100.77) 98.06,100.84 97.66,101.25 97.66,102.69 97.62,102.73 97.62,107.31 96.7,108.23 96.7,109.9 93.37,113.24 93.37,113.33 91.37,115.33 91.37,116.5 91.44,116.57 91.44,117.05 91.35,117.14 91.2,117.14 v7(90.94,116.89)
DDR_A_DQS7: length 29.2
  TOP w0.076: UCPU1.AR60 87.58,116.61 v7(87.28,116.91)
  IN3 w0.094: v7(87.28,116.91) 87.93,116.26 87.93,114.24 89.33,112.85 89.33,111.64 93.63,107.34 93.63,106.97 94.56,106.05 94.56,99.64 95.83,98.37 95.83,97.09 96.16,96.75 96.96,96.75 97.13,96.58 97.13,95.49 97.28,95.33 97.28,95.33 97.45,95.16 98.24,95.16 98.52,94.87 98.52,94.36 98.43,94.27 v5(98.06,94.27)
DDR_A_DQS#0: length 36.2
  TOP w0.076: v3(93.68,118) 93.58,118.1 93.58,118.3 UCPU1.AM70
  IN2 w0.094: v3(98.86,98.82) 98.39,98.82 98.3,98.72 98.3,98.61 98.39,98.52 99.06,98.52 101.48,100.94 101.48,105.52 105.3,109.33 105.3,111.79 102.65,114.43 100.8,114.43 100.62,114.62 100.62,115.03 100.8,115.21 101.44,115.21 101.54,115.31 101.54,115.59 101.44,115.68 99.85,115.68 99.67,115.87 99.67,117.35 99.12,117.9 95.39,117.9 95.15,118.14 94.2,118.14 94.11,118.05 94.11,117.69 93.96,117.54 93.65,117.54 93.56,117.63 93.56,117.88 v3(93.68,118)
DDR_A_DQS#1: length 41.9
  TOP w0.076: UCPU1.AT69 93.17,116 93.46,115.71 93.58,115.71 93.66,115.63 93.92,115.63 94.13,115.57 94.39,115.57 94.63,115.67 95.12,115.87 95.74,115.87 95.84,115.76 v7(95.84,115.51) ; UD2.L11 98.79,96.22 v7(98.47,95.89)
  IN4 w0.069: v7(95.84,115.51) 96.01,115.51 96.09,115.43 96.09,115.35 96.44,115 97.32,115 97.45,114.88 97.45,114.66 97.38,114.59 96.95,114.59 96.81,114.44 96.81,114.13 96.95,113.99 97.38,113.99 97.45,113.92 97.45,113.71 97.38,113.64 96.95,113.64 96.81,113.5 96.81,113.19 96.95,113.04 97.38,113.04 97.45,112.97 97.45,112.77 97.38,112.7 96.95,112.7 96.81,112.55 96.81,112.24 96.95,112.1 97.38,112.1 97.45,112.03 97.45,109.45 100.58,106.32 101.52,106.32 101.93,105.91 101.93,105.73 101.64,105.44 101.64,105.22 101.86,105 102.06,105 102.35,105.29 102.53,105.29 102.74,105.09 102.74,97.87 103.51,97.1 103.51,95.13 101.7,93.33 100.16,93.33 99.5,93.98 97.92,93.98 97.73,94.17 97.73,95.13 98.11,95.52 98.11,95.82 98.18,95.89 v7(98.47,95.89)
DDR_A_DQS#2: length 34.6
  TOP w0.076: v7(91.04,120.88) 91.36,120.57 UCPU1.AH66
  IN4 w0.069: v1(98.86,96.22) 98.83,96.22 98.45,96.6 98.45,97.03 98.23,97.26 98.23,97.75 98.89,98.42 99.23,98.42 100.06,99.25 100.06,101.05 99.32,101.79 99.32,102.25 98.74,102.83 98,102.83 97.72,103.11 97.72,105.38 92.85,110.25 92.85,112.98 92.71,113.13 92.54,113.13 92.47,113.2 92.47,113.4 92.54,113.47 92.71,113.47 92.85,113.61 92.85,113.93 92.71,114.07 92.54,114.07 92.47,114.14 92.47,114.35 92.54,114.41 92.71,114.41 92.85,114.56 92.85,114.87 92.71,115.02 92.54,115.02 92.47,115.08 92.47,115.29 92.54,115.36 92.71,115.36 92.85,115.5 92.85,115.82 92.71,115.96 92.54,115.96 92.47,116.03 92.47,116.24 92.54,116.3 92.71,116.3 92.85,116.45 92.85,116.76 92.71,116.91 92.54,116.91 92.47,116.97 92.47,117.18 92.54,117.25 92.71,117.25 92.85,117.39 92.85,117.71 92.71,117.85 92.54,117.85 92.47,117.92 92.47,118.13 92.54,118.19 92.71,118.19 92.85,118.34 92.85,118.65 92.71,118.8 92.54,118.8 92.47,118.86 92.47,119.49 92.33,119.64 91.11,119.64 90.93,119.82 90.93,120.77 v7(91.04,120.88)
DDR_A_DQS#3: length 38.5
  TOP w0.076: v7(95.73,120.36) 95.89,120.53 95.89,120.67 95.71,120.85 95,120.85 94.76,120.61 94.54,120.61 94.39,120.58 94.12,120.59 93.87,120.68 93.55,120.68 93.32,120.91 UCPU1.AG69
  IN3 w0.094: v5(98.86,98.82) 98.81,98.87 98.81,99.05 98.99,99.23 99.67,99.23 99.86,99.41 100.68,99.41 105.45,104.18 105.45,106.99 105.27,107.17 103.48,107.17 103.39,107.27 103.39,107.55 103.48,107.64 105.27,107.64 105.45,107.83 105.45,112.64 97.07,121.02 96.15,121.02 95.91,120.77 95.91,120.46 95.82,120.36 v7(95.73,120.36)
DDR_A_DQS#4: length 18
  IN2 w0.094: v3(98.86,100.77) 98.52,100.77 98.42,100.86 98.42,101.12 98,101.55 98,101.69 97.81,101.89 97.81,102.56 97.7,102.67 97.7,107.43 92.56,112.57 90.51,112.57 90.4,112.68 90.4,112.94 90.55,113.1 90.55,113.28 90.46,113.38 90.28,113.38 90.19,113.28 v3(90.19,113.17)
DDR_A_DQS#5: length 30.1
  IN2 w0.094: v3(87.74,113.82) 87.74,113.71 87.59,113.56 87.59,113.07 87.8,112.85 87.8,112.59 88.45,111.94 88.45,111.36 89.79,110.02 90.56,110.02 94.49,106.09 94.49,99.32 95.64,98.17 95.64,95.9 95.79,95.76 95.79,95.38 95.91,95.26 95.91,94.76 95.79,94.63 95.79,92.31 95.97,92.13 97.63,92.13 97.81,92.31 97.81,93.1 98.69,93.98 98.69,94.16 98.79,94.27 v3(98.86,94.27)
DDR_A_DQS#6: length 20.3
  TOP w0.076: UCPU1.AR66 91.71,116.61 v7(91.93,116.83)
  IN3 w0.094: v7(91.93,116.83) 91.68,116.83 91.59,116.75 91.59,116.5 91.53,116.43 91.53,115.39 93.52,113.39 93.52,113.3 96.86,109.97 96.86,108.29 97.77,107.38 97.77,102.79 97.81,102.75 97.81,101.31 98.09,101.03 98.6,101.03 v5(98.86,100.77)
DDR_A_DQS#7: length 29.2
  TOP w0.076: UCPU1.AR61 88.52,116.61 v7(88.19,116.94)
  IN3 w0.094: v5(98.86,94.27) 98.68,94.45 98.68,94.94 98.3,95.31 97.52,95.31 97.44,95.39 97.44,95.39 97.28,95.55 97.28,96.65 97.02,96.91 96.22,96.91 95.98,97.15 95.98,98.43 94.71,99.7 94.71,106.11 93.79,107.04 93.79,107.41 89.48,111.71 89.48,112.91 88.09,114.31 88.09,116.32 87.76,116.65 87.76,116.84 87.85,116.94 v7(88.19,116.94)
DDR_A_ODT0: length 51.8
  TOP w0.076: v8(92.35,91.89) 92.04,92.2 92.04,92.45 91.87,92.63 89.88,92.63 89.37,92.12 RD73.1 ; v7(79.05,116.13) 79.22,115.96 UCPU1.AT45 ; v7(95.36,95.47) 95.36,96.41 UD2.J8
  IN1 w0.107: v8(92.35,91.89) 92.86,92.39 94.11,92.39 94.49,92.01 95.63,92.01 95.81,92.19 95.81,95.02 v7(95.36,95.47)
  IN4 w0.069: v7(95.36,95.47) 94.89,95.94 94.55,95.94 94.09,96.4 94.09,97.99 94.31,98.22 95.04,98.22 95.41,98.59 95.41,102.42 95.48,102.49 95.48,103.2 93.78,104.9 93.78,106.51 88.09,112.21 86.28,112.21 85.78,112.71 84.37,112.71 84.3,112.78 84.3,112.92 84.37,112.98 85.37,112.98 85.44,113.05 85.44,113.17 85.35,113.26 83.78,113.26 80.95,116.09 79.34,116.09 79.3,116.13 v7(79.05,116.13)
  BOTTOM w0.076: UD2.J8 95.36,96.41 v7(95.36,95.47)
DDR_B0_ZQ0: length 4.7
  BOTTOM w0.076: UD3.B3 83.34,102.13 83.68,102.47 83.97,102.47 84.2,102.7 84.2,103.12
  BOTTOM w0.112: RD13.1 83.1,104.9 v2(83.35,104.65) 83.35,103.96
  BOTTOM w0.119: 84.2,103.12 83.35,103.96
DDR_B0_ZQ1: length 4.7
  BOTTOM w0.076: 83.43,103.12 83.43,102.69 83.21,102.47 82.58,102.47 UD3.B4
  BOTTOM w0.119: RD14.1 81.53,104.66 82.49,103.7 82.94,103.7 83.43,103.2 83.43,103.12
DDR_B1_ZQ0: length 5.2
  TOP w0.076: UD1.B3 83.23,93.03 83.56,92.7 84.07,92.7 84.2,92.58 84.2,91.83 v2(85.11,90.91) 85.28,90.74 RD8.1
DDR_B1_ZQ1: length 6.2
  TOP w0.076: 83.43,92.45 83.18,92.7 82.57,92.7 UD1.B4
  TOP w0.112: 83.43,92.11 83.43,92.45
  TOP w0.119: 83.43,92.11 85.69,89.86 RD7.1
DDR_B_CA1_0: length 32.4
  TOP w0.076: v7(81.53,113.84) 81.19,113.5 UCPU1.AY48
  IN3 w0.094: v7(81.53,113.84) 81.52,113.84 81.41,113.73 81.41,112.31 81.9,111.82 81.9,109.06 84.35,106.61 84.35,105.7 86.3,103.75 86.3,99.73 86.63,99.4 86.63,99.04 86.73,98.94 87.15,98.94 87.24,98.85 87.24,98.66 87.15,98.57 86.73,98.57 86.63,98.47 86.63,98.29 86.73,98.19 87.15,98.19 87.24,98.1 87.24,97.91 87.15,97.82 86.73,97.82 86.63,97.72 86.63,97.53 86.73,97.44 87.15,97.44 87.24,97.35 87.24,97.16 87.15,97.06 86.73,97.06 86.63,96.97 86.63,96.48 85.15,94.99 85.15,94.86 85.37,94.64 85.37,94.5 85.24,94.37 85.11,94.37 84.88,94.59 84.75,94.59 84.62,94.46 84.62,94.33 84.84,94.1 84.84,93.97 84.71,93.84 84.58,93.84 84.35,94.06 84.22,94.06 v5(83.84,93.68)
  BOTTOM w0.076: v5(83.84,93.68) 84.27,93.26 84.27,92.87 84.41,92.72 84.81,92.72 85.12,92.42 86.62,92.42 RD22.1
DDR_B_CA1_1: length 30.1
  TOP w0.076: UCPU1.AP50 82.36,117.26 v7(82.71,116.91)
  IN3 w0.094: v5(83.84,94.33) 83.85,94.33 84.24,94.72 84.24,94.97 85.75,96.48 85.75,99.71 86.02,99.97 86.02,103.64 84.07,105.58 84.07,106.49 81.62,108.94 81.62,111.7 81.12,112.2 81.12,113.95 82.17,115 82.17,116.37 v7(82.71,116.91)
  BOTTOM w0.076: RD24.1 85.5,93.41 84.57,94.33 v5(83.84,94.33)
DDR_B_CA1_2: length 30.4
  TOP w0.076: UCPU1.BA48 81.08,112.74 81.44,112.39 81.44,111.83 81.44,111.83 81.44,111.53 81.44,111.53 81.44,111.45 81.03,111.05 v7(81.03,110.96)
  IN3 w0.094: v5(83.84,94.98) 83.85,94.98 85.47,96.6 85.47,99.24 85.17,99.54 85.17,99.79 85.37,99.99 85.63,99.99 85.73,100.09 85.73,100.27 85.63,100.37 85.17,100.37 85.08,100.46 85.08,100.65 85.17,100.74 85.63,100.74 85.73,100.84 85.73,101.03 85.63,101.12 85.17,101.12 85.08,101.21 85.08,101.4 85.17,101.5 85.63,101.5 85.73,101.59 85.73,101.78 85.63,101.87 85.17,101.87 85.08,101.96 85.08,102.15 85.17,102.25 85.63,102.25 85.73,102.34 85.73,102.53 85.63,102.62 85.17,102.62 85.08,102.72 85.08,102.9 85.17,103 85.63,103 85.73,103.09 85.73,103.28 85.63,103.37 85.17,103.37 85.08,103.47 85.08,104.17 83.78,105.46 83.78,106.37 81.05,109.11 81.05,109.35 81.15,109.44 81.24,109.44 81.33,109.54 81.33,109.73 81.24,109.82 81.15,109.82 81.05,109.91 81.05,110.24 80.96,110.33 80.64,110.33 80.54,110.43 80.54,110.92 80.69,111.06 80.94,111.06 81.03,110.97 v7(81.03,110.96)
  BOTTOM w0.076: RD26.1 86.59,94.38 85.75,94.38 85.14,94.98 v5(83.84,94.98)
DDR_B_CA1_3: length 31.1
  TOP w0.076: UCPU1.BB48 81.08,111.73 81.03,111.68 v7(81.03,111.6)
  IN3 w0.094: v7(81.03,111.6) 80.83,111.6 80.26,111.03 80.26,110.14 80.35,110.05 80.67,110.05 80.77,109.95 80.77,108.99 83.5,106.26 83.5,105.34 84.79,104.04 84.79,99.98 84.15,99.34 84.15,98.34 84.53,97.97 84.53,96.98 84.32,96.77 84.32,96.77 83.54,95.99 83.54,93.12 83.46,93.03 83.17,93.03 83.04,93.16 83.04,94.3 82.95,94.39 82.32,94.39 82.23,94.48 82.23,94.89 82.32,94.98 v5(83.04,94.98)
  BOTTOM w0.076: RD28.1 85.47,92.84 84.32,93.99 83.66,93.99 83.45,94.19 83.45,94.43 83.04,94.84 v5(83.04,94.98)
DDR_B_CA1_4: length 35
  TOP w0.076: v7(81.79,116.89) 81.42,117.26 UCPU1.AP48
  IN3 w0.094: v5(83.04,95.63) 80.8,95.63 80.71,95.73 80.71,96.46 80.8,96.56 83.71,96.56 84.24,97.1 84.24,97.85 83.87,98.23 83.87,99.46 84.51,100.1 84.51,103.93 83.19,105.24 83.19,106.16 79.98,109.38 79.98,111.82 80.64,112.48 80.64,113.88 81.79,115.04 v7(81.79,116.89)
  BOTTOM w0.076: RD30.1 85.55,93.98 84.85,94.68 83.63,94.68 83.38,94.93 83.38,95.3 v5(83.04,95.63)
DDR_B_CA1_5: length 33.3
  TOP w0.076: v7(83.64,118.18) 83.64,117.87 83.16,117.39 UCPU1.AP52
  IN3 w0.094: v7(83.64,118.18) 83.23,118.58 81.27,118.58 80.32,117.64 79.95,117.64 79.45,117.14 79.45,114.71 79.21,114.47 79.21,113.2 78.55,112.54 78.55,107.73 80.73,105.55 80.73,99.8 82.29,98.24 82.69,98.24 82.78,98.33 82.78,99.27 v5(83.04,99.53)
  BOTTOM w0.076: v5(83.04,99.53) 83.18,99.53 83.48,99.84 85.19,99.84 RD32.1
DDR_B_CA1_6: length 34.4
  TOP w0.076: v7(81.82,118.23) 82.14,117.91 UCPU1.AN50
  IN3 w0.094: v5(83.04,100.18) 82.93,100.3 81.39,100.3 81.3,100.39 81.3,100.67 81.39,100.77 82.24,100.77 82.33,100.86 82.33,101.46 82.24,101.55 81.94,101.55 81.85,101.65 81.85,101.84 81.94,101.93 82.24,101.93 82.33,102.02 82.33,102.21 82.24,102.31 81.39,102.31 81.3,102.4 81.3,102.59 81.39,102.68 82.24,102.68 82.33,102.78 82.33,105.82 81.37,106.77 81.24,106.77 81.11,106.64 81.11,106.51 81.87,105.74 81.87,105.61 81.74,105.48 81.61,105.48 79.12,107.96 79.12,112.3 79.78,112.96 79.78,114.23 80.84,115.29 80.84,117.13 81.41,117.69 81.41,117.82 v7(81.82,118.23)
  BOTTOM w0.076: v5(83.04,100.18) 83.24,100.18 83.53,100.47 84.44,100.47 86.59,102.62 RD34.1
DDR_B_CA1_7: length 34.4
  TOP w0.076: UCPU1.AN48 81.09,117.91 v7(80.88,117.7)
  IN3 w0.094: v5(83.84,100.18) 83.84,100 83.71,99.87 82.82,99.87 82.37,99.42 82.37,99 82.23,98.87 82.06,98.87 81.65,99.28 81.65,99.41 81.99,99.75 81.99,99.88 81.85,100.01 81.71,100.01 81.38,99.68 81.25,99.68 81.01,99.92 81.01,101.23 81.11,101.32 81.47,101.32 81.57,101.41 81.57,101.6 81.47,101.7 81.11,101.7 81.01,101.79 81.01,103.21 81.11,103.3 81.44,103.3 81.53,103.4 81.53,103.58 81.44,103.68 81.11,103.68 81.01,103.77 81.01,103.96 81.11,104.05 81.92,104.05 82.01,104.15 82.01,104.34 81.92,104.43 81.11,104.43 81.01,104.52 81.01,104.71 81.11,104.81 81.92,104.81 82.01,104.9 82.01,105.09 81.92,105.18 81.11,105.18 81.01,105.28 81.01,105.67 78.84,107.84 78.84,112.42 79.5,113.08 79.5,114.35 80.56,115.41 80.56,117.38 v7(80.88,117.7)
  BOTTOM w0.076: RD36.1 84.97,100.18 v5(83.84,100.18)
DDR_B_CA1_8: length 31.8
  TOP w0.076: v7(83.6,116.94) 83.6,117.44 UCPU1.AN53
  IN3 w0.094: v7(83.6,116.94) 83.11,117.43 81.84,117.43 81.41,117 81.41,115.06 80.35,114 80.35,112.67 79.69,112.01 79.69,109.26 82.91,106.04 82.91,105.13 83.47,104.56 83.47,104.3 83.38,104.21 83.04,104.21 82.94,104.12 82.94,103.93 83.04,103.83 83.38,103.83 83.47,103.74 83.47,103.55 83.38,103.46 83.04,103.46 82.94,103.36 82.94,103.18 83.04,103.08 83.38,103.08 83.47,102.99 83.47,102.33 83.57,102.24 83.75,102.24 83.85,102.33 83.85,103.79 83.94,103.88 84.13,103.88 84.22,103.79 84.22,101.22 v5(83.84,100.83)
  BOTTOM w0.076: RD38.1 86.73,103.19 84.37,100.83 v5(83.84,100.83)
DDR_B_CA1_9: length 33.3
  TOP w0.076: v7(82.68,118.21) 82.98,117.91 UCPU1.AN52
  IN3 w0.094: v7(82.68,118.21) 82.38,118.21 81.13,116.96 81.13,115.18 80.07,114.11 80.07,112.84 79.41,112.18 79.41,108.08 80.7,106.78 80.84,106.78 80.97,106.92 80.97,107.05 79.86,108.16 79.86,108.3 79.99,108.43 80.12,108.43 82.62,105.93 82.62,102.88 82.71,102.79 83.09,102.79 83.19,102.69 83.19,102.51 83.09,102.41 82.71,102.41 82.62,102.32 82.62,100.76 82.71,100.67 82.9,100.67 82.99,100.76 82.99,101.93 83.09,102.03 83.27,102.03 83.37,101.93 83.37,101.46 83.49,101.34 83.7,101.34 v5(83.84,101.48)
  BOTTOM w0.076: v5(83.84,101.48) 84.48,101.48 86.76,103.76 RD40.1
DDR_B_CA2_0: length 23.1
  TOP w0.076: v3(78.87,111.5) 78.75,111.5 78.47,111.78 78.47,112.77 UCPU1.BA43 ; v3(83.84,101.48) 84.48,101.48 86.31,103.32 RD42.1
  IN2 w0.076: v3(78.87,111.5) 79.63,110.74 79.63,109.34 79.76,109.21
  IN2 w0.094: v3(83.84,101.48) 83.84,101.24 83.65,101.05 83.06,101.05 82.97,101.14 82.97,101.41 83.06,101.5 83.28,101.5 83.38,101.6 83.38,101.78 83.28,101.88 83.06,101.88 82.97,101.97 82.97,102.16 83.06,102.25 83.75,102.25 83.84,102.35 83.84,102.54 83.75,102.63 83.06,102.63 82.97,102.72 82.97,103.04 82.87,103.13 82.74,103.13 82.49,102.89 82.36,102.89 82.23,103.01 82.23,103.16 82.41,103.33 82.41,103.61 82.31,103.71 82.05,103.71 81.95,103.8 81.95,103.99 82.05,104.08 82.31,104.08 82.41,104.18 82.41,104.42 80.73,106.1 80.73,106.23 80.98,106.48 80.98,106.61 80.77,106.82 79.76,107.83 79.76,109.21
DDR_B_CA2_1: length 27.4
  TOP w0.076: UCPU1.AY43 77.97,113.73 78.49,113.2 78.8,113.2 79.2,112.8 79.2,111.45 v3(78.87,111.12) ; v3(83.84,100.83) 84.26,100.83 86.17,102.74 RD44.1
  IN2 w0.094: v3(78.87,111.12) 79.47,110.52 79.47,107.72 80.56,106.63 80.56,106.49 80.45,106.38 80.45,105.98 81.37,105.05 81.37,104.78 81.47,104.68 81.72,104.68 81.81,104.59 81.81,104.4 81.72,104.31 81.47,104.31 81.37,104.21 81.37,104.03 81.47,103.93 81.57,103.93 81.66,103.84 81.66,103.65 81.57,103.56 81.47,103.56 81.37,103.46 81.37,102.74 81.47,102.65 82.2,102.65 82.29,102.56 82.29,102.37 82.2,102.27 81.47,102.27 81.37,102.18 81.37,101.99 81.47,101.9 82.64,101.9 82.74,101.8 82.74,101.58 82.68,101.52 82.68,101.12 82.59,101.03 82.34,101.03 82.22,101.15 82.22,101.41 82.11,101.52 81.47,101.52 81.37,101.43 81.37,100.9 81.64,100.63 82.98,100.63 83.11,100.76 83.77,100.76 v3(83.84,100.83)
DDR_B_CA2_2: length 26.3
  TOP w0.076: RD46.1 85.92,101.6 84.5,100.18 v3(83.84,100.18)
  IN2 w0.076: v3(78.63,113.5) 79.08,113.5 79.16,113.42 79.16,112.33 79.55,111.94 79.55,111.67 80.74,110.47
  IN2 w0.094: 80.74,110.47 80.74,109.19 80.65,109.1 80.42,109.1 80.33,109.01 80.33,108.82 80.42,108.72 80.65,108.72 80.74,108.63 80.74,108.44 80.65,108.35 80.42,108.35 80.33,108.25 80.33,108.07 80.42,107.97 80.65,107.97 80.74,107.88 80.74,107.65 82.03,106.37 82.2,106.2 82.2,105.43 84.7,102.93 84.7,100.07 84.57,99.94 84.23,99.94 84.14,99.85 84.14,99.66 84.36,99.44 84.36,98.51 84.24,98.38 84,98.38 83.84,98.53 83.84,99.33 83.6,99.58 83.39,99.58 83.29,99.68 83.29,100.02 83.45,100.18 v3(83.84,100.18)
DDR_B_CA2_3: length 26.4
  TOP w0.076: RD48.1 86.11,102.17 84.43,100.5 83.36,100.5 v3(83.04,100.18)
  IN2 w0.076: 79.8,110.95 79.38,111.36 79.38,111.81 79,112.19 79,113.15 78.92,113.23 78.56,113.23 78.39,113.4 78.39,113.9 v3(78.63,114.15)
  IN2 w0.094: v3(83.04,100.18) 83.34,100.48 83.9,100.48 84.36,100.93 84.36,102.87 83.95,103.28 83.82,103.28 83.54,103 83.41,103 83.28,103.13 83.28,103.27 83.55,103.54 83.55,103.68 83.42,103.81 83.29,103.81 83.01,103.53 82.88,103.53 82.74,103.66 82.74,103.8 83.02,104.08 83.02,104.21 81.69,105.54 81.69,105.72 81.92,105.95 81.92,106.08 81.78,106.21 81.65,106.21 81.4,105.96 81.27,105.96 81.14,106.1 81.14,106.23 81.38,106.48 81.38,106.61 80.04,107.95 80.04,109.17 79.8,109.42 79.8,109.92 79.89,110.02 80.36,110.02 80.45,110.11 80.45,110.3 80.36,110.39 79.89,110.39 79.8,110.49 79.8,110.95
DDR_B_CA2_4: length 25.5
  TOP w0.076: RD50.1 85.98,101.03 84.81,99.86 83.37,99.86 v3(83.04,99.53) ; v3(78.9,111.86) 78.73,112.02 UCPU1.BB44
  IN2 w0.076: 79.19,109.48 79.19,109.76 78.63,110.32 78.63,111.6 78.89,111.86 v3(78.9,111.86)
  IN2 w0.094: 79.19,109.48 79.19,107.6 79.63,107.16 79.63,107.03 79.38,106.78 79.38,106.65 79.51,106.51 79.64,106.51 79.89,106.76 80.03,106.76 80.15,106.63 80.15,106.45 79.95,106.25 79.95,106.07 80.73,105.29 80.73,104.49 80.82,104.4 80.98,104.4 81.08,104.3 81.08,104.11 80.98,104.02 80.82,104.02 80.73,103.93 80.73,103.71 81.09,103.35 81.09,100.78 81.52,100.35 82.66,100.35 82.75,100.26 82.75,100.06 82.66,99.97 81.98,99.97 81.88,99.87 81.88,99.66 81.98,99.57 82.5,99.57 82.59,99.47 82.59,99.29 82.5,99.19 81.98,99.19 81.88,99.1 81.88,98.97 82.06,98.79 82.64,98.79 83.04,99.2 v3(83.04,99.53)
DDR_B_CA2_5: length 26.8
  TOP w0.076: RD52.1 86.57,95.32 83.47,95.32 83.15,95.63 v3(83.04,95.63)
  IN2 w0.076: v3(80.46,113.82) 80.2,114.08 79.88,114.08 79.36,113.56 79.36,112.46 79.61,112.21
  IN2 w0.094: 79.61,112.21 79.88,111.94 79.88,111.57 81.03,110.43 81.03,107.77 82.49,106.31 82.49,105.55 85.02,103.02 85.02,100.11 85.2,99.93 85.2,98.56 84.57,97.92 84.57,97.16 v3(83.04,95.63)
DDR_B_CA2_6: length 26.6
  TOP w0.076: RD54.1 85.66,93.73 84.73,94.65 83.37,94.65 v3(83.04,94.98)
  IN2 w0.076: 78.9,109.21 78.9,109.64 78.48,110.07 78.48,112.59 v3(78.73,112.85)
  IN2 w0.094: 78.9,109.21 78.9,106.72 80.45,105.18 80.45,103.59 80.8,103.23 80.8,100.67 81.6,99.87 81.6,98.85 81.94,98.51 82.75,98.51 82.89,98.64 83.24,98.64 83.84,98.04 84.06,98.04 84.25,97.86 84.25,97.31 82.71,95.77 82.71,95.31 v3(83.04,94.98)
DDR_B_CA2_7: length 26.6
  TOP w0.076: v3(80.04,113.84) 79.86,114.02 UCPU1.AW46 ; v3(83.84,94.98) 85.04,94.98 85.66,94.36 RD56.1
  IN2 w0.076: 79.75,112.52 79.52,112.75 79.52,113.5 79.86,113.84 v3(80.04,113.84)
  IN2 w0.094: 79.75,112.52 80.61,112.52 81.39,111.74 81.39,107.82 82.77,106.43 82.77,105.67 85.33,103.11 85.33,100.28 85.56,100.05 85.56,96.7 v3(83.84,94.98)
DDR_B_CA2_8: length 26.9
  TOP w0.076: v3(83.84,94.33) 84.66,94.33 85.84,93.16 RD58.1
  IN2 w0.094: v3(83.84,94.33) 83.85,94.32 83.99,94.32 86.65,96.99 86.65,97.43 86.12,97.96 86.12,100.29 85.95,100.46 85.95,103.3 83.34,105.9 83.34,106.8 81.98,108.16 81.98,110.88 81.92,110.94 81.92,111.71 80.13,113.5 v3(79.86,113.5)
DDR_B_CA2_9: length 26.9
  TOP w0.076: v3(83.84,93.68) 84.73,93.68 85.83,92.58 RD60.1
  IN2 w0.094: v3(79.76,112.85) 80.53,112.85 81.67,111.7 81.67,107.93 83.05,106.55 83.05,105.79 85.66,103.18 85.66,100.35 85.84,100.17 85.84,96.58 84.75,95.49 83.88,94.62 83.71,94.62 83.49,94.4 83.49,94.04 v3(83.84,93.68)
DDR_B_CKE0: length 38
  TOP w0.076: v7(85.45,117.57) 85.79,117.91 UCPU1.AN56
  IN4 w0.069: v1(83.04,96.93) 81.97,96.93 81.44,97.47 81.44,98.9 80.99,99.34 80.99,100.3 79.98,101.32 79.98,102.09 79.63,102.44 79.63,103.82 78.67,104.78 78.67,109.11 78.58,109.2 78.58,110.86 76.24,113.2 76.24,114.13 76.59,114.48 78.09,114.48 78.28,114.68 78.28,116.26 78.79,116.77 79.53,116.77 79.56,116.74 80.46,116.74 81.34,117.62 85.02,117.62 85.07,117.57 85.45,117.57 v7(85.45,117.57)
  BOTTOM w0.076: v1(83.04,96.93) 83.35,97.25 84.02,97.25 84.81,98.04 85.51,98.04 85.84,97.71 85.84,96.97 86.1,96.71 RD66.1
DDR_B_CKE1: length 38.8
  TOP w0.076: UCPU1.AP55 84.96,117.26 v7(84.54,116.83)
  IN4 w0.069: v7(84.54,116.83) 84.07,117.3 81.45,117.3 80.63,116.48 79.46,116.48 79.43,116.51 78.9,116.51 78.65,116.27 78.65,114.68 78.2,114.22 76.7,114.22 76.5,114.03 76.5,113.34 78.84,111 78.84,109.31 79,109.14 79,107.86 79.59,107.27 79.59,104.23 79.89,103.93 79.89,102.54 80.23,102.2 80.23,101.47 80.82,100.88 81.17,100.88 81.79,100.27 81.79,97.64 82.19,97.23 83.12,97.23 83.44,96.91 v1(83.44,96.65)
  BOTTOM w0.076: UD3.K4 82.53,96.65 v1(83.44,96.65) 83.96,96.65 84.29,96.97 84.29,97.3 84.88,97.89 85.45,97.89 85.62,97.71 85.62,96.85 86.39,96.08 RD68.1
DDR_B_CKE2: length 35.4
  TOP w0.076: RD70.1 86.58,98.74 86.12,98.28 86.12,98.03 85.26,97.17 84.73,97.17 84.02,97.88 83.39,97.88 v3(83.04,98.23)
  IN2 w0.076: v3(84.99,117.91) 84.99,117.84 84.44,117.29 81.66,117.29 80.63,116.25 80.04,116.25 79.55,115.76 79.55,115.46 78.24,114.15 78.24,109.69 78.51,109.42
  IN2 w0.094: v3(83.04,98.23) 82.91,98.1 81.78,98.1 81.2,98.68 81.2,99.7 80.41,100.5 80.41,103.07 80.05,103.43 80.05,103.95 78.71,105.29 78.71,105.42 78.84,105.55 78.97,105.55 79.77,104.76 79.9,104.76 80.03,104.89 80.03,105.02 78.51,106.55 78.51,109.42
DDR_B_CKE3: length 36.6
  TOP w0.076: UD1.K4 81.83,97.83 v3(81.83,97.51) ; v3(84.33,117.54) 84.07,117.29 UCPU1.AP53
  IN1 w0.107: v8(86.96,99.32) 85.57,97.92 84.22,97.92 84.15,97.99 83.32,97.99 83.25,97.92 82.11,97.92 81.83,97.65 v3(81.83,97.51)
  IN2 w0.076: v3(84.33,117.54) 81.41,117.54 80.55,116.68 79.11,116.68 78.08,115.65 78.08,109.56 78.22,109.42
  IN2 w0.094: 78.22,109.42 78.22,107.67 78,107.45 78,107.29 78.21,107.09 78.21,106.91 78,106.7 78,106.49 78.1,106.4 78.24,106.4 78.34,106.3 78.34,106.11 78.24,106.02 78.1,106.02 78,105.93 78,105.74 78.1,105.64 78.31,105.64 78.4,105.55 78.4,105.36 78.31,105.27 78.1,105.27 78,105.17 78,105.07 78.42,104.65 78.55,104.65 78.67,104.77 78.81,104.77 78.94,104.64 78.94,104.5 78.82,104.38 78.82,104.25 78.95,104.12 79.09,104.12 79.21,104.24 79.34,104.24 79.47,104.11 79.47,103.97 79.35,103.85 79.35,103.72 80.12,102.95 80.12,100.38 80.89,99.61 80.89,98.59 81.43,98.06 81.43,97.63 81.55,97.51 v3(81.83,97.51)
DDR_B_CLK0: length 33.6
  TOP w0.076: UCPU1.AP45 v7(79.07,117.69)
  IN3 w0.094: v7(79.07,117.69) 79.07,117.8 78.88,117.99 78.54,117.99 78.44,117.9 78.44,113.02 78.15,112.73 78.15,107.56 78.38,107.33 78.38,107.07 77.96,106.64 77.96,106.51 78.16,106.31 78.29,106.31 78.72,106.73 78.98,106.73 79.27,106.44 79.27,106.18 78.8,105.72 78.8,105.58 79,105.38 79.13,105.38 79.6,105.85 79.86,105.85 80.33,105.38 80.33,99.63 82.85,97.11 83.43,97.11 83.58,97.26 83.58,97.49 83.34,97.73 83.19,97.73 v5(83.04,97.58)
  BOTTOM w0.076: v5(83.04,97.58) 83.28,97.58 83.61,97.91 84.18,97.91 85.78,99.5 86.57,99.5 RD76.1
DDR_B_CLK1: length 32.7
  TOP w0.076: v3(83.04,97.58) 83.38,97.25 84.07,97.25 84.48,96.84 85.42,96.84 86.31,97.73 86.71,97.73 RD80.1
  IN2 w0.094: v3(80.42,117.26) 80.53,117.37 80.53,117.51 80.37,117.67 80.26,117.67 80.2,117.73 79.98,117.73 79.23,116.99 79,116.99 77.82,115.81 77.82,107.84 77.6,107.62 77.6,104.9 79.72,102.78 79.72,100.22 80.49,99.45 80.49,98.43 80.58,98.33 80.58,97.06 81.06,96.59 82.74,96.59 83.49,97.34 83.49,97.49 83.4,97.58 v3(83.04,97.58)
DDR_B_CLK#0: length 32.8
  TOP w0.076: v7(79.08,118.28) 79.45,117.91 UCPU1.AN45
  IN3 w0.094: v7(79.08,118.28) 78.94,118.15 78.47,118.15 78.29,117.96 78.29,113.08 78,112.8 78,107.49 78.23,107.26 78.23,107.13 77.8,106.71 77.8,106.45 78.09,106.15 78.35,106.15 78.78,106.58 78.91,106.58 79.11,106.38 79.11,106.25 78.64,105.78 78.64,105.52 78.94,105.23 79.2,105.23 79.66,105.69 79.8,105.69 80.17,105.32 80.17,99.57 82.79,96.96 83.5,96.96 83.74,97.2 83.74,97.48 v5(83.84,97.58)
  BOTTOM w0.076: RD78.1 86.57,99.32 85.85,99.32 84.26,97.73 83.98,97.73 v5(83.84,97.58)
DDR_B_CLK#1: length 31.9
  TOP w0.076: v3(83.84,97.58) 83.99,97.58 84.55,97.02 85.34,97.02 86.23,97.91 86.76,97.91 RD82.1
  IN2 w0.094: v3(83.84,97.58) 83.72,97.58 83.65,97.51 83.65,97.27 82.81,96.43 80.99,96.43 80.43,96.99 80.43,98.27 80.34,98.36 80.34,99.38 79.57,100.15 79.57,102.72 77.45,104.84 77.45,107.68 77.67,107.9 77.67,115.88 78.93,117.14 79.17,117.14 79.91,117.89 80.39,117.89 v3(80.42,117.91)
DDR_B_CS#0: length 40.7
  TOP w0.076: UD1.L3 83.36,98.57 84.35,98.57 84.72,98.2 85.06,98.2 85.44,98.59 85.58,98.59 85.73,98.44 85.73,98.27 85.08,97.62 v7(85.08,97.52) ; UCPU1.BB42 77.58,112.02 77.58,111.2 v7(77.25,110.87)
  IN4 w0.069: v7(77.25,110.87) 77.38,110.73 77.8,110.73 77.93,110.61 77.93,110.46 77.86,110.39 77.45,110.39 77.38,110.33 77.38,110.19 77.45,110.12 78.12,110.12 78.19,110.05 78.19,109.91 78.12,109.85 77.63,109.85 77.56,109.78 77.56,109.64 77.63,109.57 78.12,109.57 78.19,109.5 78.19,109.37 78.12,109.3 77.41,109.3 77.34,109.23 77.34,109.09 77.41,109.02 78.12,109.02 78.19,108.95 78.19,108.82 78.12,108.75 77.34,108.75 77.27,108.68 77.27,108.54 77.34,108.47 78.12,108.47 78.19,108.41 78.19,108.27 78.12,108.2 77.63,108.2 77.56,108.13 77.56,107.99 77.63,107.93 78.12,107.93 78.28,107.77 78.28,104.65 79.26,103.66 79.26,102.28 79.6,101.94 79.6,100.44 80.33,99.72 80.33,97.44 81.23,96.54 82.35,96.54 82.63,96.27 83.84,96.27 v7(85.08,97.52)
  BOTTOM w0.076: RD62.1 85.29,96.6 85.29,97.31 v7(85.08,97.52) 84.94,97.37 84.94,95.68 84.58,95.33 83.71,95.33 83.42,95.62 83.42,95.9 UD3.L3
DDR_B_CS#1: length 42.4
  TOP w0.076: v7(76.88,113.81) 77.2,113.5 UCPU1.AY42 ; v7(84.76,99.23) 85.98,100.46 RD64.1
  IN1 w0.107: v8(82.24,98.88) 82.57,98.88 82.68,98.99 83.11,98.99 83.32,98.77 84.33,98.77 84.56,98.54 84.96,98.54 85.13,98.71 85.61,98.71 85.69,98.78 85.69,99.13 85.58,99.23 v7(84.76,99.23)
  IN4 w0.069: v7(84.76,99.23) 84.12,99.23 83.53,99.82 82.91,99.82 82.61,100.12 82.61,100.95 81.77,101.8 81.13,101.8 81.02,101.91 81.02,102.17 80.74,102.45 80.52,102.45 80.26,102.7 80.26,104.08 79.97,104.37 79.97,108.71 80.76,109.49 80.76,109.93 79.15,111.54 79.15,111.64 79.68,112.17 79.68,112.27 79.58,112.36 79.49,112.36 78.96,111.83 78.86,111.83 78.76,111.93 78.76,112.03 79.37,112.63 79.37,112.73 79.27,112.83 79.18,112.83 78.57,112.22 78.47,112.22 78.37,112.32 78.37,112.42 79.06,113.1 79.06,113.2 78.97,113.3 78.87,113.3 78.18,112.61 78.08,112.61 77.99,112.71 77.99,112.8 78.65,113.47 78.65,113.56 78.55,113.66 78.45,113.66 77.79,113 77.69,113 77.6,113.09 77.6,113.19 78.05,113.65 78.05,113.74 77.96,113.84 77.86,113.84 77.4,113.39 77.31,113.39 v7(76.88,113.81)
  BOTTOM w0.076: UD3.L4 81.88,96.64 81.88,97.66 82.11,97.89 83.22,97.89 83.45,98.12 83.45,98.25 83.74,98.54 84.29,98.54 84.76,99.01 v7(84.76,99.23)
DDR_B_D0: length 13.5
  TOP w0.076: v3(76.36,113.18) 76.13,113.41 UCPU1.AY39
  IN2 w0.076: v3(76.36,113.18) 76.29,113.11 76.29,108.95
  IN2 w0.094: v3(79.04,101.48) 78.53,101.99 78.53,102.19 78.24,102.49 77.79,102.49 77.41,102.87 77.41,103.06 77.06,103.4 77.06,103.57 76.35,104.28 76.35,108.69 76.29,108.75 76.29,108.95
DDR_B_D1: length 13.6
  IN2 w0.076: v3(76.13,114.15) 76.13,113.87 76.6,113.4 76.6,113.04 76.44,112.88 76.44,109.21 76.63,109.02 76.63,109.01
  IN2 w0.094: 76.63,109.01 76.69,108.95 76.69,104.39 77.51,103.57 77.98,103.57 78.23,103.31 78.23,102.94 v3(79.04,102.13)
DDR_B_D2: length 12.5
  IN2 w0.076: 74.9,113.39 75.04,113.25 75.04,112.02 74.98,111.95
  IN2 w0.094: 74.9,113.39 v3(74.9,113.5) ; v3(76.64,102.13) 76.2,102.13 74.83,103.5 74.83,108.81 74.98,108.95 74.98,111.95
DDR_B_D3: length 15.8
  IN2 w0.076: 74.26,109.13 74.35,109.22 74.35,113.6 v3(74.9,114.15)
  IN2 w0.094: 74.26,109.13 73.98,108.84 73.98,103.1 75.84,101.23 77.19,101.23 v3(77.44,101.48)
DDR_B_D4: length 12
  TOP w0.076: v3(75.82,111.75) 76.13,112.06 UCPU1.BB39
  IN2 w0.076: v3(78.24,101.48) 78.24,101.56 76.74,103.06
  IN2 w0.094: 76.74,103.06 76.66,103.06 75.79,103.93 75.79,108.62 75.73,108.68 75.73,111.66 v3(75.82,111.75)
DDR_B_D5: length 12.1
  TOP w0.076: UCPU1.BA39 76.39,112.58 76.39,111.76 v3(75.98,111.35)
  IN2 w0.094: v3(75.98,111.35) 75.98,108.66 76.07,108.57 76.07,104.07 77.15,102.98 77.15,102.88 77.91,102.13 v3(78.24,102.13)
DDR_B_D6: length 12.9
  IN2 w0.094: v3(76.64,101.48) 76,101.48 74.26,103.22 74.26,108.87 74.53,109.14 74.53,112.57 v3(74.8,112.85)
DDR_B_D7: length 12.6
  TOP w0.076: UD1.T10 77.37,102.13 v3(77.11,101.87)
  IN2 w0.076: 74.8,109.16 v3(74.8,112.19)
  IN2 w0.094: v3(77.11,101.87) 76.04,101.87 74.55,103.36 74.55,108.91 74.8,109.16
DDR_B_D8: length 23.1
  TOP w0.076: v3(77.74,99.26) 77.47,99.53 UD1.M10 ; UCPU1.AY35 73.55,113.5 v3(73.37,113.68)
  IN2 w0.076: 75,98.98 76.2,98.98 76.54,98.64 77.54,98.64 77.74,98.85 v3(77.74,99.26) ; 71.4,108.45 71.4,109.21 72.77,110.58 72.77,112.86 72.72,112.92 72.72,113.87 72.91,114.06 73.11,114.06 73.25,113.92 73.25,113.79 v3(73.37,113.68)
  IN2 w0.094: 71.4,108.45 71.4,100.97 73.13,99.24 74.54,99.24 74.8,98.98 75,98.98
DDR_B_D9: length 19.5
  IN2 w0.076: v3(73.67,114.15) 74.01,114.15 74.14,114.01 74.14,110.27 73.44,109.57
  IN2 w0.094: 73.44,109.57 73.44,108.91 73.58,108.76 73.58,108.49 73.49,108.4 73.32,108.4 73.22,108.3 73.22,108.11 73.32,108.02 73.49,108.02 73.58,107.93 73.58,107.74 73.49,107.64 73.32,107.64 73.22,107.55 73.22,107.36 73.32,107.27 73.49,107.27 73.58,107.18 73.58,106.99 73.49,106.89 73.32,106.89 73.22,106.8 73.22,106.61 73.32,106.52 73.49,106.52 73.58,106.42 73.58,102.93 76.07,100.43 78.14,100.43 78.24,100.53 v3(78.24,100.83)
DDR_B_D10: length 23.9
  TOP w0.076: v3(78.46,99.25) 78.24,99.47 UD1.M9
  IN2 w0.076: v3(72.45,113.5) 72.45,113.36 71.6,112.51 71.6,111.97 71.44,111.82 71.44,110.14 70.54,109.24 70.54,108.45
  IN2 w0.094: v3(78.46,99.25) 78.3,99.09 78.3,98.74 77.61,98.05 74.33,98.05 74.17,97.89 73.27,97.89 70.54,100.62 70.54,108.45
DDR_B_D11: length 19.2
  TOP w0.076: UD1.M11 76.43,99.53 v3(76.25,99.71)
  IN2 w0.076: 72.37,109.14 72.37,109.41 73.34,110.39 73.34,112.75 73.79,113.2 73.79,113.69 73.26,114.21 72.52,114.21 v3(72.45,114.15)
  IN2 w0.094: 72.37,109.14 72.37,102.02 73.08,101.3 74,101.3 75.58,99.71 v3(76.25,99.71)
DDR_B_D12: length 17
  IN2 w0.076: v3(73.77,112.19) 73.77,110.28 73.53,110.03
  IN2 w0.094: 73.53,110.03 72.93,109.44 72.93,106.27 73.03,106.18 73.2,106.18 73.29,106.09 73.29,105.9 73.2,105.8 73.03,105.8 72.93,105.71 72.93,105.52 73.03,105.43 73.2,105.43 73.29,105.33 73.29,105.15 73.2,105.05 73.03,105.05 72.93,104.96 72.93,104.77 73.03,104.68 73.2,104.68 73.29,104.58 73.29,104.39 73.2,104.3 73.03,104.3 72.93,104.21 72.93,104.02 73.03,103.92 73.2,103.92 73.29,103.83 73.29,103.64 73.2,103.55 73.03,103.55 72.93,103.45 72.93,103.16 73.14,102.96 73.14,102.78 72.94,102.58 72.94,102.45 73.08,102.32 73.21,102.32 73.41,102.51 73.59,102.51 75.92,100.18 v3(76.64,100.18)
