# Allegro board Dell Latitude 5290 2-IN-1 LA-F371P Boardview.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+VCCIA_GT on BOTTOM (solid shape): 83.74,134.96 83.74,133.49 83.21,132.96 82.55,132.96 82.45,132.86 82.45,131.31 82.68,131.08 82.68,128.44 82.65,128.41 82.49,128.41 82.27,128.19 82.27,126.53 82.98,125.82 82.98,125.16 83.08,125.06 83.09,125.06 83.35,124.8 83.35,123.71 83.01,123.37 83.01,122.65 82.19,121.84 82.19,120.38 82.35,120.23 83.26,120.23 83.39,120.11 83.39,119.39 83.24,119.24 83.24,118.76 83.19,118.71 82.19,118.71 82.14,118.76 82.14,119.72 82.07,119.8 81.43,119.8 81.38,119.75 81.38,119.29 81.36,119.27 78.71,119.27 78.69,119.29 78.69,119.78 78.79,119.88 79.38,119.88 79.76,120.26 80.82,120.26 80.98,120.41 80.98,121.93 80.63,122.28 80.51,122.28 80.47,122.32 80.47,126 80.95,126.48 80.95,128.21 80.85,128.31 79.98,128.31 79.81,128.49 79.81,129.52 81.17,129.52 81.17,130.66 80.58,130.66 80.58,129.52 79.81,129.52 79.81,131.97 79.93,132.09 80.54,132.09 80.67,132.22 80.67,133.24 81.43,134 81.43,135.02 81.56,135.14 83.57,135.14
+VCCIA_GT on IN2 (solid shape): 79.3,120.23 82.63,120.23 82.79,120.07 82.79,119.94 82.68,119.83 78.13,119.83 78.05,119.9 78.05,120.31 78.16,120.41 79.12,120.41
+VCCIA_GT on IN2 (solid shape): 81.89,130.01 81.89,129.66 81.33,129.1 81.18,129.1 81.03,129.25 80.82,129.25 80.7,129.38 80.7,129.53 80.8,129.63 81.25,129.63 81.58,129.96 81.58,129.99 81.69,130.09 81.81,130.09
+VCCIA_GT on IN3 (solid shape): outline of 242 points within 78.71,119.42 83.33,135.02
+VCCIA_GT on VCC: 78.87,119.32 78.87,130.39 79.61,131.13 82.57,131.13 83.06,130.64 83.06,119.32
+VCCPLL_OC on IN1 (solid shape): outline of 323 points within 64.83,114.17 67.44,119.19
+VSS_PLL on BOTTOM (solid shape): 25.96,106.93 25.96,105.53 25.76,105.33 25.05,105.33 24.92,105.47 24.92,106.48 25.42,106.97 25.92,106.97
AGND on VCC: 13.08,145.61 13.08,154.98 12.3,155.77 8.36,155.77 6.35,157.78 6.35,161.84 5.06,163.13 0.28,163.13 0.26,163.11 0.26,173.5 0.26,173.78 0.29,174.06 14.63,174.06 16.51,172.17 16.51,161 22.5,155.01 34.8,155.01 34.8,149.85 33.73,148.78 28.72,148.78 28.34,148.4 27.18,148.4 27.18,149.65 26.78,150.05 22.25,150.05 21.84,149.65 21.84,146.09 21.61,145.86 20.6,145.86 20.34,145.61
AGND on GND3: 12.3,155.77 8.36,155.77 6.35,157.78 6.35,161.84 5.06,163.13 0.26,163.13 0.26,173.5 0.26,173.78 0.29,174.06 0.81,174.06 0.81,174.04 1.02,173.69 1.4,173.55 2.01,173.55 2.39,173.69 2.6,174.04 2.6,174.06 3.38,174.06 3.6,173.83 3.9,173.75 4.51,173.75 4.81,173.83 5.03,174.06 14.63,174.06 16.51,172.17 16.51,161 22.5,155.01 34.57,155.01 34.8,154.77 34.8,151.22 36.2,149.82 36.2,147.62 36.09,147.51 34.67,147.51 34.67,148.38 34.27,148.78 28.72,148.78 28.34,148.4 27.18,148.4 27.18,149.65 26.78,150.05 22.25,150.05 21.84,149.65 21.84,146.09 21.61,145.86 20.6,145.86 20.34,145.61 13.57,145.61 13.34,145.84 13.34,145.85 13.38,146.2 13.08,146.38 13.08,153.84 13.1,153.87 13.12,153.86 13.67,154.12 13.12,154.37 13.1,154.37 13.08,154.39 13.08,154.98
DV12S on BOTTOM (solid shape): 67.88,38.55 67.88,36.7 68.07,36.51 68.07,34.86 68.01,34.8 67.88,34.8 67.82,34.86 67.82,35.88 67.25,36.45 67.25,38.55 67.31,38.61 67.82,38.61
DV12S on BOTTOM (solid shape): 70.61,38.42 70.61,36.64 69.72,35.75 69.72,34.86 69.66,34.8 69.47,34.8 69.41,34.86 69.41,36.03 69.59,36.21 69.84,36.3 69.94,36.56 69.95,36.56 69.95,36.87 69.98,36.9 69.98,38.42 70.04,38.48 70.55,38.48
DV33_18 on BOTTOM (solid shape): 72.9,35.89 72.9,35.45 72.8,35.35 72.42,35.35 72.24,35.17 72.24,34.77 71.59,34.12 71.01,34.12 70.88,34.12 70.87,34.11 70.6,34.11 70.56,34.16 70.56,34.26 70.61,34.32 70.87,34.32 70.88,34.3 71.01,34.3 71.45,34.3 71.75,34.6 71.75,35.42 72.3,35.97 72.83,35.97
GND on TOP (solid shape): 54.8,35.16 46.8,35.16 46.8,43.16 54.8,43.16
GND on TOP (solid shape): 55.77,45.03 45.77,45.03 45.77,60.03 55.77,60.03
GND on TOP (solid shape): 65.35,23.6 57.35,23.6 57.35,31.6 65.35,31.6
GND on TOP (solid shape): 66.26,166.6 53.55,166.6 53.55,167.6 66.26,167.6
GND on TOP (solid shape): 102.58,166.6 69.06,166.6 69.06,167.6 102.58,167.6
GND on TOP (solid shape): 16.2,99.02 16.2,97.03 15.47,96.3 14.66,96.3 14.61,96.35 14.61,98.98 14.88,99.25 15.97,99.25
GND on TOP (solid shape): 37.74,99.5 37.74,97.86 37.51,97.63 36.68,97.63 36.61,97.7 36.61,99.46 36.69,99.54 37.7,99.54
GND on TOP (solid shape): 61.58,150.05 61.58,148.24 61.39,148.05 56.55,148.05 56.32,148.27 56.32,150.15 56.5,150.33 61.3,150.33
GND on TOP (solid shape): 70.08,66.05 70.08,64.3 69.99,64.22 69.34,64.22 69.3,64.26 69.3,66.08 69.37,66.15 69.99,66.15
GND on TOP (solid shape): 71.23,152.21 71.23,148.3 70.98,148.05 66.23,148.05 65.98,148.3 65.98,152.31 66.15,152.49 70.95,152.49
GND on TOP (solid shape): 71.89,95.41 71.89,93.07 71.82,93 71.28,93 71.22,93.06 71.22,95.34 71.32,95.44 71.86,95.44
GND on TOP (solid shape): 71.97,63.58 71.97,61.23 71.87,61.13 70.52,61.13 70.45,61.2 70.45,63.4 70.66,63.6 71.94,63.6
GND on TOP (solid shape): 71.99,99.91 71.99,96.74 71.95,96.7 71.37,96.7 71.34,96.74 71.34,99.89 71.4,99.96 71.94,99.96
GND on TOP (solid shape): 73.5,71.5 73.5,68.05 73.38,67.93 72.37,67.93 72.17,68.13 72.17,71.19 72.52,71.54 73.46,71.54
GND on TOP (solid shape): 75.27,68.6 75.27,66.6 75.17,66.5 73.92,66.5 73.77,66.65 73.77,68.65 73.82,68.7 75.17,68.7
GND on TOP (solid shape): 76.17,54.64 76.17,53.15 76.01,52.99 73.96,52.99 73.89,53.06 73.89,54.67 74.02,54.8 76.01,54.8
GND on TOP (solid shape): 76.72,106.32 76.72,105.61 76.68,105.57 73.21,105.57 73.18,105.59 73.18,106.37 73.24,106.43 76.61,106.43
GND on TOP (solid shape): 82.46,108.08 82.46,107.44 82.45,107.43 80.12,107.43 80.09,107.45 80.09,108.05 80.18,108.14 82.4,108.14
GND on TOP (solid shape): 88.19,152.15 88.19,148.24 87.93,147.98 83.19,147.98 82.93,148.24 82.93,152.25 83.11,152.43 87.91,152.43
GND on TOP (solid shape): 88.4,90.98 88.4,89.76 88.19,89.56 87.54,89.56 87.52,89.58 87.52,91.01 87.55,91.03 88.34,91.03
GND on TOP (solid shape): 103.66,152.67 103.66,147.92 103.4,147.66 99.39,147.66 99.21,147.84 99.21,152.64 99.49,152.92 103.4,152.92
GND on TOP (solid shape): 104.22,128.11 104.22,126.43 103.89,126.1 99.44,126.1 99.19,126.35 99.19,128.23 99.34,128.39 103.94,128.39
GND on TOP (solid shape): 108.33,107.89 108.33,105.92 108.2,105.79 107.06,105.79 107,105.86 107,107.95 107.06,108.02 108.2,108.02
GND on TOP (solid shape): 110.11,101.22 110.11,100.2 109.79,99.89 107.44,99.89 107.25,100.08 107.25,101.16 107.38,101.28 110.05,101.28
GND on TOP (solid shape): 117.22,108.52 117.22,106.62 117.09,106.49 116.27,106.49 116.14,106.62 116.14,108.52 116.27,108.65 117.09,108.65
GND on TOP (solid shape): 122.05,111.95 122.05,111.19 121.79,110.94 117.22,110.94 116.97,111.19 116.97,112.08 117.22,112.33 121.67,112.33
GND on TOP (solid shape): 122.3,108.59 122.3,106.62 122.17,106.49 121.35,106.49 121.22,106.62 121.22,108.52 121.35,108.65 122.24,108.65
GND on TOP (solid shape): 124.52,138.8 124.52,136.51 124.4,136.39 123.25,136.39 123.13,136.51 123.13,138.8 123.25,138.93 124.4,138.93
GND on TOP (solid shape): 125.09,103.63 125.09,102.55 124.97,102.43 122.75,102.43 122.68,102.49 122.68,103.57 122.94,103.82 124.9,103.82
GND on TOP (solid shape): 126.05,139.38 126.05,138.05 124.65,138.05 124.65,139.38 124.84,139.57 125.86,139.57
GND on TOP (solid shape): 128.59,128.65 128.59,126.94 128.4,126.75 127.38,126.75 127.25,126.87 127.25,128.59 127.38,128.72 128.52,128.72
GND on TOP (solid shape): 132.19,93.27 132.19,92.14 132.12,92.07 130.73,92.07 130.71,92.09 130.71,93.46 130.81,93.56 131.9,93.56
GND on TOP (solid shape): 136.19,93.61 136.19,92.14 136.11,92.06 135.57,92.06 135.51,92.12 135.51,93.52 135.67,93.68 136.12,93.68
GND on TOP (solid shape): 11.7,112.05 14.86,106.35 35.6,106.35 35.6,121.2 36.4,121.2 36.4,105.55 14.39,105.55 10.9,111.84 10.9,121.2 11.7,121.2
GND on TOP (solid shape): 12.86,103.9 12.86,102.39 13.12,102.13 13.12,101.1 13.08,101.06 12.24,101.06 12.14,101.17 12.14,103.87 12.23,103.96 12.8,103.96
GND on TOP (solid shape): 75.21,79.2 75.18,79.17 71.48,79.17 71.41,79.24 71.41,79.77 71.49,79.85 72.47,79.85 72.61,79.99 72.61,81.8 75.21,81.8
GND on TOP (solid shape): 99.92,143.78 99.92,140.96 99.58,140.61 92.28,140.61 92.23,140.66 92.23,143.7 92.58,144.06 99.64,144.06
GND on TOP (solid shape): 110.45,88.81 110.45,87.79 110.34,87.68 108.09,87.68 108,87.76 108,88.77 108.15,88.91 110.35,88.91
GND on TOP (solid shape): 112.68,147.45 112.68,137.06 112.59,136.97 111.18,136.97 110.92,137.23 110.92,147.46 111.12,147.66 112.46,147.66
GND on TOP (solid shape): 121.79,132.78 121.79,129.61 121.41,129.22 120.65,129.22 120.52,129.35 120.52,132.91 120.65,133.03 121.54,133.03
GND on TOP (solid shape): 135.81,90.15 135.81,89.03 135.88,88.96 135.88,88.7 135.8,88.62 135.55,88.62 135.11,89.06 135.11,90.17 135.18,90.23 135.73,90.23
GND on TOP (solid shape): 141.53,142.38 141.53,141.97 141.39,141.84 140.06,141.84 139.89,141.67 139.89,140.87 138.18,140.87 138.18,142.6 141.31,142.6
GND on TOP (solid shape): 9.67,35.33 9.67,34.17 9.4,33.9 7.8,33.9 6.99,33.09 5.62,33.09 5.53,33.18 5.53,34.89 6.08,35.43 9.56,35.43
GND on TOP (solid shape): 49.47,146.62 49.47,145.73 49.59,145.61 50.42,145.61 50.42,143.83 48.64,143.83 48.64,146.69 48.7,146.75 49.34,146.75
GND on TOP (solid shape): 133.48,148.21 133.48,145.67 133.39,145.58 132.33,145.58 132.21,145.7 132.21,148.15 132.33,148.27 133.41,148.27
GND on TOP (solid shape): 50.27,163.67 50.27,159.86 50.06,159.65 49.05,159.65 48.94,159.76 48.94,163.76 48.98,163.81 50.14,163.81
GND on TOP (solid shape): 71.53,104.81 71.53,102.77 71.9,102.4 72.86,102.4 72.93,102.33 72.93,101.66 72.79,101.51 70.8,101.51 70.69,101.62 70.69,104.75 70.86,104.92 71.42,104.92
GND on TOP (solid shape): 76.43,109.71 76.43,108.98 77.36,108.06 77.36,107.75 77.22,107.62 76.94,107.62 76.47,108.09 75.88,108.09 75.85,108.11 75.85,109.72 75.88,109.75 76.39,109.75
GND on TOP (solid shape): 123.7,129.61 123.7,128.53 123.83,128.4 124.65,128.4 124.65,126.68 122.94,126.68 122.94,128.59 122.24,129.29 122.24,129.99 122.34,130.09 123.22,130.09
GND on TOP (solid shape): 129.6,151.7 114.5,151.7 114.5,170.47 115.3,170.47 115.3,152.5 128.8,152.5 128.8,177.2 115.3,177.2 115.3,170.47 114.5,170.47 114.5,178 129.6,178
GND on TOP (solid shape): 145.73,122.92 145.73,122.49 145.67,122.43 145.1,122.43 144.91,122.62 138.75,122.62 138.68,122.68 138.68,123.26 138.81,123.38 145.27,123.38
GND on TOP (solid shape): 61.09,158.12 62.01,158.12 62.19,157.94 62.19,157.51 61.09,156.4 56.94,156.4 56.81,156.53 56.81,158.05 56.9,158.13 61.09,158.13
GND on TOP (solid shape): 70.82,51.38 70.82,49.42 70.68,49.28 69.28,49.28 69.02,49.53 69.02,49.53 69.02,51.12 69.12,51.22 69.35,51.22 69.65,51.51 70.68,51.51
GND on TOP (solid shape): 82.4,152.41 92.15,152.41 94.11,150.46 94.11,147.92 93.9,147.72 56.62,147.72 56.26,148.07 56.26,150.2 56.41,150.36 60.81,150.36 62.94,152.49 71.02,152.49 74.63,156.1 78.71,156.1
GND on TOP (solid shape): 119.76,148.68 119.76,146.78 119.51,146.52 119.51,144.62 119.38,144.49 119.25,144.49 119.13,144.62 119.13,145.63 118.75,146.01 118.24,146.01 117.86,146.39 117.86,148.55 118.11,148.81 119.63,148.81
GND on TOP (solid shape): 94.49,107.34 94.49,106.85 94.41,106.77 91.32,106.77 90.92,106.37 90.49,106.37 90.48,106.38 90.48,106.76 90.5,106.78 90.86,106.78 90.96,106.87 90.96,107.22 91.12,107.39 94.44,107.39
GND on TOP (solid shape): 119.19,121.86 119.19,118.49 118.94,118.24 118.94,117.67 118.81,117.54 118.68,117.54 118.55,117.67 118.55,118.68 118.36,118.87 117.28,118.87 117.13,119.03 117.13,119.08 116.9,119.31 116.9,121.86 117.09,122.05 119,122.05
GND on TOP (solid shape): 134.87,128.79 134.87,128.14 135.1,127.92 136.33,127.92 136.33,127.9 137.1,127.9 137.1,127.92 137.31,127.92 137.6,127.62 137.6,125.35 136.78,124.53 134.37,124.53 133.35,125.54 133.35,128.97 133.41,129.03 134.63,129.03
GND on TOP (solid shape): 136.78,99.76 136.78,97.47 136.53,97.22 126.81,97.22 126.62,97.41 126.62,97.88 126.85,98.11 129.46,98.11 129.97,98.62 129.97,99.25 130.66,99.94 131.11,99.94 131.13,99.95 136.59,99.95
GND on TOP (solid shape): 130.2,124.17 130.2,121.63 129.9,121.32 129.57,121.32 129.54,121.35 126.62,121.35 126.61,121.36 126.36,121.36 126.27,121.45 126.27,122.71 126.36,122.8 126.36,123.86 126.63,124.13 126.63,124.3 126.97,124.63 129.74,124.63
GND on TOP (solid shape): 55.46,148.22 55.46,147.09 53.82,145.45 53.82,144.16 53.75,144.08 53.21,144.08 53.09,144.21 53.09,146.69 53.4,147 53.92,147 54.23,147.31 54.23,148.32 54.37,148.46 55.22,148.46
GND on TOP (solid shape): 104.91,96.83 104.91,95.82 105.07,95.65 105.07,91.59 105.07,91.17 105.07,90.91 104.93,90.77 103.48,90.77 103.36,90.89 103.36,96.34 103.29,96.4 103.29,97 103.34,97.04 104.69,97.04
GND on TOP (solid shape): 129.1,142.62 129.1,142.43 128.91,142.24 128.91,141.1 129.48,140.53 129.48,139.64 128.91,139.07 128.91,138.21 128.83,138.13 128.28,138.13 128.19,138.21 128.19,140.64 128.65,141.09 128.65,142.16 128.59,142.22 128.59,142.62 128.71,142.75 128.97,142.75
GND on TOP (solid shape): 153.59,131.75 162.4,131.75 162.4,114.6 142.88,114.6 142.88,95.89 114.5,95.89 114.5,96.69 142.08,96.69 142.08,115.4 161.6,115.4 161.6,130.95 153.13,130.95 141.9,150.4 115.3,150.4 115.3,96.69 114.5,96.69 114.5,151.2 142.36,151.2
GND on TOP (solid shape): 115.28,153.51 128.97,153.51 128.97,152.47 130.54,152.47 130.54,150.47 115.23,150.47 115.23,95.89 113.8,95.89 113.8,155.55 106.36,155.55 105.83,156.08 105.83,162.98 105.94,163.09 106.08,163.09 106.74,162.43 108.17,162.43 108.98,163.25 115.28,163.25
GND on TOP (solid shape): 90.6,163.77 90.6,158.56 90.27,158.23 88.34,158.23 88.01,157.9 85.45,157.9 85.34,158 85.34,159.68 85.12,159.91 83.77,159.91 83.62,160.06 83.62,161.71 83.87,161.96 83.87,163.81 84.06,164 90.37,164
GND on TOP (solid shape): 101.93,161.96 101.93,156.78 101.8,156.66 100.58,156.66 100.28,156.35 100.28,155.31 100.15,155.18 98.09,155.18 97.99,155.28 97.99,156.96 97.76,157.19 96.39,157.19 96.27,157.32 96.27,159.12 96.42,159.27 98.35,159.27 98.58,159.5 98.58,162.22 98.63,162.27 101.63,162.27
GND on TOP (solid shape): 136.53,115.13 136.53,113.6 136.27,113.35 133.1,113.35 132.46,112.71 132.46,106.11 132.33,105.98 130.68,105.98 130.05,105.35 125.35,105.35 124.97,104.97 124.97,104.33 124.71,104.08 123.06,104.08 122.68,104.46 122.68,107.13 123.32,107.76 129.41,107.76 130.3,108.65 130.3,115.13 130.56,115.38 136.27,115.38
GND on TOP (solid shape): 46.58,154.18 46.58,152.93 46.8,152.72 49.29,152.72 49.81,152.2 49.81,150.92 49.71,150.81 46.48,150.81 46.35,150.94 46.35,152.02 46.16,152.21 46.16,154.16 46.25,154.25 46.51,154.25
GND on TOP (solid shape): 109.09,95.53 107.28,95.53 106.75,95.01 106.57,94.91 106.48,94.73 105.92,94.17 105.92,92.97 105.85,92.9 105.28,92.9 105.22,92.97 105.22,95.65 105.83,96.27 107.19,96.27 107.39,96.47 107.39,97.23 109.09,97.23
GND on TOP (solid shape): 6.05,29.26 6.45,29.11 6.85,29.26 7.56,29.26 7.7,29.12 7.7,28.86 7.57,28.74 6.58,28.74 6.47,28.63 5.69,28.63 5.49,28.83 5.49,29.08 5.67,29.26
GND on TOP (solid shape): 6.05,43.86 6.45,43.71 6.85,43.86 7.58,43.86 7.67,43.76 7.67,43.42 7.6,43.34 6.62,43.34 6.52,43.24 5.68,43.24 5.49,43.43 5.49,43.68 5.67,43.86
GND on TOP (solid shape): 6.61,38.16 7.59,38.16 7.66,38.09 7.66,37.76 7.54,37.64 6.95,37.64 6.45,37.87 5.95,37.64 5.65,37.64 5.49,37.79 5.49,38.07 5.69,38.26 6.5,38.26
GND on TOP (solid shape): 74.04,163.84 74.04,161.13 73.84,160.92 70.64,160.92 70.43,160.72 70.43,159.27 70.69,159.02 71.7,159.02 71.89,158.83 71.89,158.24 71.58,157.93 68.55,157.93 68.45,158.03 68.45,159.7 68.22,159.93 66.88,159.93 66.74,160.07 66.74,161.75 67.14,162.16 67.14,163.95 67.22,164.02 73.86,164.02
GND on TOP (solid shape): 6.62,23.55 7.57,23.55 7.66,23.46 7.66,23.06 7.62,23.02 6.96,23.02 6.45,23.27 5.94,23.02 5.66,23.02 5.48,23.2 5.48,23.51 5.65,23.68 6.5,23.68
GND on TOP (solid shape): 107.27,124.88 107.27,123.68 107.44,123.51 107.44,122 107.82,121.62 107.82,120.59 107.38,120.14 107.38,119.19 107.25,119.06 107.06,119.06 106.93,119.19 106.93,119.83 106.74,120.02 105.73,120.02 105.66,120.08 105.66,120.27 105.73,120.33 106.74,120.33 106.93,120.52 106.93,120.97 106.68,121.22 105.35,121.22 105.16,121.41 105.16,124.59 105.47,124.91 105.48,124.91 105.67,125.09 107.06,125.09
GND on TOP (solid shape): 67.81,131.49 67.81,131.43 66.88,130.5 66.88,130.23 66.96,130.14 66.96,129.81 66.8,129.66 66.6,129.66 66.47,129.78 66.47,130.21 66.54,130.31 66.57,130.43 66.58,130.65 66.47,130.83 66.47,130.9 66.5,131 66.47,131.1 66.47,131.49 66.6,131.62 67.68,131.62
GND on TOP (solid shape): 3.42,51.64 8.38,51.64 8.4,51.64 9.8,51.64 9.8,46.55 0.75,46.55 0.79,46.71 0.8,46.86 0.8,47.2 0.86,47.53 1.02,47.82 1.08,47.9 1.24,48.19 1.3,48.53 1.3,50.11 1.32,50.3 1.37,50.48 1.38,50.48 1.53,50.74 1.75,50.94 2.55,51.48 2.81,51.6 3.1,51.64
GND on TOP (solid shape): 69.52,131.59 69.72,131.41 69.99,131.43 70,131.43 70.09,131.43 70.28,131.62 70.46,131.62 70.47,131.59 70.61,131.44 70.81,131.39 70.83,131.39 71.04,131.18 71.04,131.11 71.02,131.02 71.02,130.26 70.93,130.18 70.76,130.18 70.66,130.28 70.66,130.91 70.66,130.92 70.47,131.11 70.46,131.11 70.1,131.11 69.91,130.92 69.73,130.92 69.68,130.96 69.63,131.01 69.63,131.02 69.27,131.38 69.27,131.56 69.33,131.62 69.5,131.62
GND on TOP (solid shape): 108.38,168.85 108.51,168.72 108.51,168.18 108.21,167.87 108.06,167.87 107.75,168.19 107.73,168.19 107.61,168.31 107.61,168.52 107.73,168.52 107.73,168.47 107.74,168.42 107.76,168.37 107.78,168.32 107.81,168.28 107.85,168.24 107.89,168.21 107.94,168.19 107.99,168.17 108.04,168.16 108.09,168.16 108.14,168.17 108.19,168.19 108.24,168.21 108.28,168.24 108.32,168.28 108.35,168.32 108.37,168.37 108.39,168.42 108.39,168.47 108.39,168.52 108.39,168.57 108.37,168.62 108.35,168.67 108.32,168.71 108.28,168.74 108.24,168.78 108.19,168.8 108.14,168.81 108.09,168.82 108.04,168.82 107.99,168.81 107.94,168.8 107.89,168.78 107.85,168.74 107.81,168.71 107.78,168.67 107.76,168.62 107.74,168.57 107.73,168.52 107.61,168.52 107.61,175.99 107.64,176.02 107.69,176.08 107.73,176.14 107.77,176.21 107.81,176.28 107.83,176.36 107.85,176.43 107.85,176.51 107.85,176.55 107.85,177.5 107.85,177.54 107.86,177.61 107.88,177.68 107.9,177.76 107.93,177.82 107.96,177.89 108.01,177.95 108.03,177.98 108.38,177.98
GND on TOP (solid shape): 6.37,122.72 6.37,122.7 6.4,122.58 6.48,122.47 6.48,120.64 6.38,120.55 6,120.55 6,120.83 5.15,121.68 5.15,122.21 5.17,122.24 5.2,122.26 5.5,122.72 4.97,122.82 4.89,122.79 4.82,122.82 4.3,122.76 4.5,122.27 4.53,122.26 4.53,121.81 4.22,121.5 4.22,120.55 3.84,120.55 3.4,120.99 3.4,122.7 3.93,123.23 5.86,123.23
GND on TOP (solid shape): 93.49,122.55 93.49,122.15 93.39,122.05 93.06,122.05 92.85,121.84 92.16,121.84 92.15,121.88 91.91,122.13 91.57,122.02 91.49,121.99 91.16,122.17 90.89,122.05 90.82,122.02 90.74,122.05 90.51,122.14 90.27,122.05 90.2,122.02 90.12,122.05 90.03,122.12 89.91,122.15 89.84,122.2 89.83,122.29 89.83,122.62 90.11,122.91 93.13,122.91
GND on TOP (solid shape): outline of 104 points within 88.47,129.04 95.11,131.71
GND on TOP (solid shape): outline of 120 points within 71.98,130.18 78.79,134.03
GND on TOP (solid shape): outline of 269 points within 9.15,136.15 38.1,159.65
GND on TOP (solid shape): outline of 97 points within 63.77,114.86 66.54,118.68
GND on TOP (solid shape): outline of 314 points within 13.42,61.79 27.79,97.27
GND on TOP (solid shape): outline of 457 points within 19.91,60.01 42.93,77.74
GND on TOP (solid shape): outline of 1750 points within 0.25,0.25 162.65,178.25
GND on TOP (solid shape): outline of 2072 points within 41.91,5.25 68.14,75.06
GND on TOP (solid shape): outline of 2323 points within 67.56,0.25 86.75,49.85
GND on TOP (solid shape): outline of 3491 points within 0.25,105.25 108.77,178.25
GND on TOP (solid shape): outline of 6482 points within 60.5,111.6 95.36,130.35
GND on BOTTOM (solid shape): 11.3,30.15 10.5,30.15 10.5,37.85 11.3,37.85
GND on BOTTOM (solid shape): 105.9,166.95 40.4,166.95 40.4,167.6 105.9,167.6
GND on BOTTOM (solid shape): 126.05,139.38 126.05,138.05 124.65,138.05 124.65,139.38 124.84,139.57 125.86,139.57
GND on BOTTOM (solid shape): 14.14,163.21 14.14,161.97 14.07,161.89 12.93,161.89 12.9,161.92 12.9,163.15 13.07,163.32 14.03,163.32
GND on BOTTOM (solid shape): 51.46,130.8 51.46,129.2 51.33,129.07 49.3,129.07 49.17,129.2 49.17,130.8 49.3,130.93 51.33,130.93
GND on BOTTOM (solid shape): 69.88,38.4 69.88,37.9 69.57,37.59 68.28,37.59 67.98,37.89 67.98,38.5 68.17,38.69 69.58,38.69
GND on BOTTOM (solid shape): 77.96,106.2 77.96,105.67 77.91,105.63 75.36,105.63 75.32,105.67 75.32,106.2 75.35,106.23 77.92,106.23
GND on BOTTOM (solid shape): 79.47,106.79 79.47,104.68 79.42,104.64 78.8,104.64 78.78,104.65 78.78,106.81 78.81,106.84 79.42,106.84
GND on BOTTOM (solid shape): 80.31,126.05 80.31,122.34 80.24,122.26 79.4,122.26 78.92,122.75 78.92,125.67 79.4,126.15 80.21,126.15
GND on BOTTOM (solid shape): 88.44,131.03 88.44,130.7 88.39,130.65 85.27,130.65 85.24,130.67 85.24,131.03 85.27,131.05 88.42,131.05
GND on BOTTOM (solid shape): 89.22,119.64 89.22,118.75 89.09,118.62 87.6,118.62 87.61,118.63 87.61,119.61 87.67,119.67 89.18,119.67
GND on BOTTOM (solid shape): 94.98,138.68 94.98,137.89 94.79,137.69 91.67,137.69 91.47,137.89 91.47,138.78 91.67,138.97 94.69,138.97
GND on BOTTOM (solid shape): 101.62,106.08 101.62,104.48 101.54,104.41 100.9,104.41 100.89,104.42 100.89,106.06 100.96,106.14 101.56,106.14
GND on BOTTOM (solid shape): 103.99,128.21 103.99,126.35 103.78,126.15 99.44,126.15 99.11,126.48 99.11,128.08 99.31,128.28 103.91,128.28
GND on BOTTOM (solid shape): 104.39,104.63 104.39,98.18 104.19,97.99 103.47,97.99 103.42,98.04 103.42,104.65 103.47,104.69 104.33,104.69
GND on BOTTOM (solid shape): 104.61,93.42 104.61,90.31 104.53,90.23 103.75,90.23 103.69,90.29 103.69,93.39 103.77,93.47 104.55,93.47
GND on BOTTOM (solid shape): 117.22,108.52 117.22,106.62 117.09,106.49 116.27,106.49 116.14,106.62 116.14,108.52 116.27,108.65 117.09,108.65
GND on BOTTOM (solid shape): 122.3,108.59 122.3,106.62 122.17,106.49 121.35,106.49 121.22,106.62 121.22,108.52 121.35,108.65 122.24,108.65
GND on BOTTOM (solid shape): 125.16,103.57 125.16,102.55 125.03,102.43 123.19,102.43 122.94,102.68 122.94,103.63 123.06,103.76 124.97,103.76
GND on BOTTOM (solid shape): 128.59,128.65 128.59,126.94 128.4,126.75 127.38,126.75 127.25,126.87 127.25,128.59 127.38,128.72 128.52,128.72
GND on BOTTOM (solid shape): 136.79,127.93 136.79,125.2 136.67,125.08 134.08,125.08 133.97,125.19 133.97,127.96 134,127.99 136.73,127.99
GND on BOTTOM (solid shape): 139.95,142.56 139.95,140.91 139.83,140.78 137.67,140.78 137.29,141.16 137.29,142.56 137.41,142.69 139.83,142.69
GND on BOTTOM (solid shape): 9.78,27.72 9.78,24.82 9.72,24.75 9.34,24.75 9.33,24.76 9.33,25.15 9.37,25.19 9.37,27.74 9.38,27.75 9.75,27.75
GND on BOTTOM (solid shape): 10.48,41.68 10.48,38.99 10.36,38.87 9.48,38.87 9.44,38.91 9.44,39.4 9.44,39.4 9.44,41.68 9.5,41.74 10.43,41.74
GND on BOTTOM (solid shape): 36.19,109.37 36.19,108.29 36.04,108.14 35.41,108.14 35.28,108.27 35.28,109.34 35.36,109.41 36.15,109.41
GND on BOTTOM (solid shape): 50.42,146.05 50.42,144.27 49.97,143.83 49.02,143.83 48.64,144.21 48.64,144.85 48.96,145.16 48.96,146.37 49.02,146.43 50.04,146.43
GND on BOTTOM (solid shape): 119.19,121.86 119.19,117.67 118.81,117.29 117.22,117.29 116.9,117.6 116.9,121.79 117.09,121.99 119.06,121.99
GND on BOTTOM (solid shape): 124.84,126.75 124.71,126.62 122.94,126.62 122.87,126.68 122.87,127.76 122.75,127.89 122.05,127.89 122.05,128.45 124.7,128.45 124.84,128.59
GND on BOTTOM (solid shape): 129.54,123.83 129.54,121.6 129.16,121.22 126.87,121.22 126.43,121.67 126.43,124.33 126.75,124.65 128.71,124.65
GND on BOTTOM (solid shape): 136.53,99.63 136.53,97.35 136.37,97.19 126.9,97.19 126.75,97.35 126.75,98.11 126.87,98.24 130.56,98.24 132.21,99.89 136.27,99.89
GND on BOTTOM (solid shape): 96.93,126 96.93,124.35 96.62,124.04 93.5,124.04 93.27,123.81 90.22,123.81 89.69,124.35 89.69,125.85 90.27,125.85 90.63,126.2 96.72,126.2
GND on BOTTOM (solid shape): 133.48,148.21 133.48,145.73 133.32,145.57 132.29,145.57 132.21,145.66 132.21,146.05 132.21,146.05 132.21,148.15 132.33,148.27 133.41,148.27
GND on BOTTOM (solid shape): 145.73,122.94 145.73,122.49 145.67,122.43 145.1,122.43 145.09,122.42 144.92,122.59 140.02,122.59 139.89,122.72 139.89,123.26 140.02,123.38 145.29,123.38
GND on BOTTOM (solid shape): 27.15,155.85 15.5,155.85 15.5,131.85 39,131.85 39,155.85 27.15,155.85 27.15,156.65 39.8,156.65 39.8,131.05 14.7,131.05 14.7,156.65 27.15,156.65
GND on BOTTOM (solid shape): 30.85,67.72 30.85,65.97 30.76,65.88 30.76,62.52 30.56,62.33 29.79,62.33 29.51,62.6 29.51,67.47 29.91,67.87 30.7,67.87
GND on BOTTOM (solid shape): 54.48,146.9 54.48,145.63 53.9,145.05 53.26,145.05 53.21,145.1 53.21,146.94 53.28,147 54.38,147
GND on BOTTOM (solid shape): 55.1,151.21 55.1,150.62 54.23,149.75 54.23,149.26 54.15,149.18 53.65,149.18 53.57,149.26 53.57,149.88 54.43,150.74 54.43,151.2 54.5,151.27 55.04,151.27
GND on BOTTOM (solid shape): 106,142.45 40.3,142.45 40.3,160.96 41.1,160.96 41.1,143.25 105.2,143.25 105.2,165.65 41.1,165.65 41.1,160.97 40.3,160.97 40.3,166.45 106,166.45
GND on BOTTOM (solid shape): 71.71,97.42 71.71,95.83 72.19,95.35 72.19,90.48 72.07,90.37 71.54,90.37 71.05,90.86 71.05,92.71 71.6,93.26 71.6,95 70.99,95.61 70.99,97.47 71.05,97.54 71.59,97.54
GND on BOTTOM (solid shape): 35.1,116.39 35.16,116.39 35.25,116.31 35.25,115.8 35.09,115.64 34.51,115.64 34.11,115.24 34.11,114.72 33.96,114.57 33.31,114.57 33.24,114.64 33.24,115.15 33.5,115.42 33.5,116.28 33.62,116.4 35.1,116.4
GND on BOTTOM (solid shape): 112.4,86.8 80.01,86.8 80.01,87.6 111.6,87.6 111.6,141.15 41.1,141.15 41.1,110.15 61.6,110.15 61.6,87.6 80.01,87.6 80.01,86.8 60.8,86.8 60.8,109.35 40.3,109.35 40.3,141.95 112.4,141.95
GND on BOTTOM (solid shape): 10.77,163.07 10.77,161.96 10.72,161.91 9.56,161.91 9.51,161.96 9.52,162.24 9.52,162.94 9.51,163 9.71,163.19 10.65,163.19
GND on BOTTOM (solid shape): 76.38,127.67 76.38,120.77 76.34,120.73 75.82,120.73 75.55,120.46 75.17,120.46 75.15,120.49 75.15,121.54 75.06,121.63 74.57,121.63 74.5,121.71 74.5,123.89 74.32,124.07 74.32,127.8 74.45,127.93 76.12,127.93
GND on BOTTOM (solid shape): 108.58,123.76 108.58,123.13 108.46,123 107.06,123 106.68,122.62 106.68,121.6 106.3,121.22 105.54,121.22 105.28,120.97 105.28,120.21 105.16,120.08 104.65,120.08 104.39,120.33 104.39,123.64 104.9,124.14 108.2,124.14
GND on BOTTOM (solid shape): 39.8,108.85 60.3,108.85 60.3,82.15 33.2,82.15 33.2,90.65 14.7,90.65 14.7,110.32 15.5,110.32 15.5,91.45 34,91.45 34,82.95 59.5,82.95 59.5,108.05 39,108.05 39,129.75 15.5,129.75 15.5,110.32 14.7,110.32 14.7,130.55 39.8,130.55
GND on BOTTOM (solid shape): 50.29,156.53 50.29,151.35 49.76,150.81 46.48,150.81 46.35,150.94 46.35,151.83 45.91,152.27 45.91,153.8 45.97,153.86 48.7,153.86 49.28,154.43 49.28,156.53 49.4,156.66 50.16,156.66
GND on BOTTOM (solid shape): 151.05,153.1 161.4,153.1 161.4,114.8 149.9,114.8 149.9,93.95 133.29,93.95 133.29,94.75 149.1,94.75 149.1,115.6 160.6,115.6 160.6,152.3 113.7,152.3 113.7,94.75 133.28,94.75 133.28,93.95 112.9,93.95 112.9,153.1 148.53,153.1 148.69,153.26 150.89,153.26
GND on BOTTOM (solid shape): 20.53,87.56 20.53,86.53 20.66,86.4 21.43,86.4 21.43,86.41 21.79,86.41 21.87,86.49 22.1,86.49 22.17,86.41 22.17,86.16 22.07,86.06 21.9,86.06 21.78,86.18 20.74,86.18 20.54,85.98 20.54,85.05 20.5,85.02 19.64,85.02 19.6,85.05 19.6,87.53 19.71,87.64 20.45,87.64
GND on BOTTOM (solid shape): 38.26,128.95 38.26,127.33 38.16,127.23 34.04,127.23 33.91,127.36 33.63,127.36 33.51,127.24 33.51,126.9 33.4,126.79 33.04,126.79 32.68,126.43 31.77,126.43 31.71,126.49 31.71,127.17 31.77,127.24 32.46,127.24 32.79,127.57 32.79,128.92 32.92,129.05 38.16,129.05
GND on BOTTOM (solid shape): 84.1,125.92 87.45,125.92 87.5,125.87 87.5,125.29 87.43,125.21 85.98,125.21 85.8,125.03 85.8,123.41 85.95,123.26 87.4,123.26 87.48,123.18 87.48,122.54 87.43,122.49 84.3,122.49 84.07,122.26 83.16,122.26 83.13,122.29 83.13,123.28 83.46,123.61 83.46,124.91 83.13,125.24 83.13,126.13 83.16,126.15 83.87,126.15
GND on BOTTOM (solid shape): 77.57,118.96 77.57,118.67 77.52,118.62 77.03,118.62 76.83,118.43 76.83,117.67 76.52,117.35 75.25,117.35 75.12,117.48 75.12,117.97 75.06,118.03 72.62,118.03 72.54,118.11 72.54,118.57 72.59,118.62 76.42,118.62 76.53,118.73 76.53,118.96 76.58,119.01 77.52,119.01
GND on BOTTOM (solid shape): 23.65,87.01 23.65,86.41 23.71,86.35 23.72,86.33 23.73,86.31 23.74,86.31 23.76,86.3 23.81,86.24 25.48,86.24 25.48,86.24 25.59,85.63 25.81,85.05 25.81,84.95 25.72,84.9 24.87,84.9 24.63,84.66 23.99,84.66 23.77,84.88 23.77,85.49 23.67,85.59 23.67,86.26 23.16,86.26 23.01,86.41 23.01,87.03 23.11,87.13 23.53,87.13
GND on BOTTOM (solid shape): 73.25,138.29 73.25,133.54 73.03,133.31 73.03,131.41 72.8,131.18 72.8,129.68 72.34,129.22 72.34,128.83 72.25,128.74 71.12,128.74 70.99,128.61 70.99,123.53 71.09,123.43 71.25,123.43 71.32,123.36 71.32,122.39 71.48,122.24 71.65,122.24 71.73,122.16 71.73,120.64 71.96,120.41 72.95,120.41 72.97,120.38 72.97,119.42 72.92,119.37 72.52,119.37 72.42,119.47 72.42,119.64 72.2,119.85 69.02,119.85 68.97,119.9 68.97,120.44 69.08,120.54 69.86,120.54 70.15,120.83 70.15,128.82 71.32,129.99 71.32,138.24 71.45,138.37 73.18,138.37
GND on BOTTOM (solid shape): 83.32,137.85 83.32,137.69 83.62,137.38 84.66,137.38 85.03,137.01 85.03,136.78 85.06,136.75 85.06,133.97 84,132.91 84,130.47 83.92,130.39 83.49,130.39 83.36,130.27 83.36,128.51 83.26,128.41 82.85,128.41 82.8,128.46 82.8,131.18 82.87,131.24 83.22,131.24 83.31,131.33 83.31,132.83 83.9,133.42 83.9,135.04 83.64,135.29 81.48,135.29 81.31,135.12 81.31,134.05 80.54,133.29 80.54,132.32 80.47,132.25 79.88,132.25 79.65,132.02 79.65,128.49 79.6,128.44 78.66,128.44 78.61,128.49 78.61,133.19 79.45,134.02 79.45,138.34 79.46,138.36 82.82,138.36
GND on BOTTOM (solid shape): 83.21,94.43 83.21,94.24 82.68,93.72 82.68,93.25 82.31,92.87 82.16,92.87 81.98,93.06 81.71,93.06 81.69,93.04 81.68,93.04 81.59,92.95 81.56,92.91 81.52,92.88 81.48,92.84 80.59,92.84 80.47,92.97 80.47,93.75 80.56,93.84 80.73,93.84 80.92,93.66 81.17,93.66 81.36,93.85 81.55,93.85 81.7,93.69 81.75,93.69 81.85,93.68 81.95,93.69 82.04,93.69 82.05,93.72 82.86,94.52 83.12,94.52
GND on BOTTOM (solid shape): 149.65,141.29 149.72,141.26 149.74,141.18 149.74,141.11 149.77,141.04 149.78,141.02 149.78,140.74 149.12,140.07 149.1,140.07 148.86,139.91 148.92,139.64 148.54,139.26 148.3,139.26 148.3,139.26 146,139.26 145.75,139.52 145.75,140.11 145.3,140.11 145.21,140.19 145.21,141.17 145.31,141.27 145.85,141.27 145.98,141.14 145.98,140.29 146.11,140.16 148.57,140.16 149.17,140.77 149.17,141.01 149.46,141.29
GND on BOTTOM (solid shape): 129.73,178.27 130.07,177.75 130.09,177.63 130.1,177.5 130.1,154.6 130.1,154.55 130.11,154.5 129.1,154.5 129.1,177.75 108.4,177.75 108.4,170.15 107.6,170.15 107.6,176.5 107.6,176.55 107.6,177.5 107.61,177.63 107.63,177.75 107.99,178.29 108.6,178.5 129.1,178.5
GND on BOTTOM (solid shape): 3.42,51.64 8.38,51.64 8.4,51.64 9.8,51.64 9.8,46.55 0.75,46.55 0.79,46.71 0.8,46.86 0.8,47.2 0.86,47.53 1.02,47.82 1.08,47.9 1.24,48.19 1.3,48.53 1.3,49.79 1.31,49.79 1.31,50.11 1.42,50.58 1.75,50.94 2.55,51.48 2.81,51.6 3.1,51.64
GND on BOTTOM (solid shape): 58.01,160.52 58.01,159.95 57.89,159.83 55.73,159.83 55.52,160.03 54.82,160.03 54.75,159.96 54.75,159.2 55.46,159.2 55.56,159.09 55.56,159.04 56.01,159.04 56.23,158.82 56.23,158.25 56.18,158.2 55.62,158.2 55.46,158.36 55.46,159.1 54.75,159.1 54.75,157.47 55.46,157.47 55.56,157.37 55.56,157.28 56.08,157.28 56.3,157.07 56.3,156.48 56.23,156.41 55.68,156.41 55.46,156.63 55.46,157.37 54.75,157.37 54.62,157.24 54.62,155.64 54.31,155.32 54.31,154.6 54.48,154.42 54.76,154.42 54.84,154.35 54.84,153.58 54.79,153.53 53.92,153.53 53.82,153.63 53.82,154.01 53.61,154.22 52.93,154.22 52.88,154.26 52.88,158.09 53.03,158.24 54.44,158.24 54.56,158.35 54.56,159.04 54.49,159.11 53.63,159.11 53.52,159.23 53.52,159.66 54.58,160.72 57.81,160.72
GND on BOTTOM (solid shape): 67.46,138.52 67.46,136.25 67.5,136.21 67.5,129.68 68.05,129.14 68.05,124.23 67.92,124.11 67.92,121.07 67.47,120.62 67.36,120.55 67.29,120.44 66.87,120.02 66.87,119.18 66.71,119.03 66.21,119.03 66.06,119.17 66.06,120.36 66.04,120.38 66.04,120.78 65.79,121.03 65.53,121.03 65.41,121.16 65.41,122.37 65.6,122.56 66.91,122.56 67.18,122.83 67.18,123.74 66.87,124.06 66.87,125.03 66.74,125.16 65.75,125.16 65.69,125.22 65.69,125.77 65.79,125.86 65.91,125.86 66.17,126.11 66.17,127.71 66.56,128.1 66.66,128.17 66.73,128.27 67.06,128.6 67.06,129.49 66.78,129.76 66.78,130.67 65.7,131.76 65.7,132.07 64.73,133.04 64.73,136.58 65.32,137.17 65.32,138.48 65.46,138.62 67.36,138.62
GND on BOTTOM (solid shape): 85.57,118.92 85.57,118.2 85.93,117.84 85.93,117.18 85.73,116.97 85.73,116.16 85.57,116 85.04,116 84.9,116.13 84.9,116.97 84.57,117.3 84.57,117.6 85.12,117.6 85.12,117.55 85.13,117.49 85.14,117.44 85.17,117.4 85.2,117.36 85.24,117.32 85.28,117.29 85.32,117.27 85.37,117.25 85.43,117.24 85.48,117.24 85.53,117.25 85.58,117.27 85.62,117.29 85.67,117.32 85.7,117.36 85.73,117.4 85.76,117.44 85.77,117.49 85.78,117.55 85.78,117.6 85.77,117.65 85.76,117.7 85.73,117.74 85.7,117.79 85.67,117.82 85.62,117.85 85.58,117.88 85.53,117.89 85.48,117.9 85.43,117.9 85.37,117.89 85.32,117.88 85.28,117.85 85.24,117.82 85.2,117.79 85.17,117.74 85.14,117.7 85.13,117.65 85.12,117.6 84.57,117.6 84.57,117.79 84.23,118.12 84.23,118.37 84.24,118.37 84.24,118.79 84.43,118.99 85.51,118.99
GND on BOTTOM (solid shape): 126.77,156.17 126.86,156.08 126.99,156.05 127.07,156.02 127.1,155.95 127.1,155.82 127.12,155.82 127.12,155.72 127.1,155.72 127.1,155.67 126.83,155.67 126.74,155.74 126.63,155.77 126.33,155.77 126.09,155.61 126.15,155.33 126.18,155.26 126.15,155.19 126.09,154.91 126.33,154.76 126.63,154.76 126.74,154.78 126.83,154.86 127.1,154.86 127.1,154.58 124.56,154.58 124.39,154.75 124.39,154.97 124.6,155.18 125.13,155.18 125.29,155.35 125.29,156.04 125.45,156.2 126.76,156.2
GND on BOTTOM (solid shape): outline of 83 points within 14.71,131.03 39.75,156.58
GND on BOTTOM (solid shape): 86.74,14.01 86.75,14.01 86.75,13.65 86.67,13.48 86.5,13.4 86.25,13.4 85.32,13.03 84.9,12.12 84.9,11.98 85.16,11.24 85.79,10.78 85.78,10.75 85.06,9.48 83.94,8.55 80.06,8.55 78,12.04 80.05,15.54 86,21.49 86.74,21.49
GND on BOTTOM (solid shape): outline of 121 points within 48.98,15.71 52.68,19.93
GND on BOTTOM (solid shape): outline of 127 points within 10.29,15.41 45.69,42.76
GND on BOTTOM (solid shape): 5.65,178.25 5.82,178.17 5.9,178 5.9,177 7.3,175.6 8.7,177 8.7,178 8.78,178.17 8.95,178.25 23.1,178.25 23.27,178.17 23.35,178 23.35,177.06 23.3,176.92 23.18,176.83 22.58,176.37 22.35,175.65 22.35,172.43 22.21,172 21.85,171.73 21.43,171.53 21.07,171.25 20.5,168.78 22.6,167.35 32.1,167.35 32.49,167.41 32.84,167.59 41.02,167.59 41.02,164.87 39.98,164.87 39.98,165.25 38.34,165.25 38.34,164.87 27.43,164.87 27.43,165.29 18.54,165.29 17.02,166.82 17.02,172.4 14.86,174.56 5.07,174.56 4.85,174.84 4.51,174.95 3.9,174.95 3.56,174.84 3.34,174.56 2.61,174.56 2.42,174.76 1.71,174.76 1.65,174.76 1.58,174.75 1.4,174.75 1.17,174.7 0.97,174.56 0.5,174.56 0.42,174.6 0.41,174.69 2.1,177.25 5,178.25
GND on BOTTOM (solid shape): outline of 263 points within 34.04,63.5 37.27,66.49
GND on BOTTOM (solid shape): outline of 272 points within 54.55,16.77 58.29,19.75
GND on BOTTOM (solid shape): outline of 289 points within 54.41,16.3 58.41,19.84
GND on BOTTOM (solid shape): 5.67,178.25 8.93,178.25 8.95,178.25 23.1,178.25 23.27,178.17 23.35,178 23.35,177.06 23.3,176.92 23.18,176.83 22.58,176.37 22.35,175.65 22.35,172.43 22.21,172 21.85,171.73 20.38,169.22 22.6,167.35 32.1,167.35 32.47,167.4 32.8,167.56 33.52,167.56 32.9,167.03 32.1,166.84 22.6,166.84 19.88,169.13 21.68,172.2 21.79,172.29 21.84,172.43 21.84,175.65 22.11,176.59 22.84,177.24 22.84,177.74 9.69,177.74 9.77,177.37 9.8,177 6.93,174.53 4.91,177.74 2.37,176.83 0.9,174.57 0.38,174.57 2.05,177.21 5,178.25 5.65,178.25
GND on BOTTOM (solid shape): outline of 103 points within 67.38,31.63 70.54,34.82
GND on BOTTOM (solid shape): outline of 690 points within 44.81,15.17 81.79,64.96
GND on BOTTOM (solid shape): outline of 619 points within 33.76,62.64 37.7,66.84
GND on BOTTOM (solid shape): outline of 1058 points within 10.06,43.98 46.89,72.38
GND on BOTTOM (solid shape): outline of 1090 points within 40.36,142.58 105.84,166.31
GND on BOTTOM (solid shape): outline of 2112 points within 14.01,61.23 82.07,91.28
GND on BOTTOM (solid shape): outline of 2347 points within 45.62,7.76 86.69,41.9
GND on BOTTOM (solid shape): outline of 13961 points within 0.25,0.25 162.65,178.25
GND on IN1 (solid shape): 110.72,166.92 108.4,166.92 108.32,167 108.32,168.03 108.37,168.08 110.72,168.08
GND on IN1 (solid shape): 52.66,91.68 52.12,91.68 48.62,88.19 48.49,88.19 48.45,88.22 48.46,88.28 52.12,91.94 52.66,91.94
GND on IN1 (solid shape): 46.53,81.88 46.05,81.41 45.94,81.39 45.88,81.48 45.88,82.93 46.38,83.43 46.53,83.43
GND on IN1 (solid shape): 40.25,156.44 38.33,154.52 38.33,153.25 34.07,148.99 34.07,144.27 33.24,143.44 32.86,143.44 32.74,143.56 32.74,150.79 40.14,158.19 40.16,158.21 40.25,158.22
GND on IN1 (solid shape): 82.07,148.93 89.99,148.93 90.09,148.83 90.09,147.79 89.99,147.69 66.37,147.69 66.04,148.02 66.04,148.78 66.18,148.92 68.19,148.92 68.25,148.99 73.94,148.99 74.98,150.03 80.98,150.03
GND on IN1 (solid shape): 13.9,106.45 13.93,106.5 13.99,106.48 19.97,100.51 19.97,100.46 19.94,100.41 19.88,100.42 13.9,106.4
GND on IN1 (solid shape): 53.32,104.86 53.32,104.28 50.42,101.37 50.31,101.35 50.24,101.45 50.24,101.94 53.25,104.94
GND on IN1 (solid shape): 71.03,67.88 71.03,66.93 70.19,66.09 70.19,64.41 69.38,63.6 69.38,56.31 69.32,56.21 69.21,56.23 68.96,56.48 68.94,56.48 67.63,57.79 67.63,66.78 69.74,68.89 70.02,68.89
GND on IN1 (solid shape): 136.53,115.13 136.53,113.6 136.27,113.35 133.1,113.35 132.46,112.71 132.46,106.11 132.33,105.98 130.68,105.98 130.05,105.35 125.35,105.35 124.97,104.97 124.97,104.33 124.71,104.08 123.06,104.08 122.68,104.46 122.68,107.13 123.32,107.76 129.41,107.76 130.3,108.65 130.3,115.13 130.56,115.38 136.27,115.38
GND on IN1 (solid shape): 102.57,127.78 102.57,126.53 101.26,125.22 100.33,125.22 99.41,124.31 99.16,124.05 97.93,124.05 97.91,124.1 97.92,124.16 97.94,124.22 97.94,124.28 97.94,124.31 98.15,124.51 98.89,124.51 99.29,124.91 99.29,125.21 99.82,125.75 101.39,125.75 101.75,126.1 101.85,126.1 101.96,126.2 101.96,127.78 102.08,127.9 102.44,127.9
GND on IN1 (solid shape): 10.54,19.61 10.54,17.04 9.8,16.3 9.8,15.25 1.8,15.25 1.09,15.54 0.8,16.25 0.8,20 0.78,20.18 0.74,20.35 9.8,20.35
GND on IN1 (solid shape): 37.89,102.94 37.89,96.47 36.29,94.87 35.66,94.87 35.65,94.91 35.59,95.07 35.46,95.18 35.41,95.25 35.43,95.34 35.73,95.64 36.25,95.64 37.75,97.14 37.75,101.09 37.76,101.1 37.76,102.37 37.4,102.73 37.4,102.95 37.54,103.09 37.74,103.09
GND on IN1 (solid shape): 50.91,97.38 51.02,97.41 51.08,97.31 51.08,93.79 49.03,91.73 49.01,91.73 48.79,91.62 48.8,91.38 48.81,91.27 48.72,91.22 47.89,91.22 47.89,94.36
GND on IN1 (solid shape): 54.67,165.5 54.69,165.49 54.68,165.46 54.07,164.84 50.18,164.84 49.89,165.13 49.11,165.13 49.11,165.13 41.48,165.13 39.9,163.55 39.9,163.53 39.9,159.41 38.67,158.19 38.67,158.06 32.33,151.71 32.22,151.69 32.16,151.79 32.16,157.4 33.11,158.35 33.11,158.35 33.21,158.43 33.25,158.54 33.28,158.61 33.35,158.64 38.4,158.64 39.61,159.85 39.61,163.65 41.34,165.38 41.57,165.38 50.23,165.38 50.5,165.1 53.67,165.1 54.07,165.5
GND on IN1 (solid shape): 113.4,168.56 113.48,168.53 113.51,168.45 113.51,167.13 113.03,166.65 113.03,166.35 113.24,166.14 113.53,166.14 113.96,166.57 114.07,166.59 114.13,166.5 114.13,166.39 113.29,165.55 111.94,165.55 111.94,165.84 113,166.9 113,167.69 113.04,167.71 113.09,167.71 113.35,167.84 113.28,168.12 113.25,168.14 113.25,168.46 113.35,168.56
GND on IN1 (solid shape): 3.42,51.64 8.38,51.64 8.4,51.64 9.8,51.64 9.8,46.55 2.35,46.55 2.35,46.55 0.75,46.55 0.79,46.7 0.8,46.86 0.8,47.2 0.86,47.53 1.02,47.82 1.08,47.9 1.24,48.19 1.3,48.53 1.3,50.11 1.35,50.44 1.51,50.73 1.52,50.73 1.62,50.84 1.75,50.94 2.55,51.48 2.81,51.6 3.1,51.64
GND on IN1 (solid shape): 124.69,144.44 124.75,144.54 124.86,144.51 125.26,144.12 125.26,142.66 126.61,141.31 126.61,141.02 126.57,140.94 126.49,140.92 126.14,140.75 126.18,140.37 126.21,140.3 126.18,140.24 126.14,139.86 126.49,139.69 126.57,139.67 126.61,139.59 126.61,139.3 125.54,138.23 124.82,138.23 124.71,138.34 124.71,144 124.69,144.03
GND on IN1 (solid shape): outline of 97 points within 15.25,16.71 27.92,20.05
GND on IN1 (solid shape): outline of 100 points within 67.57,40.37 73.63,53.18
GND on IN1 (solid shape): 117.3,143.68 117.3,143.22 117.71,142.81 117.9,142.81 117.93,142.79 117.96,142.77 117.99,142.72 117.96,142.68 117.84,142.18 118.35,142.16 118.43,142.19 118.5,142.16 119.01,142.18 118.89,142.68 118.86,142.72 118.89,142.77 118.93,142.79 118.96,142.81 120.43,142.81 121.46,141.78 121.46,139.33 121.31,139.18 120.12,139.18 119.67,139.62 116.08,139.62 115.76,139.31 115.76,135.61 116.01,135.36 116.01,134.69 115.66,134.34 113.11,134.34 112.88,134.58 112.88,139.62 114.83,141.57 115.21,141.57 115.59,141.95 116.73,141.95 116.94,142.16 116.94,142.45 116.73,142.66 115.3,142.66 114.91,142.28 114.53,142.28 112.17,139.91 112.17,134.55 111.96,134.34 111.21,134.34 110.87,134.68 110.87,139.06 111.84,140.04 111.97,140.04 112.4,140.47 112.4,140.88 116.16,144.63 116.34,144.63
GND on IN1 (solid shape): outline of 123 points within 24.16,18.35 32.85,24.58
GND on IN1 (solid shape): 24.28,45.14 24.35,45.17 24.42,45.14 24.49,45.1 24.57,45.08 28.46,45.08 28.47,45.05 28.56,44.95 28.69,44.92 28.8,44.96 28.88,45.05 28.9,45.08 31.24,45.08 31.33,45.03 31.32,44.92 31.31,44.91 29.24,42.84 27.85,42.84 27.46,42.46 24.03,42.46 23.93,42.52 23.96,42.63 24.23,42.91 24.23,43.15 24.06,43.32 23.82,43.32 23.53,43.03 22.47,43.03 22.26,43.24 22.26,44.14 22.74,44.61 22.85,44.64 22.91,44.54 22.91,44.41 23.12,44.2 24.33,44.2 25,43.52 28.67,43.52 29.06,43.91 29.06,44.21 28.85,44.41 28.55,44.41 28.38,44.24 27.27,44.24 27.18,44.28 27.18,44.38 26.97,44.72 26.77,44.38 26.77,44.28 26.68,44.24 25.29,44.24 24.62,44.91 24.29,44.91 24.2,44.97 24.22,45.08
GND on IN1 (solid shape): outline of 127 points within 58.45,96.97 62.35,107.55
GND on IN1 (solid shape): outline of 127 points within 43.47,83.97 46.36,88.45
GND on IN1 (solid shape): outline of 140 points within 53.75,91.28 63.47,100.85
GND on IN1 (solid shape): outline of 296 points within 33.69,92.47 38.97,104.12
GND on IN1 (solid shape): outline of 371 points within 71.23,131.71 75.92,142.2
GND on IN1 (solid shape): outline of 505 points within 65.17,78.73 82.11,94.27
GND on IN1 (solid shape): outline of 525 points within 66.27,128.18 71.16,138.93
GND on IN1 (solid shape): outline of 600 points within 30.56,9.34 58.72,25.81
GND on IN1 (solid shape): outline of 731 points within 51.71,93.2 66.87,120.05
GND on IN1 (solid shape): outline of 4341 points within 99.3,96.92 146.85,149.37
GND on IN1 (solid shape): outline of 8023 points within 16.85,123.24 115.54,165.34
GND on IN1 (solid shape): outline of 35014 points within 0.25,0.25 162.65,178.25
GND on GND1 (solid shape): 9.8,19.33 10.52,18.61 10.52,16.86 9.8,16.14 9.8,15.25 1.8,15.25 1.09,15.54 0.8,16.25 0.8,20 0.78,20.18 0.74,20.35 9.8,20.35
GND on GND1 (solid shape): 3.42,51.64 8.38,51.64 8.4,51.64 9.8,51.64 9.8,46.55 2.22,46.55 2.22,46.53 0.74,46.53 0.79,46.7 0.8,46.86 0.8,47.2 0.86,47.53 1.02,47.82 1.08,47.9 1.24,48.19 1.3,48.53 1.3,50.11 1.33,50.35 1.41,50.57 1.41,50.57 1.56,50.78 1.75,50.94 2.55,51.48 2.81,51.6 3.1,51.64
GND on IN2 (solid shape): 51.44,130.8 51.44,129.2 51.31,129.07 49.28,129.07 49.15,129.2 49.15,130.8 49.28,130.93 51.31,130.93
GND on IN2 (solid shape): 47.17,99.18 48.39,97.96 48.39,94.92 48.84,94.47 48.84,93.99 48.77,93.91 47.59,95.08 47.59,98.39 46.4,99.59 46.4,100.34 47.17,100.34
GND on IN2 (solid shape): 12.78,113.02 12.78,100.41 12.71,100.32 12.6,100.34 12.43,100.51 12.43,111.1 12.42,111.11 12.42,112.82 12.7,113.1
GND on IN2 (solid shape): 112.98,100.31 113.09,100.33 113.16,100.24 113.16,99.47 112.15,98.46 111.38,98.46 111.29,98.53 111.31,98.64
GND on IN2 (solid shape): 67.19,113.96 67.19,113.14 67.1,113.05 67.04,113.05 66.63,112.64 66.63,112.26 66.08,111.71 65.7,111.71 65.52,111.52 65.41,111.5 65.34,111.59 65.34,113.49 66.02,114.16 66.02,114.17 66.98,114.17
GND on IN2 (solid shape): 111.98,97 111.98,95.55 111.04,94.61 111.04,93.38 110.57,92.91 108.83,92.91 108.35,92.43 108.24,92.41 108.18,92.51 108.18,94.41 107.96,94.63 107.5,94.63 107.01,95.12 106.74,95.12 106.58,95.28 106.58,96.36 106.62,96.4 106.86,96.4 108.02,97.56 111.41,97.56
GND on IN2 (solid shape): 79.54,62.82 79.58,62.74 79.58,61.99 78.41,60.82 78.29,60.8 78.23,60.9 78.23,61.12 79.29,62.18 79.29,62.74 79.32,62.81 79.39,62.84 79.42,62.84 79.46,62.84
GND on IN2 (solid shape): 56.66,76.21 56.66,50.93 56.71,50.88 56.71,50.63 44.58,38.49 44.33,38.49 44.25,38.58 44.14,38.78 43.91,38.86 43.82,38.92 43.84,39.03 55.83,51.03 55.83,53.5 55.88,53.5 55.88,76.09 56.19,76.4 56.48,76.4
GND on IN2 (solid shape): 26.25,28.92 26.35,28.86 26.32,28.75 21.78,24.2 21.78,22.45 21.63,22.3 21.4,22.3 21.27,22.43 21.27,23.36 21.06,23.58 21.06,26.54 21.09,26.59 21.14,26.58 21.19,26.53 22.57,26.53 24.96,28.92
GND on IN2 (solid shape): 8.44,30.94 8.53,30.88 8.51,30.77 7.69,29.95 7.69,29.11 6.23,27.64 6.16,27.61 6.09,27.64 5.89,27.75 5.66,27.73 5.66,28.14 6.52,28.14 7.5,29.11 7.5,30.22 8.22,30.94
GND on IN2 (solid shape): 9.8,19.42 10.55,18.67 10.55,16.8 9.8,16.05 9.8,15.25 1.8,15.25 1.09,15.54 0.8,16.25 0.8,20 0.78,20.18 0.74,20.35 9.8,20.35
GND on IN2 (solid shape): 32.3,83.7 32.3,76.36 32.24,76.27 32.13,76.28 31.87,76.33 31.65,76.17 31.57,76.11 31.49,76.14 31.14,76.48 31.14,83.13 31.86,83.85 32.15,83.85
GND on IN2 (solid shape): 32.33,34.99 32.34,35 32.36,35.02 32.39,35.02 32.42,35.02 32.45,35.01 32.47,34.99 32.49,34.97 32.5,34.94 32.5,34.92 32.5,30.4 32.06,29.96 26.96,29.96 26.77,29.76 26.75,29.75 26.73,29.74 26.7,29.73 26.67,29.74 26.64,29.75 26.62,29.77 26.6,29.8 26.57,29.83 26.55,29.84 26.55,31.29 26.66,31.29 26.66,30.99 26.82,30.83 26.82,30.6 27.03,30.39 27.33,30.39 27.53,30.6 27.53,31.12 27.16,31.5 26.87,31.5 26.66,31.29 26.55,31.29 26.55,31.63 27.28,32.37 29.7,32.37
GND on IN2 (solid shape): 48.87,138.42 48.87,138.33 48.78,138.28 48.47,138.28 48.42,138.34 42.84,138.34 39.42,134.91 39.42,133.51 32.96,127.05 29.95,127.05 27.47,124.58 27.47,117.49 25.32,115.33 25.32,115.32 24.99,114.99 24.99,112.28 25,112.27 25,111.76 25.82,110.94 25.45,110.57 25.32,110.57 24.64,111.25 24.64,115.4 26.91,117.68 26.91,118.48 26.91,118.48 26.91,124.4 29.83,127.32 32.96,127.32 39.25,133.61 39.25,135.03 42.71,138.49 48.85,138.49
GND on IN2 (solid shape): 107.18,136.18 107.18,132.99 106.9,132.71 106.02,132.71 106.01,132.71 105.74,132.61 105.8,132.32 105.83,132.24 105.81,132.17 105.48,131.84 102.24,131.84 100.51,133.57 100.51,134.06 100.48,134.09 100.48,134.95 98.39,137.04 98.39,137.26 98.49,137.37 105.99,137.37
GND on IN2 (solid shape): 15.88,23.61 15.86,23.57 15.86,23.19 16.23,23.07 16.32,23.05 16.37,22.97 16.37,19.89 19.32,16.93 19.33,16.83 19.24,16.77 18.96,16.77 15.51,20.22 15.51,23.7 15.53,23.72 15.77,23.72
GND on IN2 (solid shape): 41.75,85.62 41.86,85.65 41.92,85.55 41.92,73.17 29.09,60.34 28.42,60.34 27.68,59.6 27.68,58.63 27.65,58.55 27.57,58.53 27.34,58.48 27.2,58.3 27.13,58.23 27.03,58.25 27.01,58.27 27.01,59.47 28.49,60.95 28.86,60.95 41.33,73.42 41.33,85.21
GND on IN2 (solid shape): 22.49,42.36 22.6,42.38 22.67,42.29 22.67,34.86 22.48,34.68 22.37,34.65 22.31,34.75 22.31,39.21 22.45,39.61 22.07,39.77 21.97,39.78 21.93,39.87 21.93,41.79
GND on IN2 (solid shape): 107.54,98.85 107.63,98.79 107.61,98.68 106.95,98.02 105.95,97.02 105.95,94.5 106.67,93.78 106.67,90.58 103.56,87.47 103.17,87.47 103.03,87.33 103.03,87.14 103.17,87.01 103.18,86.95 103.14,86.92 103.04,86.92 103.03,86.93 95.63,86.93 95.48,87.07 95.48,87.13 95.63,87.28 102.47,87.28 106.44,91.24 106.44,93.68 105.66,94.45 105.66,97.88 106.63,98.85
GND on IN2 (solid shape): 34.61,39.69 34.72,39.71 34.79,39.62 34.79,37.06 35.88,35.97 35.88,32.8 32.3,29.22 29.17,29.22 28.86,28.91 26.81,28.91 26.71,28.97 26.73,29.08 27.15,29.5 32.25,29.5 32.96,30.21 32.96,36.56 33.83,37.43 33.91,37.51 33.91,37.7 33.69,37.92 33.69,38.64 33.76,38.73 33.78,38.84 33.78,38.86
GND on IN2 (solid shape): 3.42,51.64 8.38,51.64 8.4,51.64 9.8,51.64 9.8,46.55 0.75,46.55 0.79,46.71 0.8,46.86 0.8,47.2 0.86,47.53 1.02,47.82 1.08,47.9 1.24,48.19 1.3,48.53 1.3,50.11 1.31,50.27 1.35,50.42 1.35,50.42 1.51,50.71 1.75,50.94 2.55,51.48 2.81,51.6 3.1,51.64
GND on IN2 (solid shape): 81.88,49.91 81.97,49.94 82.04,49.88 82.16,49.76 82.32,49.71 82.34,49.71 82.72,49.33 82.72,49.22 82.65,49.22 82.64,49.22 82.2,49.09 82.33,48.64 82.35,48.62 82.35,44.92 83.77,43.51 83.77,42.91 83.7,42.82 83.59,42.84 81.85,44.58 81.85,49.88
GND on IN2 (solid shape): 76.91,70.47 77.02,70.5 77.08,70.4 77.08,62.94 76.18,62.04 76.07,62.01 76,62.11 76,67.49 76.07,67.59 76.18,67.56 76.76,67.78 76.18,68 76.07,67.97 76,68.07 76,69.57
GND on IN2 (solid shape): 107.02,89.99 107.02,88.24 107.23,88.02 107.9,88.02 108.18,88.31 108.18,89.51 108.41,89.51 108.42,89.52 108.63,89.52 108.72,89.61 109.45,88.88 110.03,88.88 110.2,88.71 110.19,88.69 110.71,88.39 110.41,88.91 110.39,88.9 110.14,89.15 109.71,89.15 109.38,89.48 109.36,89.59 109.45,89.65 113.47,89.65 113.56,89.59 113.54,89.48 110.98,86.92 103.9,86.92 103.8,86.98 103.82,87.09 106.79,90.06 106.95,90.06
GND on IN2 (solid shape): outline of 92 points within 58.54,86.09 61.77,93.24
GND on IN2 (solid shape): 71.4,63.57 71.46,63.66 71.57,63.65 73.04,62.18 73.04,39.31 73.29,39.05 74.09,39.05 74.26,39.21 74.26,42.78 74.32,42.87 74.43,42.84 74.49,42.78 74.48,42.75 74.53,42.47 74.78,42.33 74.85,42.3 74.88,42.23 74.88,40.17 74.64,39.93 74.64,37.52 74.58,37.42 74.47,37.44 71.4,40.51 71.4,46.18 71.43,46.26 71.5,46.29 71.83,46.62 71.5,46.95 71.43,46.98 71.4,47.05
GND on IN2 (solid shape): outline of 96 points within 131.19,87.82 149.84,91.32
