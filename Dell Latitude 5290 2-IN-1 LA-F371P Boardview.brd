# Allegro board Dell Latitude 5290 2-IN-1 LA-F371P Boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DV12S: length 4
  BOTTOM w0.508: CR5.1 70.28,38.5 69.73,39.05 67.87,39.05 67.51,38.69 CR9.2
  vias: v2(67.36,36.9)
GND: length 5051.7
  TOP w0.076: UCPU1.AG17 v12(63.43,121.04)
  TOP w0.102: v8(75.43,131.83) 75.43,132.16 75.14,132.46 74.55,132.46 v12(74.17,132.83)
  TOP w0.112: CS7.2 5.22,120.25 5.38,120.08 5.38,119.09 4.26,117.97 U3.2 ; CS8.1 2.17,117.02 2.56,116.63 U3.6 ; v12(3.3,114.28) 3.3,115.14 3.76,115.6 U3.8 ; v12(6.65,117.13) 6.41,117.13 6.41,117.13 U3.12 ; v12(6.65,116.63) 6.63,116.63 6.63,116.63 U3.11
  TOP w0.127: v7(99.56,121.59) 99.56,122.26 v9(99.57,122.28) ; v12(54.31,131.97) 53.89,131.97 v12(53.57,132.3) 53.26,132.6 v12(52.81,132.6) v12(51.69,132.6) 51.44,132.35 51.44,132.2 51.36,132.12 v12(51.36,131.34) 51.6,131.1 51.6,130.83 51.61,130.82 v12(51.61,130.72) v12(51.61,129.96) 51.57,129.92 51.57,129.02 51.58,129.01 51.41,128.84 v12(51.08,128.84) v12(50.24,128.84) v12(49.33,128.84) 49.12,128.84 v12(48.92,129.05) v12(48.92,129.76) v12(48.92,130.44) 48.92,130.75 49.52,131.34 v12(49.59,131.34) 49.76,131.51 49.76,131.83 v12(49.71,131.88) 49.76,131.93 49.76,132.4 49.91,132.55 v12(49.91,132.81) 49.91,133.44 50.04,133.57 v12(51.23,133.57) 51.33,133.47 53.47,133.47 53.67,133.67 53.79,133.67 v12(53.98,133.86) 54.13,134.01 54.81,134.01 55,133.82 55.21,133.82 55.51,133.52 v12(56.25,133.52) 56.98,133.52 57.28,133.82 57.66,133.82 57.84,133.64 57.84,133.39 57.66,133.21 57.23,133.21 v12(56.85,132.83) ; v9(106.05,107.46) 106.1,107.51 PC604.2
  TOP w0.152: 73.48,132.15 73.23,132.41 73.21,132.41 72.68,132.94 72.68,133 72.5,133.18 72.44,133.18 72.43,133.18 72.23,133.18 72.04,133.37 72.04,135.29 v3(71.53,135.8) 71.35,135.98 v12(71.35,136.72) v12(71.35,137.72)
  TOP w0.203: v12(124.71,160.94) 124.11,160.94 JWFC1.28 ; v12(121.16,159.34) 121.71,159.34 JWFC1.7 ; JWFC1.16 121.71,162.94 121.48,162.94 v12(121.28,163.13) ; JUFC1.14 v12(124.85,169.99) ; PU1108.11 54.6,155.87 ; JWFC1.26 124.11,160.14 v12(124.71,160.14) ; JWFC1.23 124.11,158.94 v12(124.71,158.94) ; JWFC1.13 121.71,161.74 v12(121.16,161.74) ; v12(133.25,93.48) JIO1.26 ; JUFC1.2 v12(124.85,167.59) ; JUFC1.21 v12(122.2,171.59) ; v12(71.81,113.94) 71.81,113.94 ; v12(121.16,156.94) 121.71,156.94 JWFC1.1 ; v12(130.85,93.43) JIO1.38 ; v12(75.34,112.11) 75.47,112.23 UCPU1.BB38 ; JWFC1.4 121.71,158.14 v12(121.16,158.14) ; PU1006.13 64.73,159.41 ; PU1005.13 81.35,159.38 ; JUFC1.9 v12(122.2,169.19) ; UCPU1.B34 73.83,134.19 73.83,135.01 73.65,135.19 ; v12(131.25,93.43) JIO1.36 ; JWFC1.10 121.71,160.54 v12(121.16,160.54) ; JUFC1.8 v12(124.85,168.79) ; UCPU1.E71 94.82,132.41 v7(95.17,132.76) ; JUFC1.13 v12(122.2,169.99) ; v12(69.32,113.84) 69.31,113.82 ; UCPU1.A67 92.2,134.91 92.4,135.11 v7(92.4,135.28) ; JIO1.34 131.65,93.2 v12(131.85,93.4) 132.05,93.21 JIO1.32 ; JIO1.13 v7(135.65,88.85) 135.25,89.25 JIO1.15 ; JIO1.14 135.65,93.16 135.85,93.36 135.86,93.36 v12(136.05,93.56) JIO1.12 ; 74.26,114.5 v12(74.29,114.47) ; JUFC1.20 v12(124.78,171.19) ; PU1107.13 94,156.66
  TOP w0.254: UCPU1.A70 94.2,134.87 94.69,134.87 v7(94.7,134.86) 94.7,134.46 UCPU1.B71 ; v13(80.64,93.68) 80.73,93.68 v7(81.05,93.36) ; PC523.2 42.85,153.4 v7(43.48,154.04) 43.73,154.29 PU501.10 ; UCPU1.AM8 58.52,118.56 v7(58.93,118.15) ; v7(137.03,140.53) 137.03,140.84 137.16,140.98 PU720.8 ; v7(78.64,101.15) 78.73,101.15 v13(79.04,100.83) ; v7(136.68,141.98) PU720.6 ; UCPU1.AM13 61.29,118.56 v7(61.68,118.17) ; 94,156.66 93.67,156.66 v12(93.28,157.05) ; v12(60.73,114.47) 60.88,114.62 61.59,114.62 61.74,114.47 v12(61.96,114.47) ; PQ122.4 146.1,124.64 v12(146.24,124.5) ; UCPU1.AR16 62.95,116.61 v7(62.55,116.21) 62.15,116.61 UCPU1.AR15 ; v12(59.31,133.85) v12(59.31,132.83) ; v12(53.88,156.26) 54.27,155.87 54.6,155.87 ; UCPU1.F68 UCPU1.D69 93.39,132.48 v7(93.47,132.4) ; v13(80.64,93.03) 80.73,93.03 v7(81.05,93.36) ; v12(13.93,112.87) 13.94,112.87 13.97,112.89 14.91,112.89 15.38,113.36 JNGFF1.71 ; 81.35,159.38 81.02,159.38 v12(80.63,159.77) ; v7(81.05,93.36) 81.38,93.03 v13(81.44,93.03) ; v7(81.05,93.36) 81.12,93.36 v13(81.44,93.68) ; v7(84.52,118.24) 84.84,118.56 UCPU1.AM55 84.53,119.02 UCPU1.AL55 ; v7(92.85,93.3) 93.18,92.97 UD2.T4 ; v7(92.85,93.3) 92.94,93.3 v12(93.26,93.62) ; v7(92.85,93.3) 92.52,92.97 v12(92.46,92.97) 92.38,92.97 v7(92.05,93.3) 91.72,92.97 v13(91.66,92.97) ; 73.57,131.9 UCPU1.F35 74.04,131.45 ; UCPU1.W6 56.02,124.02 v12(55.93,124.02) ; v13(80.64,94.98) 80.73,94.98 v7(81.05,94.66) 81.37,94.98 v13(81.44,94.98) 81.53,94.98 v7(81.85,94.66) 82.17,94.98 v13(82.24,94.98) ; v12(32.37,96.97) 32.37,97.37 32.39,97.39 US1.14 ; v7(94.46,95.25) 94.13,94.92 v13(94.06,94.92) 94.37,94.6 v7(94.46,94.6) 94.78,94.92 v13(94.86,94.92) 94.52,95.25 v7(94.46,95.25) ; v7(94.46,95.25) 94.15,95.57 v13(94.06,95.57) ; v7(94.46,95.25) 94.78,95.57 v13(94.86,95.57) ; v12(61.96,114.47) 61.96,114 v7(61.98,113.98) 61.96,113.97 UCPU1.BA14 ; v12(61.96,114.47) 61.96,115.15 v12(62.13,115.31) ; v12(56.85,132.83) 56.69,132.83 55.93,132.07 v12(55.93,131.97) v12(54.96,131.97) v12(54.31,131.97) ; UCPU1.AT2 54.98,116.04 55.91,116.04 v12(55.93,116.06) ; v7(55.5,135.96) 56.25,135.21 v12(56.25,134.82) ; v12(59.31,127.91) 59.66,128.26 v7(59.66,128.36) 59.66,128.55 v12(59.96,128.85) ; v12(83.04,93.68) 82.98,93.68 v7(82.65,94.01) 82.97,94.33 v13(83.04,94.33) ; JNGFF1.73 14.88,113.6 14.66,113.37 13.95,113.37 13.93,113.35 v12(13.93,113.37) ; v12(57.12,113.25) 57.19,113.31 57.19,113.91 v7(57.21,113.94) 57.16,113.98 v12(57.16,114.47) 57.55,114.47 57.58,114.5 57.88,114.5 57.91,114.47 UCPU1.AW8 58.36,114.47 58.9,115.01 ; v12(59.54,114.47) 59.43,114.47 58.9,115.01 ; v7(36.36,51.81) 36.36,52.05 36.47,52.16 JNGFF3.7 ; PQ136.4 18.44,22.45 v12(18.44,22.44) ; v13(97.26,96.22) 97.32,96.22 v7(97.65,96.55) 97.97,96.87 v13(98.06,96.87) ; v12(84.09,133.85) v12(84.09,132.83) ; 58.9,115.01 59.08,115.19 59.26,115.19 v12(59.38,115.31) ; PC140.2 141.86,127.2 v12(141.36,127.2) ; v7(96.86,100.43) 96.53,100.77 v13(96.46,100.77) ; UCPU1.AL4 v12(55.44,118.72) UCPU1.AL2 ; v7(59.86,116.93) 59.88,116.93 60.2,116.61 v12(60.3,116.61) ; v12(74.29,113.25) v12(74.29,114.47) ; v7(121.79,117.79) 121.54,117.54 PU500.10 ; v7(38.1,51.81) 38.1,52.01 37.97,52.14 JNGFF3.1 ; 72.67,131.13 72.64,131.1 UCPU1.J32 ; v7(79.57,94.62) 79.28,94.33 v13(79.04,94.33) ; v13(92.46,94.27) 92.53,94.27 v7(92.86,94.6) 93.18,94.92 v13(93.26,94.92) 92.92,95.25 v7(92.86,95.25) 93.18,95.57 v13(93.26,95.57) ; v12(64.38,112.52) v12(64.38,113.25) ; UCPU1.K16 v12(62.76,128.55) v12(63.41,128.55) v12(64.06,128.55) ; v7(79.5,96.65) 79.14,96.28 v13(79.04,96.28) ; RH14.2 49.45,119.91 v12(49.71,120.17) ; UCPU1.B22 UCPU1.D22 66.74,132.72 v12(66.48,132.46) ; UCPU1.AF1 v12(54.96,121.37) ; 49.28,143.85 PU801.6 ; v13(92.46,100.77) 92.54,100.77 v7(92.86,100.45) ; v13(83.84,98.23) v12(84.34,98.23) ; RH91.2 52.01,122.28 v12(52.53,121.76) ; 66.81,114.49 UCPU1.AW23 66.83,113.99 v7(66.78,113.94) 66.83,113.89 v12(66.83,113.25) ; UCPU1.F8 58.24,131.45 v12(57.97,131.72) ; UCPU1.U10 58.71,125.18 v7(58.53,125.18) 58.53,124.83 UCPU1.W9 ; UCPU1.B14 UCPU1.D14 62.13,132.49 UCPU1.E15 61.72,131.69 v12(61.72,131.51) 61.66,131.45 UCPU1.F13 ; UCPU1.AF10 v12(59.06,121.76) ; v13(93.26,99.47) 93.19,99.47 v7(92.86,99.8) 93.18,100.12 v13(93.26,100.12) ; v12(71.81,114.47) UCPU1.BA32 ; v12(69.31,114.47) UCPU1.BA28 ; UCPU1.J11 UCPU1.J13 61.21,129.6 v12(61.72,130.11) ; 73.65,135.19 73.47,135.37 v12(73.47,135.6) 73.47,136.17 v12(73.66,136.36) 73.72,136.42 74.38,136.42 v12(74.55,136.59) v12(75.18,137.23) v12(75.79,137.83) v12(75.79,138.67) v12(75.79,139.43) v12(75.79,140.23) v12(75.79,140.92) v12(75.79,141.5) 75.79,141.8 75.54,142.05 v12(75.27,142.05) v12(74.43,142.05) v12(73.52,142.05) v12(72.68,142.05) v12(71.78,142.05) 71.61,142.05 71.35,141.8 v12(71.35,141.26) v12(71.35,140.53) v12(71.35,139.9) v12(71.35,139.33) v12(71.35,138.66) v12(71.35,137.72) ; v12(63.99,133.57) UCPU1.B18 ; UCPU1.E6 57.73,132.1 v12(57.95,132.33) ; JT100.13 v7(152.4,86.5) ; v12(56.71,126.84) 56.54,126.67 UCPU1.T4 55.87,126.61 55.02,126.61 UCPU1.T2 ; UCPU1.G5 v12(57.56,130.8) ; 64.73,159.41 64.62,159.3 64.21,159.3 v12(63.68,159.83) ; UCPU1.AP10 59.09,117.56 v7(58.97,117.56) ; v7(122.27,144.48) PU502.10 ; v12(76.65,132.83) UCPU1.B39 ; UCPU1.D62 v12(89.04,133.85)
  TOP w0.305: JIO2.6 74.55,55.65 75.53,55.65 v7(75.69,55.82) ; v12(108.33,165.09) 108.58,165.33 L80.1 ; v7(30.56,59.04) 30.56,59.32 30.72,59.49 JNGFF3.30 ; JNGFF3.33 29.97,53.78 30.1,53.91 v7(30.1,54.37) ; JNGFF3.36 29.22,59.64 28.86,59.27 v7(28.86,59.16) ; JNGFF3.24 32.22,59.12 v7(32.27,59.07) ; JIO2.4 74.55,54.65 75.4,54.65 v7(75.69,54.36) 75.49,54.15 74.55,54.15 JIO2.3 ; JNGFF2.71 63.5,81.59 64.06,81.03 v7(64.26,81.03) ; v12(19.56,115.89) 19.3,115.89 18.88,115.47 JNGFF1.57 ; v7(33.92,58.62) 33.92,59.34 33.72,59.54 JNGFF3.18 ; JIO2.2 75.45,53.65 v7(75.69,53.41) 75.44,53.15 74.55,53.15 JIO2.1 ; JIO2.12 75.59,58.65 v7(75.69,58.75) ; JIO2.9 75.25,57.15 75.4,57 v7(75.69,57) ; JNGFF2.75 64.5,81.9 v7(64.26,81.66) 64,81.92 JNGFF2.73
  TOP w0.356: v7(6.29,155.06) D20.2 ; MIC2.5 111.51,173.73 v7(112.01,173.22) ; v7(5.8,138.81) C20.2 ; CC5.2 v12(63.3,137.36) ; v12(65.56,104.48) 65.56,104.48 CLRP1.1 ; C222.2 v12(72.22,56.75) ; v7(7.11,141.04) D21.2 ; v7(109.47,176.85) 109.8,177.18 MIC2.7 ; MIC2.8 112.48,175.45 112.48,174.62 112.84,174.26 v7(112.84,173.74) ; MIC2.6 110.03,174.12 v7(109.83,173.92) ; v7(5.68,152.26) C19.2
  TOP w0.381: PQ127.4 140.57,130.64 v7(140.84,130.37) ; PQ127.1 140.98,129.34 v7(140.84,129.48) ; JSPK.6 84.35,5.27 v7(84.52,5.44)
  TOP w0.406: v7(33.88,94.39) 33.88,93.62 JDEG3.12
  TOP w0.508: v7(44.77,147.83) PC815.2 ; v7(111.95,98.78) 112.22,98.52 PC734.2 ; v7(123.95,119.76) 123.89,119.83 PR500.1 ; JIO2.32 77.71,69.8 v7(76.35,68.44) ; C232.2 v7(80.06,72.85) ; PR346.2 158.99,123.56 v7(159.14,123.41) ; RC46.1 50.09,128.23 49.05,128.23 48.41,128.87 v7(48.41,129.53) ; PC132.1 v7(138.32,106.03) ; v7(137.72,116.92) PC339.2 ; JIO1.41 138.88,90.32 v12(138.66,90.54) ; v7(140.35,136.51) 140.84,137.01 PC725.2 ; PC723.2 140.11,137.14 v7(139.81,136.84) ; PC351.2 140.84,125.41 v7(141.07,125.64) ; v12(80.52,163.58) 80.84,163.9 PC1106.2 81.99,163.9 PC1007.2 ; PC407.2 69.28,77.28 69.72,77.73 v7(69.85,77.73) ; v7(132.44,142.38) 132.51,142.31 PC713.2 ; v7(69.93,68.52) PC404.2 PC403.2 ; PC814.2 v7(45.97,147.83) ; RH21.1 v12(57.34,107.89) ; PR272.2 30.19,21.44 v12(30.02,21.6) ; v12(130.94,133.54) 131.19,133.8 C23.2 ; v12(13.74,118.12) 13.28,117.66 JNGFF1.77 ; PC611.2 PC610.2 v7(102.87,119.45) ; v12(65.79,100.32) CC25.1 ; v7(145.16,116.71) PC323.2 ; v7(48.9,157.04) PC518.1 ; PC700.2 v12(132.84,137.66) ; v7(64.34,80.41) 64.73,80.41 65.6,81.27 JNGFF2.77 ; v7(133.85,145.05) 133.92,144.97 PC722.2 ; v7(102.87,120.72) PC614.2 ; CC19.2 76.58,108.4 v7(77.09,107.89) ; JIO1.42 138.88,91.73 v12(138.95,91.66) ; PC536.2 PR518.2 122.3,144.45 v7(122.27,144.48) ; RC37.1 98.76,137.1 v7(98.73,137.12) ; PC340.2 137.41,115.89 v7(137.73,116.21) ; PD105.1 140.34,102.44 v7(139.95,102.06) ; v12(82.57,72.41) Q32.3 ; CZ1.2 CC4.2 65.63,136.64 v7(65.56,136.64) ; PC1011.2 PC1112.2 63.93,163.92 v12(63.61,163.6) ; PR511.1 123.95,146.29 v7(124.43,146.78) ; CC15.2 v7(99.56,121.59) ; v7(84.2,2.7) 84.92,3.43 JSPK.8 ; JIO1.44 129.63,92 129.79,91.84 129.79,91.71 v7(129.97,91.53) 129.97,90.32 JIO1.43 ; PC400.2 78.11,72.14 v7(78.99,72.14) ; v7(133.35,143.38) PC712.2 ; PC510.2 PR516.2 122.03,118.04 v7(121.79,117.79) ; CT2.2 v7(1.7,33.85) ; PR825.2 PC819.2 v12(51.05,140.83) ; R31.1 122.61,133.47 v7(123.13,132.95) ; v7(110.69,94.54) PR731.2 ; v7(140.84,106.24) 140.64,106.03 PC126.2 ; CZ2.2 v12(68.12,105.55) ; PR708.1 v7(133.54,139.45) ; v7(144.15,119.64) PR285.2 ; JSPK.7 80,3.43 v7(79.56,3.87) ; v7(144.16,117.78) PC280.2 ; JT100.14 v7(152.59,105.94) ; JNGFF3.77 v7(18.37,52.01)
  IN1 w0.254: v14(35.37,113.86) 35.37,116.21 v14(37.05,117.89) v12(38.09,118.92) 39.2,120.04 v12(39.92,120.04) v14(40.7,120.04) 41.43,120.04 41.85,120.46 v12(44.08,120.46) 44.4,120.46 44.69,120.17 v12(49.71,120.17) ; v12(60.73,114.47) 61.46,114.47 61.95,113.98 v7(61.98,113.98) ; 67.5,15.5 v14(67.5,20.19) 67.5,25.6 ; 67.5,15.5 v14(66.67,15.5) 66,15.5 65.11,16.38 v14(65.11,20.97) 65.11,24.76 v14(60.33,29.54) v14(54.63,35.24) v14(48.45,41.42) 46.24,43.64 v14(46.24,46.17) v14(46.24,53.15) v14(46.24,59.57) 46.24,65.03 v14(44.87,66.4) 41.92,69.34 v14(38.3,69.34) v14(31.06,69.34) v14(25.21,69.34) 22.51,69.34 v14(19.66,72.2) 18.45,73.41 v14(18.45,79.17) v14(18.45,83.49) v14(18.45,87.44) 18.45,90.99 19.89,92.44 v14(19.89,98.41) 19.89,100.48 v12(17,103.37) 13.93,106.44 v12(13.93,107.34) v12(13.93,112.87) v12(13.93,113.37) 13.93,117.93 v12(13.74,118.12) 12.12,119.74 v14(12.12,121.99) v14(12.12,125.02) 12.12,127.52 v12(13.38,128.78) 15.79,131.19 v12(15.79,135.49) 15.79,136.13 v12(17.78,138.12) 20.12,140.46 v7(22.8,140.46) 25.07,142.73 v12(26.29,142.73) 27.27,142.73 28.82,144.28 28.82,146.32 v14(29.04,146.55) ; 67.5,15.5 67.5,12.32 v14(66.46,11.28) 65.45,11.28 64.1,12.64 64.1,13.82 62.8,15.11 v14(62.8,20.91) 62.8,23.84 v14(60.29,26.35) v14(54.83,31.81) v14(49.91,36.73) 48.45,36.73 43.21,41.98 43.21,46.23 v14(43.78,46.8) v14(43.78,54.42) v14(43.78,60.83) 43.78,63.92 v14(41.75,65.95) 40.65,67.04 37.95,67.04 v14(37.91,67.01) v14(30.86,67.01) v14(23.56,67.01) 21.61,67.01 v14(17.71,70.91) 16.15,72.47 v14(16.15,76.43) v14(16.15,81.69) v14(16.15,86.92) 16.15,92.24 17.39,93.47 17.39,99.75 v12(14.95,102.19) 11.64,105.49 v14(11.64,108.08) 11.64,109.46 9.77,111.33 v14(9.77,118.68) v14(9.77,122.99) v14(9.77,126.56) 9.77,128.4 v12(11.44,130.07) 13.5,132.14 v14(13.5,133.8) 13.5,137.07 v12(15.81,139.38) 17.73,141.3 v7(17.73,143.18) ; 44.4,167.46 43.61,167.46 43.61,167.45 ; 44.4,167.46 v12(45.94,167.46) v12(47.46,167.46) 49.03,167.46 v12(49.05,167.45) v12(50.5,167.45) v12(51.87,167.45) v12(53.42,167.45) v12(55.05,167.45) v12(56.64,167.45) v12(58.08,167.45) v12(59.59,167.45) v12(61.18,167.45) v12(62.65,167.45) v12(64.24,167.45) v12(65.79,167.45) v12(66.87,167.45) 67.11,167.45 67.48,167.08 v12(68.06,167.08) 68.22,167.08 68.59,167.45 v12(68.76,167.45) v12(70.26,167.45) v12(71.82,167.45) v12(73.39,167.45) v12(74.92,167.45) v12(76.47,167.45) v12(77.91,167.45) v12(79.45,167.45) v12(80.99,167.45) v12(82.59,167.45) v12(84.04,167.45) v12(85.64,167.45) v12(87.1,167.45) v12(89.41,167.45) v12(90.28,167.45) v12(91.78,167.45) v12(93.23,167.45) v12(94.75,167.45) v12(96.25,167.45) v12(97.82,167.45) v12(99.26,167.45) v12(100.83,167.45) v12(102.32,167.45) v12(103.89,167.45) v12(105.37,167.45) v12(106.96,167.45) 107.51,167.45 107.99,166.96 v12(108.66,166.96) 109.65,166.96 v12(109.8,167.11) v12(109.8,167.91) 109.8,169.16 v12(108.89,170.07) 108.61,170.35 108.61,170.75 ; 44.4,167.46 v12(44.41,167.45) 43.61,167.45 ; 26.23,122.56 v14(26.23,120.9) 24.2,118.88 v14(22.42,118.88) 21.68,118.88 19.56,116.75 v12(19.56,115.89) 19.18,115.51 19.18,109.97 20.15,109 v14(20.86,109) 20.87,109 ; v14(37.61,144.67) 38.16,145.23 v14(41.47,145.23) 42.55,145.23 42.67,145.1 42.67,144.76 42.92,144.51 42.92,143.3 v14(44.23,141.98) 45,141.22 v14(48.32,141.22) 48.48,141.37 50.51,141.37 v12(51.05,140.83) 51.41,141.19 54,141.19 54.23,141.42 56.9,141.42 58.19,140.12 61.05,140.12 61.19,139.98 61.53,139.98 62.26,139.26 62.26,137.06 v14(63.02,136.3) 63.99,135.32 v12(63.99,133.57) ; 108.61,170.75 v12(108.61,171.13) v12(108.61,173.1) v12(108.61,174.78) v12(109.41,175.58) 110.35,176.52 111.28,176.52 v12(111.68,176.13) 111.68,175.65 111.25,175.22 111.25,174.47 111,174.22 110.13,174.22 v7(109.83,173.92) 109.36,173.45 v12(109.36,173.04) v12(109.36,171.47) 109.91,170.92 v12(110.55,170.92) 110.76,170.71 110.76,170.17 111.04,169.89 111.46,169.89 112.57,168.78 112.57,167.55 110.99,165.97 v12(110.87,165.97) 110.5,165.97 110.25,166.22 v12(108.27,166.22) 107.69,166.22 v12(107.49,166.42) 107.22,166.68 v12(106.5,166.68) v12(105.13,166.68) v12(103.64,166.68) v12(102.07,166.68) v12(100.66,166.68) v12(99.17,166.68) v12(97.78,166.68) v12(95.89,166.68) v12(94.72,166.68) v12(92.96,166.68) v12(91.71,166.68) v12(90.12,166.68) v12(88.58,166.68) v12(87,166.68) v12(85.53,166.68) v12(84.04,166.68) v12(82.51,166.68) v12(81.04,166.68) v12(79.5,166.68) v12(77.83,166.68) v12(76.28,166.68) v12(74.76,166.68) v12(73.38,166.68) v12(71.81,166.68) v12(70.29,166.68) 69.44,166.68 69.1,166.34 v12(68.64,166.34) v12(67.18,166.34) 67.1,166.34 66.89,166.55 v12(65.47,166.55) v12(63.94,166.55) v12(62.17,166.55) v12(60.39,166.55) v12(58.61,166.55) v12(56.83,166.55) v12(55.05,166.55) 53.7,166.55 v12(53.5,166.36) 53.4,166.26 52.19,166.26 v12(52.06,166.39) v12(50.64,166.39) v12(49.3,166.39) v12(47.8,166.39) v12(46.32,166.39) v12(44.89,166.39) v14(43.12,166.39) v14(41.67,166.39) 40.87,166.39 v12(39.88,165.39) v12(38.61,164.12) 38.36,163.87 v12(38.36,162.68) 38.36,161.55 v12(38.26,161.45) v12(37.34,160.53) v12(35.31,160.53) v12(33.59,160.53) v12(32.26,160.53) 31.18,160.53 v12(30.99,160.72) v12(29.97,161.74) v12(29.11,162.59) 28.26,163.45 27.88,163.45 v7(27.43,163.9) v12(26.73,164.59) 26.26,165.07 v12(24.96,165.07) v12(23.62,165.07) v12(22.1,165.07) 20.86,165.07 v12(19.97,165.96) v12(18.73,167.2) 17.59,168.34 v12(17.59,168.49) v12(17.59,170.08) v12(17.59,171.48) v12(17.59,172.24) v7(17.59,172.91) 17.48,173.03 v12(17.48,174.55) 18.48,174.55 18.93,174.1 v12(18.93,172.82) 18.75,172.64 v12(18.75,171.45) v12(18.75,169.99) v12(18.75,168.72) 18.75,168.65 v12(19.97,167.42) v12(20.99,166.41) 21.22,166.17 v12(22.42,166.17) v12(23.94,166.17) v12(25.65,166.17) 26.85,166.17 v12(27.31,165.72) v12(28.47,164.55) v12(29.71,163.31) v12(30.88,162.14) 31.67,161.36 v12(32.32,161.36) v12(33.4,161.36) v12(34.73,161.36) 36.57,161.36 v12(37.01,161.79) 37.4,162.18 v12(37.4,163.5) 37.4,164.38 v12(38.82,165.8) 39.83,166.8 v12(39.91,166.8) 40.56,167.45 v12(41.44,167.45) 43.61,167.45 ; 108.61,170.75 108.61,170.75 ; v14(24.14,89.84) 23.39,89.1 v14(23.39,86.62) v14(23.39,81.39) 24.77,80.02 v14(24.77,77.73) 24.77,77.09 24.34,76.66 v14(22.88,76.66) ; v8(68.71,107.94) 68.24,107.47 v12(68.24,107.25) 66.77,105.78 66.77,104.03 65.79,103.05 v12(65.79,100.32) 65.85,100.26 v12(65.85,95.44) 65.1,95.44 62.24,92.57 v12(62.24,92.47) 62.23,92.47 v12(62.23,89.65) 62.23,87.52 62.66,87.09 62.66,86.48 62.41,86.22 61.67,86.22 ; v14(22.88,76.66) 22.88,73.19 23.54,72.53 v14(27.42,72.53) v14(29.65,72.53) ; v14(22.88,76.66) 22.84,76.69 v14(22.84,78.3) 22.84,80.29 22.23,80.91 v14(22.23,81.6) v14(22.23,86.74) 22.23,89.58 23.48,90.83 23.48,90.82 v14(23.79,91.14) 24.19,91.54 24.19,94.49 v14(23.69,94.99) 23.69,98.74 v14(24.19,99.24) v14(24.19,104.08) 24.19,104.63 21.15,107.67 v14(19.72,107.67) 17.89,109.5 v12(17.89,111.83) 17.89,116.95 19.72,118.77 v14(19.72,119.06) ; v7(26.48,148.04) 26.98,148.54 30.57,148.54 31.21,147.9 v12(31.21,146.56) 31.31,146.47 31.31,143.46 28.28,140.44 26.29,140.44 23.85,138 v12(23.64,138) 21.05,138 v12(19.27,136.23) 18.19,135.15 v14(18.19,131.51) 18.19,130.36 v14(16.76,128.93) v14(14.66,126.82) 14.4,126.57 14.4,123.6 16.76,121.24 16.76,118.44 16.21,117.89 v14(16.21,110.68) 16.21,107.39 22.18,101.42 v14(22.18,98.24) v14(22.18,92.52) 22.18,91.49 20.73,90.05 v14(20.73,87.12) v14(20.73,80.77) 20.73,78.07 v14(22.22,76.58) 22.35,76.45 22.35,72.73 23.46,71.63 v14(24.97,71.63) v14(28.71,71.63) v14(36.59,71.63) v12(42.68,71.63) 42.9,71.63 v14(44.42,70.11) 48.52,66.01 v14(48.52,62.83) v14(48.52,56.8) v14(48.52,51.16) v14(48.52,45.68) ; v14(42.84,138.17) 42.93,138.09 42.93,137.1 43.18,136.84 43.89,136.84 44.08,137.04 v14(47.31,137.04) 49.33,135.02 50.93,135.02 51.99,133.95 v14(53.04,133.95) ; 53.21,108.4 52.61,108.4 51.06,109.95 v14(49.72,109.95) 49.35,109.95 v14(47.14,107.74) v14(44.63,105.23) v14(42.13,102.72) 39.83,100.42 v14(39.8,100.42) 39.8,100.4 ; 53.21,108.4 v14(53.21,109.73) 53.21,112.17 v7(53.49,112.45) 53.7,112.66 v12(53.98,112.66) 54.15,112.82 v12(54.61,112.82) ; 53.21,108.4 53.21,107.89 52.83,107.51 52.13,107.51 51.11,108.52 50.19,108.52 v14(48.56,106.89) ; v14(29.65,72.53) v14(35.48,72.53) 36.59,73.64 v14(39.31,73.64) v12(42.7,73.64) 44.8,73.64 v14(45.56,74.4) v14(49.97,78.81) 50.27,78.81 51.21,79.74 51.21,82.58 v12(51,82.79) 51,84.11 51.59,84.7 51.59,85.43 v14(52.07,85.92) 52.88,86.73 53.37,86.73 53.87,86.22 v14(55.42,86.22) v14(58.9,86.22) 61.67,86.22 ; v14(29.65,72.53) 29.65,73.85 30.22,74.42 v14(33.72,74.42) v14(39.18,74.42) 44.48,74.42 v14(44.85,74.79) v14(49.01,78.95) 49.5,79.44 v12(49.5,82.79) 49.5,84.61 v14(51.66,86.77) 52.73,87.84 v14(53.79,87.84) 54.25,88.31 v14(57.53,88.31) 59.58,88.31 61.67,86.22 ; v14(43.59,126.02) 43.9,126.34 v14(45.28,126.34) v12(45.95,126.34) 46.47,126.34 46.51,126.38 46.69,126.38 v14(46.72,126.35) ; v14(39.62,96.2) 39.62,94.95 v14(36.85,92.18) 35.58,90.91 35.28,90.91 34.96,90.59 34.96,90.3 34.49,89.83 v12(34.49,88.25) v14(34.49,87.01) 34.49,86.39 v14(32.38,84.27) 30.88,82.77 v14(30.88,82.38) ; v14(30.88,82.38) v14(29.84,81.35) 29.84,80.27 v14(31.24,78.87) 31.7,78.41 v14(36.51,78.41) v14(40.5,78.41) 43.34,81.25 v12(44.9,81.25) 44.9,80.74 43.57,79.41 42.6,79.41 v14(40.82,77.63) v14(36.26,77.63) 31.38,77.63 v14(30.85,78.16) 29.07,79.95 v14(29.07,82.06) v14(31.83,84.82) 33.33,86.32 v14(33.33,87.57) 33.33,91.11 32.94,91.49 ; v14(30.88,82.38) 31.13,82.13 32.17,82.13 v14(33.76,83.72) 35.59,85.55 v14(35.59,86.87) 35.59,89.84 40.79,95.04 40.79,97.7 v14(43.11,100.02) 43.18,100.09 44.67,101.58 44.67,101.73 44.91,101.97 ; 57.3,110.19 57.3,110.19 57.3,110.22 59.54,112.46 v12(59.54,113.25) v7(59.54,113.81)
  GND1 w0.203: JUSB1.12 9.99,95.9 ; JUSB1.12 9.99,97.04 ; JUSB1.12 9.99,96.47 ; JUSB1.12 9.02,95.9 ; JUSB1.12 9.02,97.04 ; 158.81,108.71 H3.1 ; H3.1 158.81,110.89 ; H3.1 161.42,109.8 ; H3.1 160.99,108.71 ; H3.1 159.9,108.28 ; H3.1 158.38,109.8 ; H3.1 159.9,111.32 ; H3.1 160.99,110.89 ; H11.1 104.77,133.12 ; H11.1 101.31,134.56 ; H11.1 103.33,132.54 ; H11.1 104.77,136 ; H11.1 105.35,134.56 ; H11.1 101.89,133.12 ; H11.1 101.89,136 ; H11.1 103.33,136.58 ; 80.45,13.6 H12.1 ; H12.1 83.55,10.5 ; H12.1 80.45,10.5 ; H12.1 79.83,12.05 ; H12.1 82,14.22 ; H12.1 82,9.88 ; H12.1 84.17,12.05 ; H12.1 83.55,13.6 ; 46.2,111.24 H5.1 ; H5.1 48.22,113.26 ; H5.1 44.76,111.82 ; H5.1 44.18,113.26 ; H5.1 47.64,111.82 ; H5.1 47.64,114.7 ; H5.1 46.2,115.28 ; H5.1 44.76,114.7 ; 118.5,87.28 H4.1 ; H4.1 119.59,89.89 ; H4.1 117.41,89.89 ; H4.1 119.59,87.71 ; H4.1 116.98,88.8 ; H4.1 117.41,87.71 ; H4.1 118.5,90.32 ; H4.1 120.02,88.8 ; H2.1 160.92,163.15 ; H2.1 158.31,164.24 ; H2.1 160.49,162.06 ; H2.1 160.49,164.24 ; H2.1 159.4,161.63 ; H2.1 157.88,163.15 ; H2.1 158.31,162.06 ; H2.1 159.4,164.67 ; H13.1 103.77,112 ; H13.1 100.31,110.56 ; H13.1 100.89,109.12 ; H13.1 102.33,108.54 ; H13.1 102.33,112.58 ; H13.1 104.35,110.56 ; H13.1 103.77,109.12 ; H13.1 100.89,112 ; 5.8,28.53 JUSBC2.B12 ; JUSBC2.B12 6.11,28.64 ; JUSBC2.B12 5.49,29.26 ; JUSBC2.B12 5.8,29.37 ; JUSBC2.B12 6.22,28.95 ; JUSB1.4 9.43,99.37 ; JUSB1.4 8.81,99.99 ; JUSB1.4 9.26,99.82 ; JUSB1.4 8.81,98.75 ; JUSB1.4 8.36,99.82 ; JUSB1.4 9.26,98.92 ; JUSB1.4 8.36,98.92 ; H1.1 110.5,161.67 ; H1.1 109.41,161.24 ; H1.1 108.98,160.15 ; H1.1 111.59,159.06 ; H1.1 110.5,158.63 ; H1.1 109.41,159.06 ; H1.1 112.02,160.15 ; H1.1 111.59,161.24 ; H10.1 45.79,135.39 ; H10.1 47.81,133.37 ; H10.1 44.35,131.93 ; H10.1 45.79,131.35 ; H10.1 47.23,134.81 ; H10.1 47.23,131.93 ; H10.1 44.35,134.81 ; H10.1 43.77,133.37 ; JUSBC2.B1 6.22,23.35 ; JUSBC2.B1 6.11,23.66 ; JUSBC2.B1 5.8,23.77 ; JUSBC2.B1 5.49,23.04 ; 1.18,150.44 SW1.4 ; SW1.4 1.65,152 ; SW1.4 1.65,150.44 ; SW1.4 2.17,152 ; H6.1 12.72,90.75 ; H6.1 10.11,91.84 ; H6.1 12.29,91.84 ; H6.1 12.29,89.66 ; H6.1 9.68,90.75 ; H6.1 10.11,89.66 ; H6.1 11.2,92.27 ; H6.1 11.2,89.23 ; 5.49,37.64 JUSBC1.B1 ; JUSBC1.B1 6.11,38.26 ; JUSBC1.B1 6.22,37.95 ; JUSBC1.B1 5.8,38.37 ; JUSB1.11 9.02,109.84 ; JUSB1.11 9.99,108.7 ; JUSB1.11 9.99,109.84 ; JUSB1.11 9.99,109.27 ; 79.28,71.72 JCR1.23 ; JCR1.23 80.61,71.72 ; JCR1.23 79.28,70.65 ; JCR1.23 79.28,69.58 ; JCR1.23 80.61,70.65 ; JCR1.23 79.94,71.72 ; JCR1.23 79.94,69.58 ; JCR1.23 80.61,69.58 ; 1.18,136.34 SW2.4 ; SW2.4 2.17,137.9 ; SW2.4 1.65,136.34 ; SW2.4 1.65,137.9 ; JUSB1.7 10.76,103.32 ; JUSB1.7 10.93,102.87 ; JUSB1.7 9.86,103.32 ; JUSB1.7 10.76,102.42 ; JUSB1.7 10.31,102.25 ; JUSB1.7 9.86,102.42 ; JUSB1.7 10.31,103.49 ; JUSB1.7 9.69,102.87 ; JCR1.22 66.21,71.72 ; JCR1.22 66.21,69.58 ; JCR1.22 66.21,70.65 ; JCR1.22 64.88,69.58 ; JCR1.22 65.54,69.58 ; JCR1.22 64.88,71.72 ; JCR1.22 65.54,71.72 ; JCR1.22 64.88,70.65 ; 0.91,111.34 JUSB1.13 ; JUSB1.13 3.15,111.34 ; JUSB1.13 0.91,110.77 ; JUSB1.13 2.03,111.34 ; JUSB1.13 3.15,110.77 ; SW1.5 1.65,155.67 ; SW1.5 1.18,155.67 ; SW1.5 1.65,154.12 ; SW1.5 2.17,154.12 ; 5.49,43.86 JUSBC1.B12 ; JUSBC1.B12 5.8,43.13 ; JUSBC1.B12 5.8,43.97 ; JUSBC1.B12 6.11,43.24 ; JUSBC1.B12 6.22,43.55 ; 2.03,94.4 JUSB1.14 ; JUSB1.14 3.15,94.97 ; JUSB1.14 0.91,94.4 ; JUSB1.14 3.15,94.4 ; JUSB1.14 0.91,94.97 ; SW2.5 2.17,140.02 ; SW2.5 1.65,141.57 ; SW2.5 1.65,140.02 ; SW2.5 1.18,141.57
  GND1 w0.254: v4(69.15,114.76) 69.31,114.61 v12(69.31,114.47) ; v12(89.01,114.47) 89.01,114.88 v7(89.08,114.95) ; v4(81.92,112.92) 81.67,113.17 v12(81.65,113.17) ; v12(68.03,114.47) v4(68.39,114.47)
  IN2 w0.203: v16(69.34,135.64) 68.77,136.21 68.77,136.35 66.02,139.1 v16(66.02,139.11)
  IN2 w0.254: v16(43.26,110.85) v16(44.58,109.54) 46.47,107.64 v16(46.47,106.36) 46.35,106.25 46.35,101.78 v16(46.47,101.67) 46.47,99.77 47.08,99.16 47.08,99.12 47.67,98.54 v16(47.67,97.73) 47.67,94.51 48.86,93.32 v16(49.47,93.32) 50.63,93.32 51.8,92.15 v16(51.8,91.25) 51.8,88.09 v16(52.9,87) 53.85,86.04 53.85,85.28 v16(54.61,84.52) ; v16(27.97,107.75) 27.97,108.39 26.59,109.76 26.59,109.97 24.8,111.76 v16(24.8,112.96) 24.8,115.44 v16(26.99,117.63) ; v16(33.91,125.36) 33.91,123.94 31.27,121.3 v16(31.27,120.94) 31.27,115.7 31.29,115.69 v16(31.29,115.56) 31.29,115.48 31.4,115.37 v16(31.4,110.71) 31.4,108.13 32.84,106.69 v16(32.84,104.54) 32.84,101.49 36.46,97.86 v16(36.46,96.56) 36.46,92.71 v3(34.71,90.95) 34.01,90.26 v16(34.01,87.06) 34.01,83.68 v16(33.59,83.26) 33.59,76.98 34.15,76.42 v16(34.15,75.76) 34.15,74.3 v16(31.84,71.99) v16(28.15,68.3) 26.78,66.93 v16(26.17,66.93) ; v16(33.91,125.36) 30.22,125.36 28.83,123.97 v16(28.83,121.86) v16(28.83,116.27) 28.83,111.92 28.96,111.8 28.96,107.66 29.3,107.32 v16(29.3,104.97) 29.31,104.95 29.31,98.84 v16(29.36,98.8) 29.47,98.68 29.47,98.22 31.02,96.67 31.02,94.19 v16(30.72,93.89) 29.48,92.65 v16(27.81,92.65) 25.65,92.65 v16(25.17,93.14) ; v16(33.91,125.36) 33.91,126.09 v16(36.84,129.02) 40.99,133.17 v16(40.99,133.19) 40.99,134.33 v16(42.96,136.3) 44.11,137.45 v16(47.78,137.45) 48.13,137.1 49.28,137.1 50.68,138.5 51.72,138.5 52.93,137.28 52.93,136.59 54.22,135.3 54.84,135.3 v7(55.5,135.96) ; v16(66.02,139.11) 63.27,141.85 v16(62.48,141.85) v16(57.02,141.85) v16(52.2,141.85) 51.65,141.3 47.67,141.3 47.39,141.02 v16(43.81,141.02) 41.58,141.02 v16(39.85,139.29) v16(36.61,136.05) 36.23,135.67 ; v16(26.17,66.93) 25.92,67.18 25.92,68.13 v16(28.58,70.8) 30.75,72.96 30.75,74.1 v16(25.59,79.25) 23.52,81.33 v16(23.52,85.03) 23.52,91.49 v16(25.17,93.14) ; v16(26.17,66.93) 26.17,66.37 25.92,66.12 25.92,63.2 v16(24.76,62.04) 23.47,60.76 23.47,57.89 v16(24.89,56.47) 24.89,55.31 25.74,54.46 27.09,54.46 ; 27.09,54.46 27.67,54.46 29.82,52.31 v16(29.82,49.82) 29.82,47.87 31.33,46.36 31.33,37.39 31.08,37.14 30.19,37.14 29.94,37.39 29.94,38 30.4,38.46 v16(30.4,42.1) 30.4,46 28.83,47.56 v16(28.83,48.45) 28.83,51.8 27.66,52.98 v3(26.97,52.98) v3(25.47,52.98) ; 27.09,54.46 v7(27.09,55.42) 27.09,55.47 25.55,57.01 v7(25.55,58.99) 25.55,60.59 v16(27.61,62.65) ; v7(77.03,32.7) v16(74.09,32.7) v16(70.32,36.48) v16(66.85,39.95) v16(66.85,46.55) v16(66.85,53.02) v16(66.85,59.88) v16(66.85,67.5) v16(66.85,73.6) 66.82,73.62 v4(66.82,76.33) 66.82,79.67 v16(66.85,79.69) 66.85,80.78 66.28,81.35 v16(66.28,84.77) 66.28,86.07 67.88,87.68 v16(67.88,88) 67.88,88.09 69.13,89.34 71.43,89.34 72.8,90.7 ; v16(107.44,149.29) v16(109.66,151.51) v16(112.46,154.31) v16(112.46,156.91) v16(114.38,158.83) v16(114.38,162.37) v16(114.38,165.23) v16(114.38,168.85) v16(114.38,171.08) v16(115.38,172.09) v16(116.97,172.09) 117.22,171.83 v16(117.22,169.74) v16(117.22,167.3) v16(118.54,165.98) v16(120.28,164.24) v16(120.28,161.99) v16(120.28,158.75) v16(120.28,155.45) 120.28,153.52 v16(119.34,152.57) v16(116.67,149.91) v16(114.85,148.09) 113.51,146.75 113.51,145.86 113.36,145.71 v16(113.36,145.48) 113.36,144.01 v16(113.46,143.91) 113.46,142.48 v16(112.69,141.71) 110.54,139.56 v16(105.92,139.56) 104.27,139.56 v16(104.22,139.51) 98.65,139.51 v16(98.63,139.49) v16(95.86,139.49) 93.7,139.49 92.13,137.91 v16(86.39,137.91) 84.86,137.91 84.35,138.42 v16(83.57,138.42) v16(81.05,138.42) v16(79.36,136.73) 77.98,135.34 v16(77.98,135.07) ; v16(77.03,90.7) v16(73.66,90.7) 72.8,90.7 ; v16(77.03,90.7) 77.03,90.04 77.39,89.68 78.83,89.68 79.42,90.27 v16(79.42,90.7) ; v16(77.03,90.7) v16(79.42,90.7) ; 72.8,90.7 v16(70.58,90.7) 70.45,90.7 v16(69.16,91.99) 68.91,91.99 v16(67.79,93.11) 67.79,93.38 64.07,97.11 v16(64.07,97.21) v16(64.07,103.7) 64.07,104.02 63.41,104.68 v16(63.41,109.16) 63.41,109.54 63.43,109.54 65.71,111.83 v16(66.04,111.83) ; v16(43.99,16.91) 45.08,18 v16(46.22,18) v16(50.09,18) ; v16(27.61,62.65) 27.61,62.98 27.35,63.24 27.35,65.4 v16(29.2,67.25) v16(33.2,71.25) 35.6,73.65 v16(35.6,76.35) 35.6,77.2 35.03,77.78 35.03,82.44 35.44,82.85 v16(35.44,83.49) v16(35.44,89.23) ; v16(27.61,62.65) 28.72,62.65 30.71,64.64 v16(30.71,64.86) v16(35.28,69.43) v16(39.87,74.02) v16(39.87,78.81) v16(39.87,84.77) 39.87,85.96 42.57,88.66 v16(42.57,89.09) v16(42.57,95.98) v16(42.57,99.35) 42.55,99.38 v16(42.55,102.25) 42.55,104.03 v16(41.55,105.02) v16(39.6,106.97) 38.82,107.75 v16(38.82,110.05) v16(38.82,116.27) 38.82,120.1 v16(39.17,120.45) 39.86,121.15 39.86,124.79 41.15,126.08 v16(41.9,126.08) 42.3,126.08 43.5,127.28 v16(43.5,130.81) 42.98,131.33 42.14,131.33 v16(41.66,131.81) v16(37.66,127.82) 35.34,125.5 v16(35.34,122.98) v16(32.7,120.34) 32.13,119.77 32.13,115.83 v16(32.7,115.25) 32.28,114.84 32.28,108.44 v16(33.23,107.5) 33.88,106.84 33.88,101.77 37.52,98.13 37.52,97.73 v16(37.47,97.68) 37.47,92.27 v16(37.34,92.14) ; v16(27.25,121.5) 27.25,124.56 v16(28.73,126.04) 29.87,127.18 v16(31.82,127.18) 32.93,127.18 32.93,127.2 v16(34.84,129.11) v16(38.58,132.86) 39.34,133.62 39.34,134.94 v16(41.12,136.72) ; v16(102.07,98.36) 102.07,99.14 103.61,100.69 v16(103.61,104.71) 103.61,105.27 v16(107.04,108.69) v16(107.04,113.24) v16(104.65,115.64) v16(100.58,119.7) 98.26,122.02 98.04,122.02 v16(96.09,123.97) ; v16(102.07,98.36) 102.49,97.94 v16(102.49,94.3) 102.49,92.47 101.78,91.76 99.95,91.76 v16(99.82,91.89) ; v16(102.07,98.36) 101.28,97.58 v16(101.28,97.03) 99.82,95.57 v16(99.82,94.81) v16(99.82,91.89) ; 109.92,125.03 v7(110.74,125.03) 110.74,124.16 v16(112.34,122.56) 114.9,120.01 v3(114.9,119.55) v3(114.9,118.35) v3(114.9,116.32) v3(114.9,114.28) v3(114.9,112.25) v3(114.9,110.22) 114.91,110.21 114.91,107.71 v16(113.12,105.92) 111.08,105.92 v16(109.16,104.01) v16(105.64,100.48) 105.64,99.85 104.51,98.73 v16(104.51,96.84) v16(104.51,92.01) 104.51,91.63 102.17,89.3 100.09,89.3 99.37,88.58 v16(97.92,88.58) v16(94.87,88.58) 94.17,88.58 93.73,89.02 v16(91.44,89.02) v16(86.87,89.02) v16(81.79,89.02) 81.04,89.02 79.58,87.57 v16(77.6,87.57) 76.32,87.57 75.31,88.58 v16(74.68,88.58) 73.71,88.58 72.54,87.42 v16(72.01,87.42) 70.16,87.42 69.91,87.16 69.91,86.84 68.7,85.63 v16(68.7,84.65) 68.7,81.79 68.87,81.62 v16(68.87,80.08) v16(68.87,73.98) v16(68.87,67.88) v16(68.87,61.28) v16(68.87,55.56) 68.87,51.4 v7(69.28,50.99) v7(69.28,50.36) v7(69.28,49.72) v16(69.28,42.99) 69.28,40.45 v7(70.74,38.99) 73.6,36.13 v16(74.8,36.13) 78.17,36.13 v16(79.28,35.02) ; v16(79.63,143.53) v16(74.99,143.53) v16(71.47,143.53) v16(69.87,141.93) v16(69.87,138.22) 71.53,136.56 v3(71.53,135.8) ; 19.7,102.2 20.48,102.2 21.41,103.14 v4(21.41,103.62) 21.41,104.81 v16(18.7,107.52) 18.09,108.13 18.09,111.7 v16(17.2,112.59) 17.2,115.08 16.25,116.04 v16(16.25,119.57) 16.25,121.23 15.67,121.81 15.67,124.93 16.44,125.7 v16(17.11,125.7) 19.53,128.12 v16(23.24,128.12) ; v16(25.17,93.14) 25.61,93.58 25.61,95.02 23.65,96.98 v16(23.65,97.27) 23.65,101.41 24.27,102.04 v16(24.27,104.59) 24.27,106.34 22.02,108.59 22.02,109.66 21.38,110.3 21.38,113.46 21.97,114.05 21.97,114.53 v3(21.88,114.62) 21.02,115.48 21.02,117.44 20.8,117.65 20.8,119.6 v16(20.4,120) 19.79,120.61 19.79,122 v16(20.32,122.53) 21.23,122.53 v16(23.1,124.41) 23.98,125.28 24.28,125.28 v16(28.79,129.79) 31.67,132.67 v16(31.73,132.67) ; v16(78.41,5.02) v7(79.56,3.87) 80.72,2.7 82.04,2.7 ; v16(62.12,112.82) 61.61,112.31 v16(61.61,111.7) 61.61,111.51 59.97,109.87 59.97,108.31 v16(59.66,107.99) 59.66,107.98 58.79,107.12 58.79,105.98 57.97,105.15 v16(57.97,103.57) 57.97,100.36 v3(59.05,99.27) 60.61,97.71 60.61,95.73 v16(62.2,94.14) v16(65.78,90.56) 65.78,86.92 v16(65.28,86.41) v16(65.28,81.47) 65.28,79.72 v7(64.41,78.85) 62.1,76.55 v7(62.1,74.68) 62.1,72.71 v16(60.33,70.93) v16(60.33,62.17) ; v16(79.42,90.7) 79.87,91.15 v16(82.8,91.15) v16(86.87,91.15) v16(91.95,91.15) 94.46,91.15 95.01,90.6 v16(96.14,90.6) 98.54,90.6 v16(99.82,91.89) ; v16(41.12,136.72) 42.82,138.41 v16(46.35,138.41) v16(48.72,138.41) ; v16(41.12,136.72) 41.12,136.74 ; v16(69.34,135.64) 69.66,135.32 69.66,133.38 70.68,132.36 v16(70.68,132.27) ; v16(50.23,84.01) v16(50.23,90.36) 50.23,91.63 49.97,91.88 48.14,91.88 47.65,92.37 ; v16(109.41,122.56) 112.78,119.19 v16(112.78,115.13) v16(112.78,111.44) 112.78,108.52 112.2,107.94 v16(110.1,107.94) 108.2,106.05 v7(108.08,106.05) ; 39.55,37.28 39.55,36.55 38.2,35.21 v16(38.2,34.15) 38.59,33.76 38.59,32.66 ; v16(45.31,20.36) v16(49.19,20.36) v16(52.07,20.36) ; 22.49,48.97 v16(21.69,48.97) 20.79,49.87 20.79,50.32 ; 22.49,48.97 22.99,49.47 24,49.47 24.64,48.83 25.78,48.83 26.1,49.16 26.1,49.98 25.48,50.6 v16(24.64,50.6) 23.19,50.6 v16(21.8,51.99) v16(21.8,58.1) 21.8,61.57 v16(20.13,63.25) 19.58,63.8 v16(19.58,68.01) v16(19.58,77.15) v16(19.58,84.65) v16(19.58,90.24) ; 22.49,48.97 22.49,48.26 24.26,46.5 24.26,45.21 25.06,44.41 v16(25.06,44.27) 25.06,35.66 v16(24.89,35.5) 24.89,32.98 v16(22.96,31.05) 22.23,31.05 21.97,31.31 21.97,31.94 v4(21.84,32.07) 21.84,33.36 23.16,34.69 23.16,43.7 22.36,44.5 22.36,45.94 16.83,51.47 v16(16.83,52.52) v16(16.83,58.87) v16(16.83,67.63) v16(16.83,75.25) v16(16.83,85.79) 16.83,92.33 v16(16.51,92.65) 15.24,93.92 15.24,97.98 12.57,100.65 12.57,100.78 ; 46.67,143.43 46.31,143.07 v16(42.55,143.07) 40.77,143.07 v16(37.78,140.08) v16(35.18,137.48) 34.63,136.93 33.07,136.93 v16(31.67,135.53) v16(28.05,131.91) 24.26,128.12 v16(23.24,128.12) ; v16(23.24,128.12) 23.24,127.42 20.4,124.58 19.94,124.58 v16(19.51,124.58) 18.64,123.71 17.76,122.84 v16(17.76,120.21) 17.76,119.38 18.64,118.51 18.64,116.95 19,116.6 v16(19,115.93) 19,112.89 19.36,112.53 v16(19.36,109.62) 19.36,109.13 22.78,105.71 v16(22.78,105.35) 22.78,102.66 22.12,101.99 v16(22.12,100.57) v16(22.12,96.64) 22.12,96.48 24.08,94.52 24.08,94.08 23.9,93.9 22.09,92.09 v16(22.09,90.11) v16(22.09,84.39) 22.09,80.73 v16(23.69,79.13) 25.08,77.74 v16(25.08,74.61) v16(25.08,66.99) 25.08,63.81 v16(23.91,62.64) 22.63,61.37 v16(22.63,57.72) ; v16(47.5,127.48) v16(45.58,125.56) 45.37,125.35 45.2,125.35 v16(42.65,122.8) 42.21,122.37 v16(42.21,120.33) 42.21,119.81 41.43,119.02 v16(41.43,116.27) v16(41.43,111.32) 41.43,109.62 v16(43.04,108) 44.67,106.38 v16(44.67,103.95) 44.67,99.34 v16(44.73,99.28) ; v7(49.53,144.1) 51.93,144.1 v16(52.16,143.87) v16(58.8,143.87) v16(64.12,143.87) v16(68.02,139.97) ; v4(54.79,19.88) 54.79,19.84 54.85,19.78 54.85,18.25 v16(54.6,18) ; v16(44.73,99.28) 44.73,98.57 44.45,98.29 44.45,92.8 44.22,92.57 44.22,87.82 43.71,87.31 43.71,86.22 ; v16(44.73,99.28) v16(46.24,97.77) 46.24,93.76 46.86,93.13 v16(46.86,92.95) ; 36.23,135.67 35.41,134.85 33.91,134.85 v16(33.38,134.32) v16(31.73,132.67) ; 36.23,135.67 36.23,134.2 v16(34.89,132.86) 34.25,132.22 32.17,132.22 v16(31.73,132.67) ; v16(2.39,125.49) 3.16,125.49 v16(6.11,128.45) v16(12.53,134.86) 15.61,137.94 v16(16.64,137.94) v16(21.93,137.94) 22.8,138.81 v7(22.8,140.46) 22.8,141.82 v16(19.23,145.38) v16(19.23,153.1) v16(19.23,157.67) v16(19.23,163.26) 17.59,164.9 v7(17.59,172.91) 17.59,175.45 17.87,175.73 18.69,175.73 19.13,175.3 v16(19.13,170.52) 19.13,165.43 20.23,164.33 v16(20.23,164.02) v16(20.23,157.93) v16(20.23,149.8) 20.23,146.51 v16(24.94,141.8) 24.94,139.18 v16(22.92,137.16) v16(16.26,137.16) 15.64,137.16 v16(12.17,133.69) v16(6.45,127.98) 4.26,125.78 4.25,125.78 3.14,124.66 v16(2.4,124.66) ; v7(36.32,55.33) 36.32,56 v16(34.67,57.65) 34.67,62.1 v16(35.94,63.37) 37.49,63.37 v16(39.51,65.4) 39.63,65.52 40.08,65.52 40.39,65.83 40.39,69.32 v16(41.38,70.32) 42.82,71.75 v16(42.82,76.65) 42.82,80.5 v16(43.07,80.75) 43.77,80.75 44.32,80.2 v16(44.32,79.06) v16(44.32,75.63) v16(44.32,71.5) v4(41.98,69.15) 41.27,68.45 41.27,65.47 v16(40.94,65.14) 38.1,62.3 v16(36.32,62.3) 35.51,61.48 v16(35.51,59.12) 35.51,58 38.1,55.42 v7(38.1,55.33) ; 78.84,32.48 v7(79.25,32.89) ; 69.22,15.11 69.34,15.24 71.61,15.24 v16(73.55,13.3) v16(76.82,10.04) v16(80.39,6.47) 82.04,4.81 82.04,2.7 ; 82.04,2.7 v7(84.2,2.7) 84.52,3.02 v7(84.52,5.44) 84.52,5.77 v16(81.56,8.73) ; v16(77.58,6.11) v16(75.14,8.55) v16(73.13,10.56) 72.2,11.5 69.53,11.5 v16(69.22,11.81) ; v16(39.23,25.74) v16(45.58,32.09) v16(52.18,38.69) v16(58.28,44.79) ; v16(78.78,11.42) v16(76.99,13.21) v16(74.68,15.52) v16(72.05,18.15) 71.46,18.73 69.47,18.73 v16(69.22,18.48) ; v3(94.85,129.29) 95.07,129.29 v16(96.34,128.02) 97.3,127.06 98.37,125.99 v16(101.72,125.99) v16(108.84,125.99) ; 43.94,144.46 42.93,144.46 v16(42.41,144.98) v16(35.76,144.98) v16(32.04,141.26) v16(27.59,136.81) v16(23.86,133.08) v16(17.95,133.08) 10.22,125.35 v16(10.22,124.02) 10.22,118.52 v16(12.46,116.28) 12.46,114.34 12.63,114.17 v16(12.63,102.4) ; v16(57.91,126.03) 57.96,125.98 58.16,125.98 58.53,125.6 v7(58.53,125.18) 58.53,124.61 57.48,123.56 57.15,123.56 57.13,123.54 56.85,123.54 56.83,123.56 56.45,123.56 56.18,123.29 56.18,122.91 56.2,122.89 54.67,121.36 54.67,121.04 54.42,120.79 53.98,120.79 v16(51.1,117.92) v16(51.1,113.48) 51.1,111.67 50.55,111.11 v16(50.55,109.79) 50.55,106.65 v16(50.88,106.32) 51.67,105.53 v16(51.67,103.19) v16(51.67,98.11) 51.67,96.78 v16(53.56,94.9) 54.46,93.99 54.46,93.18 55.35,92.3 v16(55.35,91.25) 55.35,89.38 57.27,87.46 v16(57.27,86.68) v16(57.27,81.85) 57.27,81 v16(53.25,76.98) v16(53.25,70.68) v16(53.25,63.31) 53.25,56.19 v16(52.48,55.41) v16(47.41,50.34) v16(42.42,45.35) 39.19,42.13 v7(39.19,38.29) ; v16(61.09,86.93) 60.83,87.19 60.83,88.9 59.94,89.79 v16(59.94,91.24) 60.18,91.24 61.57,89.84 61.57,87.34 61.16,86.93 v16(61.09,86.93)
  GND2 w0.203: H1.1 112.02,160.15 ; H1.1 108.98,160.15 ; H1.1 109.41,161.24 ; H1.1 110.5,161.67 ; H1.1 110.5,158.63 ; H1.1 109.41,159.06 ; H1.1 111.59,159.06 ; H1.1 111.59,161.24 ; 1.18,155.67 SW1.5 ; SW1.5 2.17,154.12 ; SW1.5 1.65,154.12 ; SW1.5 1.65,155.67 ; H2.1 159.4,164.67 ; H2.1 158.31,164.24 ; H2.1 160.92,163.15 ; H2.1 159.4,161.63 ; H2.1 160.49,164.24 ; H2.1 157.88,163.15 ; H2.1 158.31,162.06 ; H2.1 160.49,162.06 ; JUSBC1.B12 6.22,43.55 ; JUSBC1.B12 5.8,43.97 ; JUSBC1.B12 6.11,43.24 ; JUSBC1.B12 5.49,43.86 ; JUSBC1.B12 5.8,43.13 ; H10.1 47.23,134.81 ; H10.1 44.35,134.81 ; H10.1 47.23,131.93 ; H10.1 44.35,131.93 ; H10.1 45.79,135.39 ; H10.1 43.77,133.37 ; H10.1 47.81,133.37 ; H10.1 45.79,131.35 ; JUSB1.13 3.15,111.34 ; JUSB1.13 3.15,110.77 ; JUSB1.13 0.91,110.77 ; JUSB1.13 0.91,111.34 ; JUSB1.13 2.03,111.34 ; 159.9,108.28 H3.1 ; H3.1 158.81,110.89 ; H3.1 160.99,110.89 ; H3.1 159.9,111.32 ; H3.1 158.38,109.8 ; H3.1 160.99,108.71 ; H3.1 161.42,109.8 ; H3.1 158.81,108.71 ; JUSB1.11 9.99,109.27 ; JUSB1.11 9.99,108.7 ; JUSB1.11 9.99,109.84 ; JUSB1.11 9.02,109.84 ; H5.1 47.64,111.82 ; H5.1 48.22,113.26 ; H5.1 44.76,114.7 ; H5.1 46.2,111.24 ; H5.1 44.18,113.26 ; H5.1 46.2,115.28 ; H5.1 47.64,114.7 ; H5.1 44.76,111.82 ; 1.65,150.44 SW1.4 ; SW1.4 1.65,152 ; SW1.4 2.17,152 ; SW1.4 1.18,150.44 ; 10.31,102.25 JUSB1.7 ; JUSB1.7 9.69,102.87 ; JUSB1.7 10.76,103.32 ; JUSB1.7 10.31,103.49 ; JUSB1.7 10.76,102.42 ; JUSB1.7 9.86,103.32 ; JUSB1.7 10.93,102.87 ; JUSB1.7 9.86,102.42 ; H11.1 105.35,134.56 ; H11.1 101.89,136 ; H11.1 103.33,132.54 ; H11.1 101.31,134.56 ; H11.1 103.33,136.58 ; H11.1 101.89,133.12 ; H11.1 104.77,133.12 ; H11.1 104.77,136 ; 2.03,94.4 JUSB1.14 ; JUSB1.14 3.15,94.4 ; JUSB1.14 0.91,94.97 ; JUSB1.14 0.91,94.4 ; JUSB1.14 3.15,94.97 ; 64.88,71.72 JCR1.22 ; JCR1.22 66.21,71.72 ; JCR1.22 65.54,69.58 ; JCR1.22 66.21,70.65 ; JCR1.22 64.88,69.58 ; JCR1.22 65.54,71.72 ; JCR1.22 64.88,70.65 ; JCR1.22 66.21,69.58 ; 8.81,98.75 JUSB1.4 ; JUSB1.4 9.26,99.82 ; JUSB1.4 8.81,99.99 ; JUSB1.4 8.36,98.92 ; JUSB1.4 8.36,99.82 ; JUSB1.4 9.43,99.37 ; JUSB1.4 9.26,98.92 ; JUSBC2.B12 6.22,28.95 ; JUSBC2.B12 5.8,28.53 ; JUSBC2.B12 5.49,29.26 ; JUSBC2.B12 5.8,29.37 ; JUSBC2.B12 6.11,28.64 ; JUSBC1.B1 5.8,38.37 ; JUSBC1.B1 6.22,37.95 ; JUSBC1.B1 5.49,37.64 ; JUSBC1.B1 6.11,38.26 ; H13.1 103.77,109.12 ; H13.1 104.35,110.56 ; H13.1 100.31,110.56 ; H13.1 103.77,112 ; H13.1 102.33,112.58 ; H13.1 100.89,112 ; H13.1 102.33,108.54 ; H13.1 100.89,109.12 ; SW2.5 1.65,141.57 ; SW2.5 2.17,140.02 ; SW2.5 1.18,141.57 ; SW2.5 1.65,140.02 ; H6.1 12.29,91.84 ; H6.1 12.29,89.66 ; H6.1 11.2,92.27 ; H6.1 10.11,91.84 ; H6.1 11.2,89.23 ; H6.1 9.68,90.75 ; H6.1 10.11,89.66 ; H6.1 12.72,90.75 ; 1.65,136.34 SW2.4 ; SW2.4 1.65,137.9 ; SW2.4 2.17,137.9 ; SW2.4 1.18,136.34 ; 9.02,95.9 JUSB1.12 ; JUSB1.12 9.99,97.04 ; JUSB1.12 9.02,97.04 ; JUSB1.12 9.99,96.47 ; JUSB1.12 9.99,95.9 ; 118.5,87.28 H4.1 ; H4.1 117.41,87.71 ; H4.1 119.59,89.89 ; H4.1 117.41,89.89 ; H4.1 118.5,90.32 ; H4.1 120.02,88.8 ; H4.1 119.59,87.71 ; H4.1 116.98,88.8 ; 79.28,71.72 JCR1.23 ; JCR1.23 79.94,71.72 ; JCR1.23 80.61,70.65 ; JCR1.23 80.61,71.72 ; JCR1.23 80.61,69.58 ; JCR1.23 79.28,69.58 ; JCR1.23 79.28,70.65 ; JCR1.23 79.94,69.58 ; JUSBC2.B1 6.11,23.66 ; JUSBC2.B1 5.8,23.77 ; JUSBC2.B1 5.49,23.04 ; JUSBC2.B1 6.22,23.35 ; 80.45,10.5 H12.1 ; H12.1 83.55,13.6 ; H12.1 80.45,13.6 ; H12.1 79.83,12.05 ; H12.1 82,9.88 ; H12.1 84.17,12.05 ; H12.1 82,14.22 ; H12.1 83.55,10.5
  VCC w0.203: JUSBC1.B12 6.22,43.55 ; JUSBC1.B12 5.49,43.86 ; JUSBC1.B12 5.8,43.97 ; JUSBC1.B12 5.8,43.13 ; JUSBC1.B12 6.11,43.24 ; 157.88,163.15 H2.1 ; H2.1 158.31,164.24 ; H2.1 160.92,163.15 ; H2.1 160.49,162.06 ; H2.1 159.4,164.67 ; H2.1 158.31,162.06 ; H2.1 160.49,164.24 ; H2.1 159.4,161.63 ; JUSB1.14 3.15,94.97 ; JUSB1.14 2.03,94.4 ; JUSB1.14 0.91,94.4 ; JUSB1.14 3.15,94.4 ; JUSB1.14 0.91,94.97 ; 5.49,37.64 JUSBC1.B1 ; JUSBC1.B1 5.8,38.37 ; JUSBC1.B1 6.11,38.26 ; JUSBC1.B1 6.22,37.95 ; 8.36,98.92 JUSB1.4 ; JUSB1.4 9.26,98.92 ; JUSB1.4 9.26,99.82 ; JUSB1.4 9.43,99.37 ; JUSB1.4 8.81,98.75 ; JUSB1.4 8.36,99.82 ; JUSB1.4 8.81,99.99 ; 0.91,111.34 JUSB1.13 ; JUSB1.13 3.15,111.34 ; JUSB1.13 0.91,110.77 ; JUSB1.13 2.03,111.34 ; JUSB1.13 3.15,110.77 ; 100.89,109.12 H13.1 ; H13.1 103.77,112 ; H13.1 100.89,112 ; H13.1 104.35,110.56 ; H13.1 102.33,108.54 ; H13.1 102.33,112.58 ; H13.1 100.31,110.56 ; H13.1 103.77,109.12 ; JUSB1.11 9.99,109.27 ; JUSB1.11 9.99,109.84 ; JUSB1.11 9.99,108.7 ; JUSB1.11 9.02,109.84 ; JUSBC2.B12 5.8,29.37 ; JUSBC2.B12 5.8,28.53 ; JUSBC2.B12 6.11,28.64 ; JUSBC2.B12 6.22,28.95 ; JUSBC2.B12 5.49,29.26 ; 1.65,154.12 SW1.5 ; SW1.5 1.18,155.67 ; SW1.5 1.65,155.67 ; SW1.5 2.17,154.12 ; 9.86,102.42 JUSB1.7 ; JUSB1.7 9.86,103.32 ; JUSB1.7 10.31,103.49 ; JUSB1.7 10.31,102.25 ; JUSB1.7 10.76,102.42 ; JUSB1.7 10.76,103.32 ; JUSB1.7 10.93,102.87 ; JUSB1.7 9.69,102.87 ; SW2.5 2.17,140.02 ; SW2.5 1.18,141.57 ; SW2.5 1.65,140.02 ; SW2.5 1.65,141.57 ; JUSBC2.B1 5.8,23.77 ; JUSBC2.B1 5.49,23.04 ; JUSBC2.B1 6.22,23.35 ; JUSBC2.B1 6.11,23.66 ; SW1.4 1.65,152 ; SW1.4 2.17,152 ; SW1.4 1.65,150.44 ; SW1.4 1.18,150.44 ; 1.65,136.34 SW2.4 ; SW2.4 1.18,136.34 ; SW2.4 1.65,137.9 ; SW2.4 2.17,137.9 ; JUSB1.12 9.99,95.9 ; JUSB1.12 9.99,96.47 ; JUSB1.12 9.99,97.04 ; JUSB1.12 9.02,97.04 ; JUSB1.12 9.02,95.9
  IN3 w0.254: 99.32,92.77 v17(100.1,91.99) v17(107.63,91.99) 108.42,91.99 110.69,94.27 v7(110.69,94.54) 111.95,95.8 v7(111.95,98.78) 112.17,99 114.74,99 115,98.74 v17(115,97.79) 115,94.09 v17(114.12,93.21) v17(110.37,89.47) 109.52,88.61 107.21,88.61 106.53,89.29 v17(104.39,89.29) v17(98.17,89.29) 94.36,89.29 94.18,89.47 v17(93.95,89.47) 93.86,89.57 v17(87.5,89.57) v17(81.99,89.57) 81.56,89.57 80.33,88.34 v17(76.97,88.34) v17(75.46,88.34) 73.78,88.34 v17(69.03,93.08) 65.95,96.17 v17(65.47,96.17) ; 99.32,92.77 98.52,91.96 95.19,91.96 v17(94.75,92.4) 93.86,93.3 v7(92.85,93.3) v7(92.05,93.3) 92.02,93.26 91.67,93.26 90.66,92.25 v17(89.47,92.25) v17(82.93,92.25) 80.37,92.25 v17(80.11,91.98) 78.87,90.74 v17(75.84,90.74) 74.96,90.74 v17(71.78,93.92) 71.15,94.55 v17(71.15,94.93) 71.15,95.24 v17(69.66,96.72) 68.69,97.69 v17(67.93,97.69) 65.36,100.26 v17(65.36,102.59) 65.36,103.32 63.5,105.17 v17(63.5,106.87) v17(63.5,109.86) v17(63.5,114.94) 63.5,115.7 62.98,116.21 v7(62.55,116.21) ; 99.32,92.77 100.01,93.45 100.01,95.63 v17(100.49,96.11) v17(103.06,98.68) v17(105.66,101.28) 106.98,102.6 v17(106.98,106.43) v17(106.98,113.42) v17(103.94,116.45) v17(98.8,121.6) 97.59,122.81 95.31,122.81 v17(95.09,122.59) 94.76,122.26 94.76,121.26 95.13,120.9 v7(95.13,120.37) ; 10.64,95.81 10.64,97.58 11.96,98.9 v17(12.34,98.9) 13.06,98.9 14.48,97.47 20.02,97.47 21.91,95.58 21.91,95.01 22.16,94.76 v17(22.66,94.76) ; v5(151.93,147.26) 151.76,147.09 151.76,143.45 150.62,142.31 v17(150.24,142.31) ; v17(24.26,100.9) 24.77,100.9 25.3,101.44 26.72,101.44 26.95,101.21 v7(26.95,100.77) v7(26.95,100.11) 26.95,98.86 26.73,98.64 26.38,98.64 26.07,98.34 26.07,97.37 26.45,96.99 v17(27.2,96.99) ; v17(17.53,100.9) 17.35,100.73 15.21,100.73 v17(11.72,104.22) ; v5(94.42,120.91) v4(93.98,120.46) ; 47.76,105.89 47.69,105.82 v17(46.93,105.82) 46.93,105.01 48.19,103.74 49.33,103.74 49.97,104.38 v17(49.97,104.66) 49.97,105.12 49.24,105.86 48.15,105.86 48.12,105.89 47.76,105.89 ; 46.26,75.27 v5(46.86,74.66) v17(48.67,72.86) 49.62,71.9 v17(55.42,71.9) 57.02,70.3 57.02,68.9 56.49,68.37 v17(55.75,68.37) 53.81,68.37 51.96,70.21 v7(51.05,70.21) 48.67,70.21 v17(45.5,73.38) 42.77,76.11 v17(40.13,76.11) 36.86,76.11 35.83,77.14 v17(32.13,77.14) v17(25.91,77.14) 23.25,77.14 22.86,77.54 v17(22.86,78.55) 23.11,78.81 v17(28.83,78.81) v17(35.88,78.81) 36.27,78.41 39.84,78.41 v17(40.76,79.32) 41.81,80.37 43.07,80.37 44.07,79.37 v17(44.07,78.17) 44.07,77.38 46.18,75.27 46.26,75.27
  GND3 w0.203: 2.03,94.4 JUSB1.14 ; JUSB1.14 0.91,94.4 ; JUSB1.14 0.91,94.97 ; JUSB1.14 3.15,94.4 ; JUSB1.14 3.15,94.97 ; JUSB1.12 9.99,95.9 ; JUSB1.12 9.99,97.04 ; JUSB1.12 9.99,96.47 ; JUSB1.12 9.02,95.9 ; JUSB1.12 9.02,97.04 ; 5.49,43.86 JUSBC1.B12 ; JUSBC1.B12 5.8,43.13 ; JUSBC1.B12 5.8,43.97 ; JUSBC1.B12 6.11,43.24 ; JUSBC1.B12 6.22,43.55 ; H2.1 160.49,162.06 ; H2.1 158.31,164.24 ; H2.1 160.92,163.15 ; H2.1 158.31,162.06 ; H2.1 157.88,163.15 ; H2.1 159.4,161.63 ; H2.1 159.4,164.67 ; H2.1 160.49,164.24 ; 79.28,71.72 JCR1.23 ; JCR1.23 79.94,71.72 ; JCR1.23 80.61,69.58 ; JCR1.23 79.28,69.58 ; JCR1.23 79.28,70.65 ; JCR1.23 80.61,70.65 ; JCR1.23 80.61,71.72 ; JCR1.23 79.94,69.58 ; SW2.5 2.17,140.02 ; SW2.5 1.18,141.57 ; SW2.5 1.65,140.02 ; SW2.5 1.65,141.57 ; H12.1 82,14.22 ; H12.1 84.17,12.05 ; H12.1 79.83,12.05 ; H12.1 82,9.88 ; H12.1 80.45,10.5 ; H12.1 83.55,10.5 ; H12.1 80.45,13.6 ; H12.1 83.55,13.6 ; JUSB1.11 9.02,109.84 ; JUSB1.11 9.99,109.84 ; JUSB1.11 9.99,109.27 ; JUSB1.11 9.99,108.7 ; 5.8,28.53 JUSBC2.B12 ; JUSBC2.B12 6.11,28.64 ; JUSBC2.B12 5.49,29.26 ; JUSBC2.B12 6.22,28.95 ; JUSBC2.B12 5.8,29.37 ; H4.1 120.02,88.8 ; H4.1 119.59,87.71 ; H4.1 118.5,87.28 ; H4.1 117.41,87.71 ; H4.1 118.5,90.32 ; H4.1 117.41,89.89 ; H4.1 119.59,89.89 ; H4.1 116.98,88.8 ; 43.77,133.37 H10.1 ; H10.1 47.23,134.81 ; H10.1 45.79,135.39 ; H10.1 47.81,133.37 ; H10.1 44.35,131.93 ; H10.1 45.79,131.35 ; H10.1 47.23,131.93 ; H10.1 44.35,134.81 ; 44.76,111.82 H5.1 ; H5.1 48.22,113.26 ; H5.1 46.2,111.24 ; H5.1 44.76,114.7 ; H5.1 44.18,113.26 ; H5.1 46.2,115.28 ; H5.1 47.64,111.82 ; H5.1 47.64,114.7 ; H1.1 110.5,161.67 ; H1.1 108.98,160.15 ; H1.1 112.02,160.15 ; H1.1 111.59,161.24 ; H1.1 110.5,158.63 ; H1.1 111.59,159.06 ; H1.1 109.41,159.06 ; H1.1 109.41,161.24 ; 159.9,108.28 H3.1 ; H3.1 159.9,111.32 ; H3.1 161.42,109.8 ; H3.1 158.81,110.89 ; H3.1 160.99,108.71 ; H3.1 158.81,108.71 ; H3.1 158.38,109.8 ; H3.1 160.99,110.89 ; 101.89,136 H11.1 ; H11.1 105.35,134.56 ; H11.1 104.77,133.12 ; H11.1 103.33,136.58 ; H11.1 104.77,136 ; H11.1 101.89,133.12 ; H11.1 103.33,132.54 ; H11.1 101.31,134.56 ; 10.11,91.84 H6.1 ; H6.1 11.2,92.27 ; H6.1 10.11,89.66 ; H6.1 9.68,90.75 ; H6.1 11.2,89.23 ; H6.1 12.29,91.84 ; H6.1 12.72,90.75 ; H6.1 12.29,89.66 ; JUSB1.13 2.03,111.34 ; JUSB1.13 0.91,111.34 ; JUSB1.13 3.15,110.77 ; JUSB1.13 0.91,110.77 ; JUSB1.13 3.15,111.34 ; 102.33,108.54 H13.1 ; H13.1 104.35,110.56 ; H13.1 102.33,112.58 ; H13.1 103.77,109.12 ; H13.1 100.31,110.56 ; H13.1 103.77,112 ; H13.1 100.89,112 ; H13.1 100.89,109.12 ; JUSB1.7 10.93,102.87 ; JUSB1.7 9.86,102.42 ; JUSB1.7 10.31,102.25 ; JUSB1.7 9.86,103.32 ; JUSB1.7 10.76,102.42 ; JUSB1.7 10.31,103.49 ; JUSB1.7 9.69,102.87 ; JUSB1.7 10.76,103.32 ; 1.65,154.12 SW1.5 ; SW1.5 1.18,155.67 ; SW1.5 1.65,155.67 ; SW1.5 2.17,154.12 ; JUSB1.4 9.43,99.37 ; JUSB1.4 9.26,98.92 ; JUSB1.4 8.36,98.92 ; JUSB1.4 9.26,99.82 ; JUSB1.4 8.81,99.99 ; JUSB1.4 8.81,98.75 ; JUSB1.4 8.36,99.82 ; 64.88,69.58 JCR1.22 ; JCR1.22 64.88,71.72 ; JCR1.22 66.21,69.58 ; JCR1.22 65.54,69.58 ; JCR1.22 64.88,70.65 ; JCR1.22 66.21,71.72 ; JCR1.22 65.54,71.72 ; JCR1.22 66.21,70.65 ; 1.65,150.44 SW1.4 ; SW1.4 1.65,152 ; SW1.4 1.18,150.44 ; SW1.4 2.17,152 ; JUSBC2.B1 5.8,23.77 ; JUSBC2.B1 6.11,23.66 ; JUSBC2.B1 5.49,23.04 ; JUSBC2.B1 6.22,23.35 ; SW2.4 1.65,137.9 ; SW2.4 2.17,137.9 ; SW2.4 1.18,136.34 ; SW2.4 1.65,136.34 ; JUSBC1.B1 6.11,38.26 ; JUSBC1.B1 5.8,38.37 ; JUSBC1.B1 5.49,37.64 ; JUSBC1.B1 6.22,37.95
  GND3 w0.254: v13(145.16,127.97) 145.03,127.97 v4(144.81,127.74) ; v7(92.05,93.3) 92.37,93.62 v13(92.46,93.62) 92.53,93.62 v7(92.85,93.3)
  IN4 w0.152: 104.24,89.68 104.09,89.52 95.53,89.52 95.35,89.7
  IN4 w0.254: 128.8,93.38 128.73,93.38 128.25,93.86 126.86,93.86 126.52,94.2 ; 41.32,81.09 v15(41.32,77.66) v15(41.32,72.84) v15(44.73,69.43) 46.02,68.14 v15(46.02,62.93) 46.02,59.63 46.43,59.23 v15(46.43,57.09) 46.43,52.64 v15(48.36,50.71) 51.3,47.77 v15(51.3,42.99) v15(51.3,31.82) 51.3,28.52 51.47,28.35 v15(51.47,26.35) 51.47,25.88 51.77,25.59 52.1,25.59 52.27,25.77 52.27,26.1 52,26.38 v15(52,26.86) v15(52,32.58) v15(52,37.02) v15(52,41.98) v15(52,47.94) 52,48.39 v15(47.5,52.88) 47.35,53.03 v15(47.35,60.69) v13(47.35,66.43) 47.35,69.05 v13(47.29,69.11) 47.29,69.88 v15(44.83,72.34) 44.8,72.34 43.01,74.13 v13(43.01,75.18) 43.01,76.29 43.01,76.38 43.01,76.39 43.01,78.78 42.93,78.86 v13(42.93,79.37) 42.93,79.52 43.28,79.87 43.28,80.17 43.01,80.44 43.01,82.21 v15(43.28,82.49) 42.96,82.81 42.96,84.3 41.3,85.96 v15(41.3,86.03) 40.22,87.11 40.22,88.51 v13(40.17,88.56) 40.22,88.6 40.22,89.14 40.37,89.29 v15(40.37,89.3) 40.43,89.35 40.43,89.48 40.7,89.75 v13(40.7,91.78) ; v15(31.93,94.68) 31.9,94.65 31.9,90.67 v15(31.83,90.59) 31.83,89.09 32.62,88.3 v15(32.62,86.81) 32.62,85.1 v15(34,83.72) 36.63,81.09 v15(36.63,79.19) v13(36.63,77.01) ; 133.31,93.93 133.31,92.61 132.88,92.18 ; v7(66.78,113.94) 68.82,111.9 v15(68.82,109.92) 68.82,107.52 v15(71.06,105.28) v15(72.95,103.39) 74.03,102.31 74.03,99.39 v13(75.84,97.58) 76.8,97.58 76.97,97.41 78.49,97.41 v7(78.63,97.27) 79.65,97.27 v13(80.64,96.28) 80.85,96.08 81.8,96.08 v13(82.24,95.63) ; v15(64.49,97.1) 64.48,97.09 64.48,97.06 64.49,97.05 v15(64.49,91.51) 64.49,90.42 66.34,88.56 v15(67.44,88.56) v15(72.63,88.56) 74.46,88.56 v15(75.97,90.06) 77.45,91.54 v15(79.12,91.54) v15(81.79,91.54) ; v15(64.49,97.1) 64.48,97.1 ; v15(64.49,97.1) 64.49,103.4 ; v15(99.95,114.87) 97.42,117.39 v15(95.12,117.39) ; v13(132.89,94.35) v13(130.51,94.35) ; v13(61.02,134.32) 62.43,132.91 ; 49.31,24.23 v15(49.31,26.3) 49.31,28.21 49.87,28.76 v15(49.87,32.83) v15(49.87,39.44) v15(49.87,48.1) v15(44.57,53.4) 44.33,53.64 v15(44.33,60.64) ; v13(94.06,92.97) 95.14,91.89 v15(95.89,91.89) 96.39,91.38 96.65,91.38 96.77,91.25 v15(102.12,91.25) v13(104.03,93.16) v15(105.16,94.29) v15(105.16,100.78) 105.16,105.35 v15(103.5,107) ; 51.05,137.61 51.13,137.68 52.54,137.68 52.8,137.41 53.28,137.41 54.73,135.96 v7(55.5,135.96) 56.45,135.96 56.79,136.3 v15(59.44,136.3) 62.6,136.3 v5(63.32,135.57) ; 130.94,93.38 132.14,92.19 132.87,92.19 ; v15(78.8,132.33) 78.55,132.08 73.53,132.08 v15(73.28,132.33) ; v15(32.99,70.36) 33.54,70.36 v15(35.03,71.84) 36.63,73.44 v13(36.63,77.01) ; v7(35.93,95.35) 36.3,94.99 v15(36.3,93.16) 36.3,90.03 v13(36.54,89.79) 36.7,89.63 36.7,88.23 v15(36.73,88.2) 36.73,86.66 38.1,85.28 38.53,85.28 v15(39.45,84.37) 39.53,84.37 41.32,82.58 v15(41.32,81.73) ; v13(36.63,77.01) 37.62,77.01 37.75,77.13 37.75,77.19 v15(38.81,78.25) 39.31,78.74 39.31,81.51 v13(38.25,82.57) 34.83,85.99 v15(34.83,87.06) v13(34.83,88.59) 34.45,88.96 34.45,90.14 v13(33.7,90.9) 33.7,93.64 33.88,93.82 v7(33.88,94.39) 33.82,94.45 v7(33.82,95.06) 33.82,95.41 34.37,95.96 ; v15(60.69,110.28) 60.96,110.56 61.63,110.56 v15(62.31,109.88) v15(62.31,106.57) 64.49,104.39 v15(64.49,103.43) ; v15(32.1,84.52) 32.1,87.87 v15(31.69,88.27) 31.69,88.45 31.28,88.86 31.28,90.86 31.37,90.95 v13(31.37,91.06) v15(31.37,92.01) v15(31.37,95.57) ; v15(37.91,124.08) 38.08,124.08 39.33,122.82 v13(39.33,122.65) 39.33,122.55 39.33,120.69 v13(39.4,120.62) v13(39.4,118.59) v13(39.4,116.55) 39.4,116.34 39.98,115.76 v13(39.98,112.87) v13(39.98,110.38) v13(39.98,108.37) 39.98,107.66 40.58,107.05 v15(40.58,103.84) 40.88,103.54 40.88,102.08 41.6,101.37 41.6,100.58 v15(41.66,100.52) 42.32,99.86 v15(42.32,95.75) 42.32,95.57 42.04,95.29 v13(42.04,95.04) 42.14,94.93 42.14,90.96 v13(42.16,90.94) 42.16,89.83 v15(42.29,89.7) 42.14,89.55 42.14,87.8 45.11,84.83 v15(45.11,84.33) 45.11,81.45 44.76,81.1 44.76,79.56 v13(45.21,79.11) 45.21,78.86 46.18,77.9 46.18,73.84 v15(47.02,72.99) 49.05,70.97 v15(49.05,65.85) v15(49.05,59.12) 49.05,53.45 v15(49.5,52.99) 53.49,49 v15(53.49,48.71) 53.49,42.24 53.54,42.2 ; v13(62.49,20.61) 62.49,18.14 62.85,17.78 63.75,17.78 v13(64.14,18.16) 64.49,18.52 v15(64.49,20.01) 63.38,21.12 63.38,22.54 v15(61.41,24.52) 59.19,26.74 56.01,26.74 55.93,26.81 v15(55.08,26.81) 53.54,28.34 v15(53.54,33.34) 53.54,40.57 ; v15(78.32,135.13) 76.81,133.62 v15(72.26,133.62)
  IN4 w0.356: v7(26.48,149.35) 26.54,149.42 v1(26.54,151.73)
  BOTTOM w0.203: v13(21.12,137.68) U14.11 ; UZ4.11 v7(73.44,24.64) ; v13(31.85,135.98) U13.11 ; U21.11 v13(49.72,87.44)
  BOTTOM w0.254: v13(96.46,100.77) 96.53,100.77 v7(96.86,100.43) ; v7(35.93,95.35) 36.25,95.04 U4246.32 ; v7(78.64,101.15) 78.73,101.15 v13(79.04,100.83) ; CA44.2 68.33,14.38 69.19,15.24 70.87,15.24 70.87,13.87 v13(70.56,13.57) 70.56,12.33 69.9,11.67 v5(68.07,11.67) ; C130.2 37.6,88.72 C128.2 ; v7(152.69,117.02) 152.69,117.35 153,117.65 JXDP1.62 ; R451.2 36.32,89.57 v13(36.54,89.79) ; CA47.2 27.14,152.81 v7(27.56,152.81) ; v13(29.08,111.2) 29.08,111.2 UE3.C4 ; Q25.4 27.38,128.49 v13(27.58,128.28) ; v13(82.24,94.98) 82.17,94.98 v7(81.85,94.66) 81.53,94.98 v13(81.44,94.98) 81.37,94.98 v7(81.05,94.66) 80.73,94.98 v13(80.64,94.98) ; v13(92.46,94.27) 92.53,94.27 v7(92.86,94.6) 93.18,94.92 v13(93.26,94.92) 92.92,95.25 v7(92.86,95.25) 93.18,95.57 v13(93.26,95.57) ; v13(92.46,100.77) 92.54,100.77 v7(92.86,100.45) 93.19,100.12 v13(93.26,100.12) 92.94,99.8 v7(92.86,99.8) 93.19,99.47 v13(93.26,99.47) ; v13(151.55,144.43) U12.A2 ; v13(94.06,95.57) 94.15,95.57 v7(94.46,95.25) ; RE16.2 63.92,103 v13(63.65,102.73) ; v13(97.26,96.22) 97.32,96.22 v7(97.65,96.55) 97.97,96.87 v13(98.06,96.87) ; v13(79.04,94.33) 79.28,94.33 v7(79.57,94.62) ; CC41.2 65.02,127.3 v7(64.99,127.26) ; v13(147.79,127.19) 148.06,126.93 RC189.1 ; v7(94.46,95.25) 94.52,95.25 v13(94.86,94.92) 94.78,94.92 v7(94.46,94.6) 94.37,94.6 v13(94.06,94.92) 94.13,94.92 v7(94.46,95.25) ; v7(94.46,95.25) 94.78,95.57 v13(94.86,95.57) ; CA46.2 28.33,154 v7(27.88,154.46) ; v13(45.58,87.59) 45.78,87.8 C126.2 ; CC70.2 63.8,116.91 v7(64.45,116.91) ; v7(92.85,93.3) 92.53,93.62 v13(92.46,93.62) 92.37,93.62 v7(92.05,93.3) 91.72,92.97 v13(91.66,92.97) ; CA48.2 v7(24.75,153.94) ; UT1.G8 v13(36.69,65.84) ; v13(79.04,96.28) 79.14,96.28 v7(79.5,96.65) ; CT25.2 v13(52.7,20.92) ; CE15.2 32.63,121.85 32.44,122.04 v13(32.36,122.04) ; D89.1 v13(8.32,31.28) ; v13(42.16,90.94) 42.26,90.94 42.42,91.1 42.42,91.38 42.26,91.54 U4246.16 ; CT24.2 62.1,21.01 v13(62.49,20.61) ; D78.1 v13(18.16,42.38) ; v13(16.59,43.25) 16.59,43.17 16.76,42.99 D76.1 ; v13(65.15,118.3) 64.92,118.53 CC64.2 ; Q10.3 v13(63.66,102.11) ; v13(40.39,57.68) 40.07,58 RT110.2 ; UT1.G7 v13(35.69,65.34)
  BOTTOM w0.356: DA6.2 7.17,162.95 v7(7.16,162.96) ; v13(86.11,92.08) 86.53,91.66 CD107.2 ; UC2.3 54.47,139.02 v13(54.36,139.13) ; R490.2 v13(24.74,76.54) ; D64.1 42.6,75.81 42.34,75.55 v13(41.91,75.55) ; R488.1 24.74,74.4 v13(24.61,74.27) ; v13(28.96,141.34) 28.61,141.34 CA35.2 ; RC397.1 v13(64.01,111.19) ; RT2.1 30.92,70.44 v13(30.58,70.78) ; v13(146.86,146.37) 147.15,146.08 C65.2 ; CA13.2 v1(26.54,151.73)
  BOTTOM w0.381: v7(63.75,119.8) 63.68,119.86 CC57.2 63.23,120.52 63.17,120.46 CC58.2 ; U44.3 143.11,130.16 v13(142.88,129.92) ; v7(62.43,126.45) 61.86,126.45 CC45.2
  BOTTOM w0.406: CC38.2 63.63,129.54 v13(64.01,129.92)
  BOTTOM w0.508: CV18.2 CV17.2 24.51,51.44 v7(24.19,51.75) ; CA37.2 22.86,141.16 22.8,141.1 v7(22.8,140.46) ; v7(60.07,79.19) 60.41,79.53 JSIM1.7 ; v7(121.79,117.79) 121.98,117.98 PR505.2 ; CZ4.2 v13(58.47,139) ; CR9.1 v7(66.6,38.8) ; v13(64.58,130.55) 64.51,130.62 CC32.2 ; v7(140.84,130.37) PR325.1 ; C112.2 154.24,101.35 v7(154.24,101.08) ; C1040.2 v13(30.63,92.88) ; v13(50.49,126.18) 50.2,125.89 CC47.2 ; PC333.1 131.32,132.84 v7(131.32,133.06) ; C139.2 C140.2 62.37,74.41 v7(62.1,74.68) ; v7(145.16,116.71) PC323.2 ; v7(157.44,141.24) Y1.4 ; CC48.2 50.85,124.15 v13(51.05,124.35) ; 160.2,97.97 v7(158.54,99.63) ; JSIM1.10 v7(61.5,66.71) ; JSIM1.9 51.83,79.42 v7(51.89,79.36) ; v7(102.87,119.45) PC610.2 ; C1131.2 29.12,100.14 29.13,100.15 v13(30.01,100.15) ; RC160.2 62.81,116.35 62.68,116.21 v7(62.55,116.21) ; PC931.2 57.1,160.24 57.1,160.24 v13(56.95,160.24) ; C129.2 v13(47.8,87.82) ; CT29.2 v7(60.2,12.32) ; RA19.1 v13(24.42,141.04) ; JRTC1.2 v7(154.79,97.58) ; v7(63.09,123.91) 63.02,123.84 CC50.2 ; C94.2 18.61,135.65 v13(18.32,135.36) ; RA22.1 v7(36.26,153.1) ; v7(70.74,38.99) 71.2,38.53 CR5.2 CR6.1 ; v13(44.83,138.94) 44.26,138.94 43.8,138.48 RC96.2 ; v7(51.05,70.21) 51.11,70.16 JSIM1.4 ; v7(128.84,142.5) 128.91,142.56 PC701.2 ; RC142.1 v7(151,121.22) ; CT30.2 v7(57.09,11.6) ; 155.28,93.06 v7(153.73,94.62) ; C210.2 v13(124.59,161.15) ; v7(128.03,129.44) 128.07,129.48 PC332.2 ; RR1.1 v7(65.52,37.78) ; JCR1.11 v7(64.41,78.85) ; C144.2 42.99,74.89 43.01,74.91 v13(43.01,75.18) ; JAPS1.19 v7(27.43,163.9) ; v7(140.79,126.76) PC349.2 ; CR10.2 v13(75.51,38.86)
  vias: v3(20.38,114.62) v3(81.72,132.21) v3(82.84,132.81) v3(92,131.05) v3(97.41,131.08) v4(9.75,29.86) v4(10.83,116.49) v4(12.32,18.53) v4(27.55,26.1) v4(27.56,23.31) v4(30.12,25.48) v4(30.73,32.96) v4(32.49,24.32) v4(32.77,46.05) v4(33.05,162.07) v4(33.06,160.19) v4(33.96,161.98) v4(34.56,160.61) v4(34.58,159.39) v4(34.58,158.52) v4(34.96,161.82) v4(35.53,162.37) v4(35.99,43.35) v4(36.88,37.11) v4(40.3,164.73) v4(41.64,34.42) v4(43.17,164.72) v4(43.42,38.24) v4(44.44,164.72) v4(44.45,163.48) v4(45.28,163.46) v4(45.71,164.72) v4(46.18,163.45) v4(46.35,29.91) v4(46.98,164.72) v4(47.14,163.44) v4(48.25,164.72) v4(49.52,164.72) v4(49.91,163.54) v4(50.79,164.72) v4(50.99,159.2) v4(51.36,158.48) v4(51.6,160.02) v4(51.99,18.51) v4(52.06,164.72) v4(52.07,158.38) v4(52.1,17.24) v4(52.29,160.03) v4(52.83,158.47) v4(52.79,116.91) v4(52.88,159.98) v4(53.33,164.72) v4(54.24,155.83) v4(55.22,158.45) v4(55.17,157.27) v4(55.44,164.73) v4(55.44,130.56) v4(55.75,159.04) v4(56.31,125.35) v4(56.5,159.44) v4(56.71,164.73) v4(57.24,159.21) v4(57.38,158.33) v4(57.39,157.63) v4(57.38,156.97) v4(57.78,150.56) v4(57.98,164.73) v4(58.36,150.56) v4(58.55,149.54) v4(58.93,150.56) v4(59.03,149.32) v4(59.25,164.73) v4(59.44,150.56) v4(59.59,149.47) v4(59.69,155.96) v4(59.75,152.72) v4(60.01,150.56) v4(60.52,164.73) v4(60.58,150.56) v4(61.34,150.56) v4(61.59,149.54) v4(61.72,155.96) v4(61.66,152.72) v4(61.66,148.66) v4(61.79,164.73) v4(62.55,122.3) v4(63.06,164.73) v4(64.33,164.73) v4(65.6,164.73) v4(66.36,151.64) v4(66.36,150.62) v4(66.48,149.42) v4(66.87,164.73) v4(66.93,151.65) v4(66.93,150.64) v4(67.12,149.42) v4(67.69,149.42) v4(68.14,164.73) v4(68.14,151.64) v4(68.14,150.62) v4(68.26,149.42) v4(68.83,149.42) v4(69.14,162.17) v4(69.24,119.88) v4(69.34,151.64) v4(69.34,150.62) v4(69.34,149.42) v4(69.41,164.73) v4(69.7,119.9) v4(69.77,131.21) v4(69.91,151.64) v4(69.91,150.62) v4(69.91,149.42) v4(70.03,162.19) v4(69.95,160.09) v4(70.33,126.05) v4(70.41,160.09) v4(70.36,127.37) v4(70.36,124.88) v4(70.36,123.71) v4(70.36,122.37) v4(70.61,149.42) v4(70.68,164.73) v4(70.74,29.76) v4(70.82,131.08) v4(71.35,162.19) v4(71.44,32.39) v4(71.95,164.73) v4(72.24,162.22) v4(73.22,164.73) v4(74.49,164.73) v4(74.5,131.21) v4(74.63,127.34) v4(74.6,124.93) v4(74.65,126.18) v4(74.7,123.38) v4(74.68,122.11) v4(75.76,164.73) v4(76.02,126.18) v4(76.05,124.91) v4(76.05,123.36) v4(76.05,122.06) v4(76.07,127.37) v4(76.28,131.18) v4(76.39,37.91) v4(77.03,164.73) v4(77.06,131.2) v4(77.98,133.92) v4(78.3,164.73) v4(78.77,133.84) v4(79.2,122.34) v4(79.48,124.68) v4(79.48,123.71) v4(79.57,164.73) v4(79.95,127.27) v4(80.26,131.13) v4(80.84,164.73) v4(82.11,164.73) v4(83.38,164.73) v4(83.38,151.64) v4(83.44,150.43) v4(83.38,149.35) v4(83.72,124.88) v4(83.72,124.41) v4(83.73,123.91) v4(83.72,123.28) v4(83.77,130.32) v4(84.01,149.35) v4(84.48,132.07) v4(84.65,164.73) v4(84.58,151.64) v4(84.65,150.43) v4(84.58,149.35) v4(85.15,151.64) v4(85.22,150.43) v4(85.15,149.35) v4(85.52,124.83) v4(85.5,124.35) v4(85.5,123.86) v4(85.72,149.35) v4(85.8,122.65) v4(85.92,164.73) v4(85.85,125.74) v4(86.23,151.64) v4(86.23,149.35) v4(86.33,131.81) v4(86.36,150.43) v4(86.72,160.19) v4(86.8,151.64) v4(86.8,149.35) v4(86.87,150.43) v4(87.07,161.66) v4(87.19,164.73) v4(87.5,149.35) v4(87.66,161.63) v4(87.66,160.9) v4(87.9,128.21) v4(87.9,127.78) v4(87.91,127.27) v4(88.39,160.9) v4(88.46,164.73) v4(89.13,160.87) v4(89.73,164.73) v4(89.89,124.62) v4(90.35,125.59) v4(91,164.73) v4(90.96,125.95) v4(91.21,124.58) v4(92.27,164.73) v4(92.33,124.58) v4(92.51,125.92) v4(92.84,124.58) v4(92.94,125.92) v4(93.54,164.73) v4(94.81,164.73) v4(94.75,125.88) v4(95.05,125.57) v4(95.44,125.78) v4(96.08,164.73) v4(97.35,164.73) v4(98.62,164.73) v4(99.24,164.63) v4(99.31,162.47) v4(99.36,155.03) v4(99.54,160.06) v4(99.54,158.89) v4(99.49,156.61) v4(99.47,156.07) v4(99.76,152.08) v4(99.76,151) v4(99.76,150.05) v4(99.76,148.97) v4(99.89,164.73) v4(100.25,161.53) v4(100.39,152.08) v4(100.74,156.5) v4(100.76,163.56) v4(100.86,155.03) v4(100.97,152.08) v4(100.97,151) v4(100.97,150.05) v4(100.97,148.97) v4(101.16,164.73) v4(101.5,160.09) v4(101.54,152.08) v4(101.54,151) v4(101.54,150.05) v4(101.54,148.97) v4(102.03,155.77) v4(102.13,161.63) v4(102.11,152.08) v4(102.16,158.26) v4(102.43,164.73) v4(102.62,152.08) v4(102.74,151) v4(102.74,150.05) v4(102.79,148.97) v4(103.19,152.08) v4(103.31,151) v4(103.31,150.05) v4(103.37,148.97) v4(105.87,149.95) v4(106.06,162.17) v4(106.06,161.13) v4(106.06,159.75) v4(106.06,155.54) v4(106.27,163.44) v4(107.24,152.47) v4(107.42,162.14) v4(107.39,155.55) v4(107.37,150.51) v4(107.47,157.47) v4(107.54,154.32) v4(108.56,155.56) v4(108.86,154.55) v4(108.92,152.24) v4(109.44,168.73) v4(109.79,155.56) v4(110.25,165.47) v4(110.39,156.02) v4(110.52,164.53) v4(110.87,155.59) v4(111.68,163.69) v4(111.71,156.76) v4(111.76,155.31) v4(112.17,165.63) v4(112.57,166.82) v4(113.33,163.08) v4(113.44,158.59) v4(113.59,161.86) v4(113.72,165.62) v4(113.84,166.66) v4(115.01,160.06) v4(115.19,153.68) v4(115.29,164.4) v4(115.32,157.49) v4(115.47,158.74) v4(116,161.46) v4(116.51,153.46) v4(116.94,155.54) v4(117.45,163.13) v4(119.41,167.62) v4(120.47,166.68) v4(121.13,165.97) v4(123.94,165.89) v4(124.55,166.55) v4(124.88,167.12) v4(125.08,165.51) v4(126.8,166.03) v4(128.26,167.82) v4(131.83,93.04) v4(133.41,93.09) v4(156.31,135.45) v5(20.43,45.96) v5(28.63,67.86) v5(35.83,70.73) v5(38.57,70.69) v5(41.91,77.33) v5(49.66,129.63) v5(50.88,130.54) v5(55.19,132.53) v5(61.54,17.21) v5(61.54,16.19) v5(68.12,18.35) v5(144.17,92.65) v5(150.08,149.67) v5(150.08,147.26) v5(150.24,146.45) v5(151.93,149.67) v6(46.35,26.43) v6(64.91,86.22) v6(66.18,86.25) v6(66.24,81.52) v6(67.72,80.48) v6(67.9,79.15) v7(0.52,156.29) v7(0.51,149.52) v7(0.51,148.25) v7(0.51,146.98) v7(0.51,145.71) v7(0.51,144.44) v7(0.51,143.17) v7(0.51,141.9) v7(0.51,130.24) v7(0.51,128.97) v7(0.51,127.7) v7(0.51,126.43) v7(0.51,125.16) v7(0.51,123.89) v7(0.51,122.62) v7(0.51,121.35) v7(0.51,120.08) v7(0.51,118.81) v7(0.51,113.72) v7(0.51,112.45) v7(0.51,111.18) v7(0.5,94.59) v7(0.5,93.32) v7(0.51,92.09) v7(0.7,174.82) v7(0.81,161.72) v7(0.84,114.94) v7(0.88,155.68) v7(0.88,150.45) v7(0.85,136.32) v7(1.09,135.71) v7(1.31,47.24) v7(1.31,19.59) v7(1.31,18.32) v7(1.31,17.05) v7(1.46,176.21) v7(1.61,91.46) v7(1.58,15.81) v7(1.79,156.29) v7(1.77,130.28) v7(1.79,49.61) v7(1.79,48.49) v7(2.08,161.72) v7(2.18,50.64) v7(2.31,93.37) v7(2.36,135.71) v7(2.73,177.36) v7(2.85,15.76) v7(2.88,91.46) v7(3.04,130.28) v7(3.05,112.84) v7(3.06,156.29) v7(3.3,49.3) v7(3.3,17.6) v7(3.35,161.72) v7(3.39,50.91) v7(3.56,149.75) v7(3.63,135.68) v7(3.89,110.43) v7(4.01,95.31) v7(4.13,177.87) v7(4.11,122.95) v7(4.23,156.82) v7(4.23,130.82) v7(4.15,91.46) v7(4.34,160.66) v7(4.34,159.39) v7(4.34,158.12) v7(4.34,134.63) v7(4.34,133.36) v7(4.34,132.09) v7(4.6,47.05) v7(4.6,19.85) v7(4.85,93.37) v7(5.04,128.44) v7(5.16,110.43) v7(5.28,95.31) v7(5.35,125.42) v7(5.42,91.46) v7(5.52,177.83) v7(5.53,177) v7(5.64,122.98) v7(5.68,176.02) v7(6.42,175.47) v7(6.43,110.43) v7(6.55,95.31) v7(6.69,91.46) v7(6.78,34.71) v7(7.2,47.05) v7(7.21,35.09) v7(7.21,34.3) v7(7.21,33.72) v7(7.2,19.85) v7(7.28,175.11) v7(7.67,110.38) v7(7.75,91.44) v7(7.77,34.93) v7(7.77,34.34) v7(8.06,95.57) v7(8.05,94.18) v7(8.18,175.47) v7(8.41,15.93) v7(8.5,49.3) v7(8.5,18.94) v7(8.84,176.05) v7(9.07,177.88) v7(9.07,177) v7(9.07,51.14) v7(9.43,90.75) v7(9.42,42.95) v7(9.53,135.07) v7(9.59,91.61) v7(9.69,89.84) v7(9.7,23.08) v7(9.67,15.76) v7(9.8,162.96) v7(9.79,18.68) v7(9.91,153.35) v7(9.91,16.61) v7(10.03,156.28) v7(10.22,95.29) v7(10.16,28.79) v7(10.32,92.28) v7(10.32,89.22) v7(10.34,51.14) v7(10.34,17.64) v7(10.55,162.94) v7(10.94,15.76) v7(10.95,177.99) v7(11.05,151.58) v7(11.19,92.69) v7(11.2,88.85) v7(11.43,135.32) v7(11.61,51.14) v7(11.94,155.06) v7(12.08,92.28) v7(12.08,89.22) v7(12.09,41.16) v7(12.09,39.33) v7(12.12,37.58) v7(12.1,30.43) v7(12.1,28.7) v7(12.14,27.57) v7(12.09,25.82) v7(12.09,24.75) v7(12.09,23) v7(12.22,177.99) v7(12.19,36.51) v7(12.19,34.74) v7(12.21,15.76) v7(12.32,45.79) v7(12.34,43.88) v7(12.75,91.7) v7(12.75,89.85) v7(12.88,51.14) v7(12.9,19.95) v7(12.95,139.77) v7(12.97,90.75) v7(13.08,146.05) v7(13.06,88.8) v7(13.15,162.94) v7(13.34,154.12) v7(13.49,177.99) v7(13.48,15.76) v7(13.84,149.04) v7(13.89,162.94) v7(14.16,51.16) v7(14.37,88.6) v7(14.75,15.76) v7(14.76,177.99) v7(15.16,87.61) v7(15.21,86.35) v7(15.21,85.08) v7(15.21,83.81) v7(15.21,82.54) v7(15.21,81.27) v7(15.21,80) v7(15.21,78.73) v7(15.21,77.46) v7(15.21,76.19) v7(15.21,74.92) v7(15.21,73.65) v7(15.21,72.38) v7(15.21,71.11) v7(15.21,69.84) v7(15.21,68.57) v7(15.21,67.3) v7(15.21,66.03) v7(15.21,64.76) v7(15.21,63.49) v7(15.21,62.22) v7(15.21,60.95) v7(15.21,59.68) v7(15.21,58.41) v7(15.21,57.14) v7(15.21,55.87) v7(15.21,54.6) v7(15.21,53.33) v7(15.19,52.07) v7(15.82,22.82) v7(15.9,28.67) v7(16.03,177.99) v7(15.95,26.96) v7(16.02,15.76) v7(16.37,144.12) v7(16.38,142.18) v7(16.42,24.68) v7(17.3,177.99) v7(17.29,15.76) v7(17.4,148.78) v7(17.53,150.18) v7(17.56,144.05) v7(17.68,176.48) v7(17.81,24.12) v7(17.86,23.05) v7(18.21,43.75) v7(18.57,177.99) v7(18.56,15.76) v7(19.84,177.99) v7(19.83,15.76) v7(19.93,173) v7(20.13,169.15) v7(20.23,170.41) v7(20.67,168) v7(20.93,171.47) v7(21.11,177.99) v7(21.1,15.76) v7(21.67,167.27) v7(22,172.15) v7(22.15,175.96) v7(22.09,174.69) v7(22.09,173.42) v7(22.38,177.99) v7(22.37,15.76) v7(22.54,149.35) v7(22.54,148.04) v7(22.54,146.73) v7(22.54,145.42) v7(22.81,56.21) v7(23,177.06) v7(22.96,167.09) v7(23.5,65.34) v7(23.64,15.76) v7(23.86,149.35) v7(23.86,148.04) v7(23.86,146.73) v7(23.86,145.42) v7(24.23,167.09) v7(24.91,15.76) v7(25.17,149.35) v7(25.17,148.04) v7(25.17,146.73) v7(25.17,145.42) v7(25.5,167.09) v7(26.18,15.76) v7(26.48,146.73) v7(26.48,145.42) v7(26.77,167.09) v7(26.8,157.8) v7(27.01,51.71) v7(27.24,58.69) v7(27.45,15.76) v7(27.56,57.06) v7(28.04,167.09) v7(28.07,159.07) v7(28.07,157.8) v7(28.72,15.76) v7(28.93,165.97) v7(29.31,167.09) v7(29.46,159.07) v7(29.99,15.76) v7(30.24,165.27) v7(30.58,167.09) v7(30.73,157.55) v7(31.26,15.76) v7(31.73,54.59) v7(31.85,167.09) v7(32.53,15.76) v7(32.68,166.26) v7(32.89,167.32) v7(33.21,165.13) v7(33.22,54.59) v7(33.8,15.76) v7(33.95,166.26) v7(34.16,167.32) v7(34.23,92.9) v7(34.48,165.13) v7(35.07,15.76) v7(35.22,166.26) v7(35.43,167.32) v7(35.75,165.13) v7(36.34,15.76) v7(37.61,15.76) v7(38.88,15.76) v7(40.03,33.82) v7(40.12,35.21) v7(40.15,15.76) v7(40.97,37.12) v7(41.42,15.76) v7(42.69,15.76) v7(43.95,15.59) v7(44.35,37.33) v7(44.45,41.95) v7(44.48,38.77) v7(44.73,14.59) v7(44.77,13.32) v7(44.77,12.05) v7(44.77,10.78) v7(44.77,9.51) v7(44.77,8.24) v7(44.77,6.97) v7(44.86,5.71) v7(46.12,5.51) v7(47.39,5.51) v7(47.69,152.47) v7(47.69,151.83) v7(47.69,151.2) v7(48.26,152.47) v7(48.26,151.83) v7(48.26,151.2) v7(48.66,5.51) v7(48.83,152.47) v7(48.83,151.83) v7(48.83,151.2) v7(48.91,144.72) v7(49.15,162.63) v7(49.15,162.05) v7(49.15,161.36) v7(49.15,160.78) v7(49.53,145.34) v7(49.93,5.51) v7(50.15,144.72) v7(51.2,5.51) v7(52.47,5.51) v7(52.58,12.26) v7(53.74,5.51) v7(55.01,5.51) v7(55.3,12.08) v7(56.28,5.51) v7(57.18,149.39) v7(57.55,5.51) v7(57.99,149.24) v7(58.82,5.51) v7(60.15,149.47) v7(60.09,5.51) v7(60.9,124.27) v7(60.96,149.39) v7(61.07,127.3) v7(61.36,5.51) v7(62.63,5.51) v7(63.04,72.72) v7(63.06,124.8) v7(63.75,126.45) v7(63.72,124.77) v7(63.71,122.27) v7(63.9,5.51) v7(64.38,126.42) v7(64.38,123.91) v7(65.17,5.51) v7(65.66,122.3) v7(66.29,119.76) v7(66.37,127.19) v7(66.44,5.51) v7(66.48,122.3) v7(67.51,151.65) v7(67.54,150.61) v7(67.84,34.33) v7(67.84,32.09) v7(67.77,5.51) v7(68.73,151.68) v7(68.76,150.59) v7(68.96,33.21) v7(68.98,5.51) v7(70.08,34.33) v7(70.08,32.09) v7(70.25,5.51) v7(70.51,150.61) v7(70.56,151.63) v7(71.52,5.51) v7(71.77,83.45) v7(72.39,68.52) v7(72.64,117.6) v7(72.84,81.57) v7(72.84,79.44) v7(72.79,5.51) v7(73.44,22.85) v7(73.45,98.27) v7(73.91,81.57) v7(73.91,79.44) v7(74.04,98.29) v7(74.06,5.51) v7(74.3,68.45) v7(74.42,115) v7(74.93,68.45) v7(74.98,81.57) v7(74.98,79.44) v7(75.33,5.51) v7(75.37,117.6) v7(75.44,116.97) v7(76.33,117.6) v7(76.26,116.97) v7(76.37,39.29) v7(76.6,5.51) v7(76.9,33.85) v7(77.22,115.64) v7(77.34,39.31) v7(77.84,5.25) v7(78.5,4.16) v7(78.51,2.89) v7(78.51,1.62) v7(79.13,39.12) v7(79.11,0.51) v7(79.38,62.55) v7(79.54,99.62) v7(79.57,48.06) v7(79.59,12.94) v7(79.68,11.34) v7(79.76,92.84) v7(79.95,118.24) v7(79.95,64.64) v7(80.07,10.29) v7(80.38,14.1) v7(80.38,0.51) v7(81.05,97.89) v7(81.04,97.26) v7(80.99,9.73) v7(81.65,0.51) v7(81.93,14.71) v7(82.02,9.45) v7(82.49,84.61) v7(82.49,83.34) v7(82.5,82.07) v7(82.89,85.82) v7(82.92,0.51) v7(83.12,80.96) v7(83.06,9.7) v7(83.16,14.26) v7(83.49,69.81) v7(83.49,68.54) v7(83.49,67.27) v7(83.49,66) v7(83.49,64.73) v7(83.49,63.46) v7(83.49,62.19) v7(83.49,60.92) v7(83.49,59.65) v7(83.49,58.38) v7(83.49,57.11) v7(83.49,55.84) v7(83.49,54.57) v7(83.49,53.3) v7(83.49,52.03) v7(83.51,50.76) v7(83.63,116.21) v7(83.97,151.6) v7(84.05,150.51) v7(84.02,80.07) v7(84,10.15) v7(84.06,86.31) v7(84.05,70.95) v7(84.23,49.72) v7(84.19,0.51) v7(84.29,13.1) v7(84.4,10.99) v7(84.52,116.27) v7(84.91,79.17) v7(85.17,71.55) v7(85.33,86.31) v7(85.4,111.82) v7(85.37,49.15) v7(85.47,116.91) v7(85.47,116.27) v7(85.46,0.51) v7(85.7,151.6) v7(85.78,150.46) v7(85.81,78.27) v7(86.11,114.75) v7(86.16,94.83) v7(86.3,72.13) v7(86.45,48.48) v7(86.49,77.2) v7(86.49,75.93) v7(86.49,74.66) v7(86.49,73.39) v7(86.49,47.21) v7(86.49,45.94) v7(86.49,44.67) v7(86.49,43.4) v7(86.49,42.13) v7(86.49,40.86) v7(86.49,39.59) v7(86.49,38.32) v7(86.49,37.05) v7(86.49,35.78) v7(86.49,34.51) v7(86.49,33.24) v7(86.49,31.97) v7(86.49,30.7) v7(86.49,29.43) v7(86.49,28.16) v7(86.49,26.89) v7(86.49,25.62) v7(86.49,24.35) v7(86.49,23.08) v7(86.49,21.89) v7(86.49,20.54) v7(86.49,19.27) v7(86.49,18) v7(86.49,16.73) v7(86.49,15.46) v7(86.49,14.19) v7(86.49,10.14) v7(86.49,8.87) v7(86.49,7.6) v7(86.49,6.33) v7(86.49,5.06) v7(86.49,3.79) v7(86.49,2.52) v7(86.49,1.25) v7(86.62,109.88) v7(86.6,86.31) v7(87.53,151.63) v7(87.63,150.43) v7(87.87,86.31) v7(88.99,118.91) v7(89.1,118.21) v7(89.14,86.31) v7(90.41,86.31) v7(90.91,114.87) v7(91.68,86.3) v7(92.92,86.03) v7(94.12,85.63) v7(95.35,85.31) v7(96.62,85.31) v7(96.98,120.14) v7(97.03,115.51) v7(97.89,85.31) v7(99.16,85.31) v7(100.38,150.99) v7(100.36,150) v7(100.36,148.96) v7(100.43,85.31) v7(101.7,85.31) v7(102.11,151.02) v7(102.16,150.03) v7(102.18,148.99) v7(102.97,85.31) v7(104.24,85.31) v7(105.42,123.41) v7(105.42,122.65) v7(105.42,121.88) v7(105.51,85.31) v7(105.93,123.79) v7(105.93,123.03) v7(105.93,122.26) v7(105.93,121.5) v7(106.44,123.41) v7(106.44,122.65) v7(106.44,121.88) v7(106.78,85.31) v7(107.57,100.97) v7(107.62,96.39) v7(108.11,177.13) v7(108.08,107.76) v7(108.08,107.19) v7(108.08,106.62) v7(108.05,85.31) v7(108.24,97.01) v7(108.24,95.76) v7(108.46,100.97) v7(108.73,160.15) v7(108.88,161.02) v7(108.93,159.22) v7(108.87,96.39) v7(109.04,177.99) v7(109.32,85.31) v7(109.62,161.68) v7(109.62,158.62) v7(109.6,100.14) v7(110.31,177.99) v7(110.5,162.05) v7(110.53,158.26) v7(110.59,85.31) v7(110.72,91.91) v7(111.43,173.04) v7(111.38,161.68) v7(111.38,158.62) v7(111.58,177.99) v7(111.86,85.31) v7(112.06,161.04) v7(112.06,159.3) v7(112.27,160.15) v7(112.85,177.99) v7(113.13,85.31) v7(113.41,172.72) v7(113.6,175.83) v7(114.12,177.99) v7(114.4,85.31) v7(115.39,177.99) v7(115.67,85.31) v7(116.4,108.4) v7(116.4,107.82) v7(116.46,172.79) v7(116.66,177.99) v7(116.73,88.8) v7(116.83,89.7) v7(116.88,87.86) v7(116.94,85.31) v7(116.97,108.4) v7(116.97,107.82) v7(117.22,121.73) v7(117.22,121.16) v7(117.22,120.59) v7(117.22,119.95) v7(117.22,114.56) v7(117.62,90.33) v7(117.62,87.27) v7(117.73,121.41) v7(117.73,120.84) v7(117.73,120.27) v7(117.73,119.7) v7(117.93,177.99) v7(118.11,147.54) v7(118.11,146.98) v7(118.24,148.17) v7(118.24,120.59) v7(118.24,120.02) v7(118.24,119.45) v7(118.21,85.31) v7(118.5,90.79) v7(118.48,86.84) v7(118.69,147.54) v7(118.69,146.98) v7(118.81,119.7) v7(119.2,177.99) v7(119.38,90.33) v7(119.38,87.27) v7(119.48,85.32) v7(120.12,87.9) v7(120.17,89.78) v7(120.27,88.8) v7(120.47,177.99) v7(120.58,85.95) v7(121.54,132.4) v7(121.54,131.19) v7(121.48,108.4) v7(121.48,107.82) v7(121.55,129.67) v7(121.64,86.66) v7(121.74,177.99) v7(122.05,108.4) v7(122.05,107.82) v7(122.49,129.86) v7(122.9,86.81) v7(123.01,177.99) v7(123.06,129.86) v7(123.15,127.52) v7(123.19,103.51) v7(123.37,138.56) v7(123.37,137.92) v7(123.37,137.29) v7(123.37,136.65) v7(123.78,128.14) v7(123.78,126.9) v7(124.21,103.51) v7(124.17,86.81) v7(124.28,177.99) v7(124.4,127.52) v7(124.84,103.51) v7(124.97,139.32) v7(125.44,86.81) v7(125.55,177.99) v7(125.67,139.32) v7(126.75,123.76) v7(126.75,123.13) v7(126.71,86.81) v7(126.82,177.99) v7(127.38,123.76) v7(127.38,123.13) v7(127.51,128.46) v7(127.51,127.89) v7(128.02,124.4) v7(128.02,123.76) v7(128.02,123.13) v7(127.98,86.81) v7(128.09,177.99) v7(128.35,127) v7(128.65,124.4) v7(128.65,123.76) v7(128.65,123.13) v7(128.78,140.15) v7(129.25,86.81) v7(129.29,123.76) v7(129.29,123.13) v7(129.36,177.92) v7(129.59,176.67) v7(129.59,175.4) v7(129.59,174.13) v7(129.59,172.86) v7(129.59,171.59) v7(129.59,170.32) v7(129.59,169.05) v7(129.59,167.78) v7(129.59,166.51) v7(129.59,165.24) v7(129.59,163.97) v7(129.59,162.7) v7(129.59,161.43) v7(129.59,160.16) v7(129.59,158.89) v7(129.59,157.62) v7(129.59,156.35) v7(129.59,155.08) v7(130.04,153.79) v7(130.52,86.81) v7(131,98.24) v7(131,97.66) v7(131.37,153.59) v7(131.58,98.24) v7(131.58,97.66) v7(131.79,86.81) v7(132.21,98.24) v7(132.21,97.66) v7(132.46,147.64) v7(132.46,147.06) v7(132.46,146.37) v7(132.46,145.79) v7(132.64,153.59) v7(132.79,98.24) v7(132.79,97.66) v7(133.06,86.81) v7(133.38,98.24) v7(133.38,97.66) v7(133.91,153.59) v7(133.96,98.24) v7(133.96,97.66) v7(134.26,127.67) v7(134.26,126.56) v7(134.26,125.44) v7(134.33,86.81) v7(134.54,98.24) v7(134.54,97.66) v7(135.13,98.24) v7(135.13,97.66) v7(135.18,153.59) v7(135.38,127.67) v7(135.38,126.56) v7(135.38,125.44) v7(135.6,86.81) v7(135.71,98.24) v7(135.71,97.66) v7(136.3,98.24) v7(136.3,97.66) v7(136.45,153.59) v7(136.5,127.67) v7(136.5,126.56) v7(136.5,125.44) v7(136.87,86.81) v7(137.72,153.59) v7(138.14,86.81) v7(138.41,141.73) v7(138.99,153.59) v7(139.03,142.35) v7(139.03,141.1) v7(139.41,86.81) v7(139.65,141.73) v7(140.26,153.59) v7(140.68,86.81) v7(141.3,142.23) v7(141.53,153.59) v7(141.95,86.8) v7(142.8,153.59) v7(143.16,86.42) v7(144.07,153.59) v7(144.11,85.58) v7(144.73,150.13) v7(145.34,153.59) v7(145.35,85.31) v7(146.61,153.59) v7(146.62,85.31) v7(147.78,153.57) v7(147.89,85.31) v7(149.17,153.11) v7(149.16,85.31) v7(150.43,85.31) v7(150.58,153.16) v7(151.21,95.49) v7(151.21,94.86) v7(151.18,94.22) v7(151.28,93.66) v7(151.51,116.91) v7(151.69,153.59) v7(151.7,85.31) v7(151.82,94.81) v7(151.84,94.22) v7(151.89,95.49) v7(151.87,93.66) v7(152.32,96.1) v7(152.43,94.91) v7(152.43,93.66) v7(152.45,94.25) v7(152.55,95.54) v7(152.65,144.91) v7(152.96,153.59) v7(153.03,93.66) v7(152.97,85.31) v7(153.06,96.18) v7(153.11,94.91) v7(153.06,94.22) v7(153.19,95.54) v7(154.23,153.59) v7(154.24,85.31) v7(155.42,154.04) v7(155.5,89.12) v7(155.5,87.85) v7(155.5,86.58) v7(155.5,85.31) v7(155.74,146.1) v7(155.68,90.36) v7(156.03,116.96) v7(156.1,155.11) v7(156.17,165.27) v7(156.16,164) v7(156.16,162.73) v7(156.16,161.46) v7(156.16,160.19) v7(156.16,158.92) v7(156.16,157.65) v7(156.16,156.38) v7(156.51,91.23) v7(157.1,117.67) v7(157.3,92.01) v7(157.39,165.64) v7(157.54,147.77) v7(157.63,163.56) v7(157.72,162.37) v7(157.8,164.31) v7(157.84,93.11) v7(157.9,94.27) v7(158.13,109.8) v7(158.27,110.69) v7(158.32,108.84) v7(158.52,164.68) v7(158.52,161.62) v7(158.66,165.64) v7(158.79,95.19) v7(159.02,111.33) v7(159.02,108.27) v7(159.44,165.08) v7(159.38,161.23) v7(159.93,165.64) v7(159.89,111.77) v7(159.88,107.82) v7(159.85,95.48) v7(160.28,164.68) v7(160.28,161.62) v7(160.78,111.33) v7(160.78,108.27) v7(160.99,161.98) v7(161.02,95.72) v7(161.12,163.88) v7(161.2,165.64) v7(161.16,162.73) v7(161.51,110.71) v7(161.49,108.85) v7(161.67,109.8) v7(161.95,96.65) v7(162.39,165.2) v7(162.39,163.93) v7(162.39,162.66) v7(162.39,161.39) v7(162.39,160.12) v7(162.39,158.85) v7(162.39,157.58) v7(162.39,156.31) v7(162.39,155.04) v7(162.39,153.77) v7(162.39,152.5) v7(162.39,151.23) v7(162.39,149.96) v7(162.39,148.69) v7(162.39,147.42) v7(162.39,146.15) v7(162.39,144.88) v7(162.39,143.61) v7(162.39,142.34) v7(162.39,141.07) v7(162.39,139.8) v7(162.39,138.53) v7(162.39,137.26) v7(162.39,135.99) v7(162.39,134.72) v7(162.39,133.45) v7(162.39,132.18) v7(162.39,130.91) v7(162.39,129.64) v7(162.39,128.37) v7(162.39,127.1) v7(162.39,125.83) v7(162.39,124.56) v7(162.39,123.29) v7(162.39,122.02) v7(162.39,120.75) v7(162.39,119.48) v7(162.39,118.21) v7(162.39,116.94) v7(162.39,115.67) v7(162.39,114.15) v7(162.39,105.51) v7(162.39,104.24) v7(162.39,102.97) v7(162.39,101.7) v7(162.39,100.43) v7(162.39,99.16) v7(162.39,97.89) v9(2.59,129.19) v9(8.81,130.38) v9(18.59,163.83) v9(30.72,36.5) v9(49.49,151.97) v9(71.18,17.77) v9(96.01,142.74) v9(122.69,131.73) v9(126.68,122.56) v9(129.86,111.94) v9(129.98,123.6) v9(132.14,138.63) v9(132.94,99.28) v9(153.68,144.16) v9(154.18,109.42) v10(42.13,159.5) v10(42.11,158.74) v10(42.13,157.77) v10(42.13,156.71) v10(42.11,155.46) v10(42.13,154.57) v10(42.82,159.63) v10(43.42,159.65) v10(43.62,163.03) v10(43.61,162.45) v10(43.6,161.89) v10(43.59,161.29) v10(44.06,163.44) v10(44.21,160.91) v10(44.86,163.44) v10(45.68,163.44) v10(46.13,160.91) v10(46.1,160.19) v10(46.63,163.43) v10(46.67,162.83) v10(46.66,162.16) v10(46.66,161.53) v10(47.42,159.78) v10(48.08,159.81) v10(48.5,163.41) v10(49.21,163.3) v10(49.72,163.07) v10(50.32,163.07) v10(51.04,163.09) v10(51.73,163.09) v10(52.72,163.08) v10(53.44,163.08) v10(54.24,163.08) v10(54.44,162.43) v10(54.93,163.06) v10(55.03,162.46) v10(55.61,163.11) v10(105.31,89.61) v10(105.8,96.48) v10(105.8,94.64) v10(106.16,97.83) v10(106.38,93.89) v10(106.5,91.04) v10(107.1,98.67) v12(1.32,125.54) v12(3,126.79) v12(3.71,121.78) v12(3.73,120.97) v12(4.06,113.15) v12(4.77,125.54) v12(4.78,121.2) v12(4.83,113.25) v12(4.95,120.23) v12(6.22,121.83) v12(6.25,121.17) v12(6.78,43.49) v12(6.79,37.99) v12(6.81,28.88) v12(6.81,23.39) v12(7.08,43.49) v12(7.1,37.99) v12(7.11,28.89) v12(7.11,23.4) v12(7.43,43.5) v12(7.44,38) v12(7.45,28.89) v12(7.45,23.41) v12(8.57,44.58) v12(8.57,43.18) v12(8.57,29.21) v12(8.57,27.82) v12(9.02,38.78) v12(9.02,23.8) v12(9.08,37.84) v12(9.08,37.08) v12(9.13,30.8) v12(9.14,26.99) v12(9.15,41.97) v12(9.21,22.99) v12(9.21,22.23) v12(9.4,44.52) v12(9.4,29.91) v12(10.54,158.94) v12(10.95,48.73) v12(10.95,46.7) v12(10.95,44.67) v12(10.95,42.63) v12(10.95,40.6) v12(10.95,38.57) v12(10.95,36.54) v12(10.95,34.51) v12(10.95,32.47) v12(10.95,30.44) v12(10.95,28.41) v12(10.95,26.38) v12(10.95,24.35) v12(10.95,22.31) v12(10.95,20.28) v12(10.93,18.45) v12(10.92,16.38) v12(11.05,138.11) v12(11.23,111.98) v12(11.19,50.75) v12(11.3,141.67) v12(11.56,144.85) v12(12.06,147.77) v12(12.56,103.57) v12(12.56,102.68) v12(12.69,42.78) v12(12.67,25.08) v12(12.83,157.42) v12(12.75,37.05) v12(12.92,101.92) v12(12.92,101.28) v12(13.21,159.07) v12(13.22,50.75) v12(13.21,48.83) v12(13.21,48.58) v12(13.21,48.33) v12(13.34,24.7) v12(13.49,37.45) v12(13.61,174.5) v12(13.63,42.78) v12(13.97,156.28) v12(14.22,91.89) v12(14.2,30.29) v12(14.2,29.4) v12(14.35,144.85) v12(14.35,140.4) v12(14.48,142.56) v12(14.48,90.11) v12(14.61,147.64) v12(14.66,42.76) v12(14.73,19) v12(15.01,16.15) v12(15.1,98.95) v12(15.1,98.15) v12(15.1,97.35) v12(15.1,96.55) v12(15.24,30.67) v12(15.26,50.75) v12(15.44,17.39) v12(15.56,42.76) v12(15.75,155.51) v12(16,33.23) v12(16.22,44.17) v12(16.26,47.78) v12(16.54,42.38) v12(16.51,30.67) v12(16.62,35.7) v12(16.76,152.85) v12(16.89,22.33) v12(16.99,42.33) v12(17.03,33.14) v12(17.27,69.53) v12(17.27,66.99) v12(17.27,62.68) v12(17.29,50.75) v12(17.64,35.61) v12(17.55,29.19) v12(17.65,158.69) v12(17.86,42.28) v12(18.03,146.88) v12(18.26,42.28) v12(18.54,29.17) v12(18.8,68.26) v12(19.07,16.15) v12(19.18,158.69) v12(19.33,50.75) v12(19.34,42.13) v12(19.25,41.31) v12(19.47,52.98) v12(19.46,29.2) v12(19.56,34.36) v12(19.68,149.04) v12(19.68,21.15) v12(19.76,165.17) v12(19.81,157.04) v12(19.91,41.34) v12(20.32,154.24) v12(20.32,147.26) v12(20.38,28.88) v12(20.57,143.96) v12(20.7,151.58) v12(20.97,52.98) v12(21.01,42.9) v12(21.01,28.88) v12(21.36,50.75) v12(21.38,23.23) v12(22.1,65.98) v12(22.06,47.87) v12(22.44,143.83) v12(22.35,62.17) v12(22.47,52.98) v12(22.61,153.35) v12(22.86,135.32) v12(22.91,41.6) v12(23.14,16.15) v12(23.28,21.93) v12(23.38,114.62) v12(23.39,50.75) v12(23.62,18.06) v12(23.97,52.98) v12(24.38,152.08) v12(24.38,63.44) v12(24.64,66.23) v12(24.74,107.51) v12(24.83,105.92) v12(24.88,114.62) v12(24.88,43.18) v12(25.13,21.4) v12(25.42,50.75) v12(25.91,135.32) v12(25.91,45.79) v12(26.05,17.78) v12(26.21,20.89) v12(26.29,105.94) v12(26.38,114.62) v12(26.54,48.14) v12(26.89,96.05) v12(26.89,94.55) v12(27.13,50.94) v12(27.2,16.15) v12(27.34,90.54) v12(27.3,42.83) v12(27.35,19.68) v12(27.81,44.49) v12(27.85,40.96) v12(28.19,94.3) v12(28.19,93.03) v12(28.44,96.6) v12(28.44,92) v12(28.47,52.98) v12(29.34,135.32) v12(29.46,62.68) v12(29.49,50.75) v12(29.55,90.7) v12(30.33,49.4) v12(30.3,47.16) v12(30.38,114.62) v12(30.62,22.1) v12(30.73,17.57) v12(30.85,91.62) v12(30.97,52.98) v12(31,42.42) v12(31.24,152.08) v12(31.5,62.68) v12(31.52,50.75) v12(31.88,114.62) v12(32.26,137.86) v12(32.29,47.68) v12(32.38,114.62) v12(32.47,52.98) v12(32.64,135.32) v12(32.64,100.29) v12(32.64,100.01) v12(32.64,99.73) v12(32.79,22.16) v12(33.16,152.71) v12(33.27,148.27) v12(33.27,144.97) v12(33.32,100.27) v12(33.32,99.76) v12(33.53,154.88) v12(33.53,128.02) v12(33.45,102.94) v12(33.55,50.75) v12(33.78,157.42) v12(33.96,115.13) v12(34.21,105.81) v12(34.32,128.78) v12(34.29,62.68) v12(34.42,140.53) v12(34.37,127.52) v12(34.36,45.14) v12(34.53,40.71) v12(34.48,26.5) v12(34.54,20.06) v12(34.8,151.07) v12(34.8,138.5) v12(34.82,126.61) v12(34.82,17.85) v12(34.92,156.53) v12(35.04,154.69) v12(35.18,136.46) v12(35.31,157.93) v12(35.33,16.15) v12(35.51,129.78) v12(35.47,125.88) v12(35.51,124.63) v12(35.57,128.25) v12(35.58,50.75) v12(35.78,122.53) v12(35.81,18.07) v12(35.94,106.08) v12(35.95,127.33) v12(35.99,123.8) v12(36.03,121.07) v12(36,120.02) v12(36,109.18) v12(36,107.57) v12(36.09,126.32) v12(36.07,66.23) v12(36.32,147.64) v12(36.3,125.1) v12(36.32,49.04) v12(36.31,39.82) v12(36.31,38.93) v12(36.38,25.2) v12(36.47,130.44) v12(36.54,128.73) v12(36.56,156.22) v12(36.58,139.13) v12(36.74,126.7) v12(36.73,22.16) v12(36.73,21.27) v12(36.79,122.57) v12(36.91,99.25) v12(36.91,97.98) v12(36.92,42.8) v12(37.01,127.9) v12(37.03,124.46) v12(37.1,125.62) v12(37.16,118.59) v12(37.21,109.29) v12(37.34,154.24) v12(37.34,146.37) v12(37.4,123.17) v12(37.39,121.05) v12(37.47,21.82) v12(37.59,149.67) v12(37.55,131.23) v12(37.62,120.04) v12(37.59,119.11) v12(37.61,50.75) v12(37.72,135.07) v12(37.69,129.4) v12(37.72,127.24) v12(37.85,157.48) v12(37.78,125.17) v12(37.85,63.95) v12(37.99,126.21) v12(38.13,128.6) v12(38.1,20.19) v12(38.16,167.37) v12(38.18,121.65) v12(38.2,109.98) v12(38.52,124.19) v12(38.65,125.96) v12(38.72,166.92) v12(38.71,131.95) v12(38.73,47.69) v12(38.77,158.57) v12(38.85,130.02) v12(38.8,127.69) v12(38.82,126.72) v12(38.84,45.07) v12(38.94,44.07) v12(38.94,43.18) v12(38.88,25.4) v12(39.07,167.4) v12(39.07,53.75) v12(39.15,106.58) v12(39.39,16.15) v12(39.5,45.91) v12(39.65,50.75) v12(39.67,105.82) v12(39.76,163.16) v12(39.76,162.33) v12(39.76,161.48) v12(39.76,160.58) v12(39.75,159.72) v12(39.79,110.86) v12(39.76,107.34) v12(39.93,157.72) v12(39.93,153.66) v12(39.93,149.59) v12(39.93,145.78) v12(39.93,141.47) v12(39.93,137.4) v12(39.93,135.6) v12(39.93,134) v12(39.93,131.66) v12(39.93,129.27) v12(39.93,127.23) v12(39.93,125.21) v12(39.94,123.76) v12(39.92,121.25) v12(39.93,117.08) v12(39.93,113.02) v12(39.95,151.58) v12(39.97,147.83) v12(40.2,164.03) v12(40.24,104.12) v12(40.24,101.47) v12(40.21,93.45) v12(40.52,108.19) v12(40.5,105.75) v12(40.93,49.9) v12(40.9,48.37) v12(40.9,44.3) v12(40.9,42.27) v12(40.9,40.24) v12(40.9,36.18) v12(40.9,34.14) v12(40.92,31.55) v12(40.92,29.52) v12(40.92,27.48) v12(40.92,25.4) v12(40.92,21.34) v12(40.92,19.31) v12(40.92,17.27) v12(40.96,46.2) v12(41.14,106.29) v12(41.1,105.44) v12(41.18,59.67) v12(41.18,51.55) v12(41.49,165.24) v12(41.71,152.47) v12(41.71,150.69) v12(41.77,107.45) v12(41.8,105.83) v12(41.89,100.22) v12(42.25,167.08) v12(42.43,129.11) v12(42.58,105.44) v12(42.62,95.67) v12(42.65,89.59) v12(42.74,165.25) v12(42.66,87.73) v12(42.7,85.95) v12(42.71,75.49) v12(42.72,64.2) v12(42.7,61.56) v12(42.7,59.53) v12(42.7,57.5) v12(42.7,55.47) v12(42.7,53.44) v12(42.7,51.4) v12(42.7,49.37) v12(42.7,41.24) v12(42.7,39.21) v12(42.7,37.18) v12(42.68,30.35) v12(42.7,27.32) v12(42.7,24.99) v12(42.71,22.8) v12(42.72,21.17) v12(42.7,19.8) v12(42.71,18.73) v12(42.7,16.99) v12(42.93,167.46) v12(43.17,118.43) v12(43.17,117.33) v12(44.15,167.08) v12(44.08,165.25) v12(44.08,119.45) v12(44.27,106.06) v12(44.39,89.65) v12(44.75,86.36) v12(44.96,73.22) v12(45.6,165.25) v12(45.74,100.22) v12(45.78,89.61) v12(45.92,125.29) v12(46,82.79) v12(46.28,119.45) v12(46.5,82.79) v12(46.59,86.67) v12(46.69,104.68) v12(46.74,73.85) v12(46.99,70.8) v12(47.12,165.25) v12(48.05,89.65) v12(48,82.79) v12(48.65,165.25) v12(48.82,125.64) v12(49.02,103.47) v12(49.25,140.91) v12(49.53,68.26) v12(49.62,130.5) v12(49.68,94.22) v12(50.17,165.25) v12(50.19,140.91) v12(50.34,84.9) v12(50.79,115.44) v12(50.8,73.85) v12(50.88,44.05) v12(50.97,129.5) v12(50.98,102.29) v12(51.03,60.87) v12(51.05,65.22) v12(51.19,148.66) v12(51.19,147.77) v12(51.41,165) v12(51.61,157.32) v12(51.61,157) v12(51.71,120.48) v12(51.88,162.47) v12(51.88,162.22) v12(51.88,161.96) v12(52.13,162.47) v12(52.13,162.22) v12(52.13,161.96) v12(52.12,157.32) v12(52.12,157) v12(52.39,162.47) v12(52.39,162.22) v12(52.39,161.96) v12(52.51,89.65) v12(52.5,82.79) v12(52.64,162.47) v12(52.64,162.22) v12(52.64,161.96) v12(52.55,98.31) v12(52.55,91.81) v12(52.72,165) v12(52.9,101.24) v12(52.96,157.72) v12(53.54,145.35) v12(53.54,144.46) v12(53.85,157.72) v12(53.85,73.34) v12(53.85,64.96) v12(53.89,146.27) v12(53.98,114.68) v12(54,82.79) v12(54.09,153.65) v12(54.09,153.14) v12(54.24,165.25) v12(54.21,146.27) v12(54.22,60.89) v12(54.41,153.65) v12(54.41,153.14) v12(54.52,100.34) v12(54.59,148.13) v12(54.59,147.79) v12(54.61,69.03) v12(54.74,143.36) v12(54.74,143.11) v12(54.96,148.13) v12(54.96,147.79) v12(54.99,143.36) v12(54.99,143.11) v12(54.96,129.32) v12(54.96,124.02) v12(54.99,43.94) v12(55.11,144.21) v12(55.05,93.31) v12(55.24,143.36) v12(55.24,143.11) v12(55.27,113.48) v12(55.5,82.79) v12(55.93,129.32) v12(55.93,121.37) v12(55.93,119.38) v12(56,99.46) v12(56.13,62.93) v12(56.13,45.91) v12(56.13,41.34) v12(56.24,165.09) v12(56.43,52.59) v12(56.58,150.04) v12(56.58,148.91) v12(56.58,148.32) v12(56.64,116.61) v12(56.64,71.82) v12(56.69,127.93) v12(56.71,120.44) v12(56.72,47.68) v12(56.9,55.06) v12(56.9,49.47) v12(56.99,157.95) v12(56.99,157.28) v12(56.99,156.61) v12(57,82.79) v12(57.09,150.04) v12(57.09,148.91) v12(57.09,148.32) v12(57.12,112.52) v12(57.59,150.04) v12(57.61,148.78) v12(57.59,148.32) v12(57.8,157.95) v12(57.8,157.28) v12(57.8,156.61) v12(57.91,148.73) v12(58.01,128.85) v12(58.01,123.64) v12(58.01,122.58) v12(58.01,119.5) v12(58.1,150.04) v12(58.1,148.32) v12(58.48,165.09) v12(58.47,129.5) v12(58.47,116.61) v12(58.5,82.79) v12(58.61,150.04) v12(58.61,148.91) v12(58.61,148.32) v12(58.67,98.06) v12(58.93,65.22) v12(59.16,157.41) v12(59.18,157.1) v12(59.18,150.04) v12(59.18,148.91) v12(59.18,148.32) v12(59.18,59.88) v12(59.38,130.8) v12(59.44,69.03) v12(59.64,103.7) v12(59.73,157.1) v12(59.69,150.04) v12(59.69,148.91) v12(59.69,148.32) v12(59.75,157.42) v12(59.94,42.36) v12(59.94,37.78) v12(59.98,132.87) v12(59.96,119.5) v12(60,82.79) v12(60.2,150.04) v12(60.2,148.91) v12(60.2,148.32) v12(60.16,97.23) v12(60.2,47.18) v12(60.27,157.39) v12(60.33,157.06) v12(60.3,132.1) v12(60.5,103.7) v12(60.68,157.02) v12(60.71,150.04) v12(60.71,148.91) v12(60.71,148.32) v12(60.96,157.04) v12(61.15,150.04) v12(61.15,148.91) v12(61.15,148.32) v12(61.21,72.58) v12(61.26,126.84) v12(61.26,124.71) v12(61.26,122.58) v12(61.26,120.44) v12(61.47,63.08) v12(61.47,58.61) v12(61.68,157.79) v12(61.72,120.44) v12(61.98,39.05) v12(62.1,165.09) v12(62.13,130.15) v12(62.11,126.03) v12(62.11,121.84) v12(62.08,87.52) v12(62.48,70.04) v12(62.48,68.26) v12(62.6,97.29) v12(62.76,125.19) v12(62.76,123.52) v12(62.76,122.68) v12(62.76,121) v12(62.76,119.33) v12(62.99,107.94) v12(62.99,104.23) v12(63.15,114.47) v12(63.25,34.23) v12(63.41,126.87) v12(63.41,126.03) v12(63.41,125.19) v12(63.41,124.36) v12(63.41,121.84) v12(63.82,128.91) v12(63.75,54.8) v12(63.96,157.18) v12(63.96,156.54) v12(63.96,132.1) v12(63.96,130.15) v12(63.96,117.26) v12(64.01,41.59) v12(64.13,165.09) v12(64.08,151.86) v12(64.08,150.92) v12(64.08,150.03) v12(64.06,126.03) v12(64.06,125.19) v12(64.06,123.52) v12(64.06,121) v12(64.06,119.33) v12(64.12,108.84) v12(64.12,107.06) v12(64.14,104.26) v12(64.27,157.18) v12(64.27,156.54) v12(64.26,132.83) v12(64.38,114.47) v12(64.71,127.71) v12(64.71,126.87) v12(64.71,124.36) v12(64.71,122.68) v12(64.71,121) v12(64.87,151.86) v12(64.87,150.92) v12(64.87,150.03) v12(64.97,137.1) v12(65.13,119.78) v12(65.36,128.55) v12(65.36,126.87) v12(65.36,124.36) v12(65.36,122.68) v12(65.36,121) v12(65.71,151.88) v12(65.71,150.94) v12(65.71,150.05) v12(65.7,89.17) v12(65.85,165.09) v12(65.78,132.1) v12(65.79,106.52) v12(65.79,33.47) v12(66.01,126.87) v12(66.01,126.03) v12(66.01,124.36) v12(66.01,123.52) v12(66.01,122.68) v12(66.01,121) v12(66.01,119.33) v12(66.04,52.26) v12(66.04,45.91) v12(66.04,41.09) v12(66.23,152.2) v12(66.23,151.07) v12(66.23,149.93) v12(66.23,148.85) v12(66.23,148.27) v12(66.36,88.39) v12(66.55,35.24) v12(66.55,31.18) v12(66.74,152.2) v12(66.74,151.07) v12(66.74,149.93) v12(66.74,148.85) v12(66.74,148.27) v12(66.7,131.45) v12(66.85,161.48) v12(66.86,160.81) v12(66.85,160.14) v12(67.25,152.2) v12(67.25,151.07) v12(67.25,149.93) v12(67.45,163.21) v12(67.44,104.87) v12(67.61,117.91) v12(67.61,117.26) v12(67.61,116.61) v12(67.61,115.96) v12(67.67,161.48) v12(67.67,160.81) v12(67.67,160.14) v12(67.84,162.93) v12(67.75,152.2) v12(67.75,151.07) v12(67.75,149.93) v12(67.9,87.13) v12(67.9,85.1) v12(67.9,83.06) v12(67.9,74.94) v12(67.9,72.9) v12(67.9,70.92) v12(67.9,66.86) v12(67.9,64.82) v12(67.9,62.74) v12(67.9,60.76) v12(67.9,58.68) v12(67.94,49.42) v12(67.94,41.33) v12(67.9,38.41) v12(67.9,36.38) v12(67.9,30.23) v12(67.87,28.07) v12(67.87,26.05) v12(67.9,24.14) v12(67.9,22.15) v12(67.88,19.04) v12(67.92,15.9) v12(67.88,13.55) v12(67.86,11.37) v12(67.87,10.36) v12(67.9,7.93) v12(67.91,7.02) v12(67.9,6.15) v12(67.97,52.91) v12(67.96,51.41) v12(68.15,163.44) v12(68.15,162.93) v12(68.13,112.52) v12(68.24,94.08) v12(68.26,152.2) v12(68.26,151.07) v12(68.26,149.93) v12(68.26,148.85) v12(68.26,148.27) v12(68.54,133.52) v12(68.54,132.87) v12(68.63,161.48) v12(68.63,160.81) v12(68.63,160.34) v12(68.63,159.89) v12(68.63,159.42) v12(68.63,159.03) v12(68.63,158.56) v12(68.63,158.18) v12(68.72,163.44) v12(68.72,163.11) v12(68.72,162.8) v12(68.83,152.2) v12(68.83,151.07) v12(68.83,148.85) v12(68.83,148.27) v12(68.96,149.98) v12(68.99,130.34) v12(69.09,161) v12(69.09,160.62) v12(69.09,160.21) v12(69.09,159.81) v12(69.09,159.4) v12(69.09,158.99) v12(69.09,158.61) v12(69.12,102.77) v12(69.23,163.44) v12(69.23,163.11) v12(69.23,162.8) v12(69.22,132.83) v12(69.18,54.04) v12(69.34,152.2) v12(69.34,151.07) v12(69.34,149.93) v12(69.34,148.85) v12(69.34,148.27) v12(69.34,140.48) v12(69.44,131.45) v12(69.65,161.46) v12(69.63,161.08) v12(69.63,160.44) v12(69.63,159.7) v12(69.63,159.07) v12(69.63,158.43) v12(69.85,152.2) v12(69.85,151.07) v12(69.85,149.93) v12(69.85,148.85) v12(69.85,148.27) v12(69.77,65.47) v12(69.77,64.58) v12(70.02,163.44) v12(70.02,163.11) v12(70.02,162.8) v12(70.31,161.43) v12(70.29,161.05) v12(70.29,159.09) v12(70.29,158.46) v12(70.36,152.2) v12(70.36,149.93) v12(70.36,148.85) v12(70.36,148.27) v12(70.36,117.91) v12(70.36,117.26) v12(70.36,116.61) v12(70.36,115.96) v12(70.48,165.18) v12(70.46,151.09) v12(70.48,112.52) v12(70.58,114.47) v12(70.66,163.41) v12(70.66,162.88) v12(70.74,58.27) v12(70.8,152.2) v12(70.8,151.07) v12(70.8,149.93) v12(70.8,148.85) v12(70.8,148.27) v12(70.81,130.34) v12(70.85,158.46) v12(70.85,158.14) v12(70.9,62.17) v12(70.9,61.66) v12(70.99,161.46) v12(70.98,161.08) v12(70.99,87.17) v12(71.15,104.42) v12(71.17,103.15) v12(71.2,101.96) v12(71.27,117.91) v12(71.37,163.41) v12(71.37,162.88) v12(71.49,158.46) v12(71.49,158.14) v12(71.54,93.35) v12(71.58,95.12) v12(71.58,94.22) v12(71.68,161.46) v12(71.67,161.08) v12(71.7,133.85) v12(71.7,132.83) v12(71.73,119.04) v12(71.67,99.63) v12(71.67,98.76) v12(71.67,97.87) v12(71.68,96.99) v12(71.68,63.31) v12(71.78,151.96) v12(71.78,151.02) v12(71.78,150.13) v12(71.93,109.41) v12(71.93,108.43) v12(71.94,79.7) v12(71.94,79.3) v12(72.16,163.41) v12(72.16,162.88) v12(72.19,117.26) v12(72.19,115.31) v12(72.43,141.12) v12(72.42,101.96) v12(72.51,165.18) v12(72.57,138.32) v12(72.71,54.95) v12(72.72,54.04) v12(73.01,114.47) v12(73.08,163.39) v12(73.08,162.85) v12(73.1,117.91) v12(73.11,112.52) v12(73.09,71.06) v12(73.09,69.79) v12(73.2,152.01) v12(73.2,151.07) v12(73.2,150.18) v12(73.44,105.87) v12(73.56,119.04) v12(73.84,161.99) v12(73.83,161.61) v12(74.01,117.91) v12(74.01,117.26) v12(74.01,116.61) v12(74.01,115.96) v12(73.96,85.92) v12(74.43,138.28) v12(74.43,105.87) v12(74.54,165.18) v12(74.63,139.42) v12(74.93,131.45) v12(74.93,117.91) v12(75.06,149.12) v12(75.06,148.81) v12(75.18,152.9) v12(75.18,151.96) v12(75.18,151.07) v12(75.18,149.7) v12(75.37,149.12) v12(75.37,148.81) v12(75.39,119.04) v12(75.37,105.9) v12(75.56,114.47) v12(75.69,149.12) v12(75.69,148.81) v12(75.84,117.91) v12(75.84,117.26) v12(75.84,115.31) v12(75.84,102.13) v12(75.84,100.83) v12(75.84,99.53) v12(75.84,95.63) v12(75.84,94.33) v12(75.84,93.03) v12(76.01,149.12) v12(76.01,148.81) v12(76.15,109.41) v12(76.26,155.64) v12(76.26,155.39) v12(76.26,155.13) v12(76.33,149.12) v12(76.33,148.81) v12(76.41,105.9) v12(76.52,155.64) v12(76.52,155.39) v12(76.52,155.13) v12(76.58,165.18) v12(76.77,155.64) v12(76.77,155.39) v12(76.77,155.13) v12(76.83,152.95) v12(76.83,152.01) v12(76.83,151.12) v12(76.83,149.75) v12(76.76,117.91) v12(76.77,114.47) v12(76.77,113.25) v12(77.03,155.64) v12(77.03,155.39) v12(77.03,155.13) v12(77.44,98.23) v12(77.44,96.93) v12(77.67,117.91) v12(77.67,117.26) v12(77.67,116.61) v12(77.67,115.96) v12(77.84,105.79) v12(77.84,90.24) v12(77.85,51) v12(77.97,114.47) v12(78.07,112.52) v12(78.05,87.15) v12(78.24,98.88) v12(78.24,96.28) v12(78.3,149.06) v12(78.3,148.74) v12(78.41,152.95) v12(78.41,152.01) v12(78.41,151.12) v12(78.41,149.75) v12(78.54,109.41) v12(78.54,108.4) v12(78.61,165.18) v12(78.61,149.06) v12(78.61,148.74) v12(78.59,118.56) v12(78.59,116.61) v12(78.6,88.36) v12(78.93,149.06) v12(78.93,148.74) v12(78.86,105.81) v12(79.04,98.88) v12(79.13,133.85) v12(79.13,132.83) v12(79.25,149.06) v12(79.25,148.74) v12(79.24,114.47) v12(79.24,113.25) v12(79.17,76.2) v12(79.5,130.8) v12(79.5,118.56) v12(79.48,76.2) v12(79.57,149.06) v12(79.57,148.74) v12(79.81,132.87) v12(79.79,116.38) v12(80.07,84.41) v12(80.24,152.92) v12(80.24,151.98) v12(80.24,151.09) v12(80.24,149.72) v12(80.42,132.1) v12(80.42,118.56) v12(80.42,116.61) v12(80.39,107.71) v12(80.4,83.61) v12(80.46,114.47) v12(80.53,90.16) v12(80.64,165.18) v12(80.64,102.13) v12(80.64,101.48) v12(80.64,100.18) v12(80.64,99.53) v12(80.64,98.88) v12(80.64,95.63) v12(80.85,157.15) v12(80.85,156.52) v12(80.93,132.87) v12(81.17,157.15) v12(81.17,156.52) v12(81.18,106.08) v12(81.2,44.35) v12(81.2,32.95) v12(81.2,21.55) v12(81.33,130.8) v12(81.33,116.61) v12(81.28,107.71) v12(81.44,102.13) v12(81.44,101.48) v12(81.44,100.18) v12(81.44,99.53) v12(81.44,95.63) v12(81.61,133.85) v12(81.61,132.83) v12(81.65,114.47) v12(82.24,132.1) v12(82.24,116.61) v12(82.17,107.71) v12(82.24,102.13) v12(82.24,101.48) v12(82.24,100.18) v12(82.24,99.53) v12(82.24,97.58) v12(82.24,96.28) v12(82.52,151.78) v12(82.52,150.84) v12(82.52,149.95) v12(82.52,148.58) v12(82.67,165.18) v12(82.7,119.04) v12(82.84,114.47) v12(83.04,102.13) v12(83.04,100.83) v12(83.04,96.28) v12(83.15,47.6) v12(83.15,18.3) v12(83.19,152.13) v12(83.19,151) v12(83.19,149.86) v12(83.19,148.78) v12(83.19,148.21) v12(83.16,130.8) v12(83.16,116.61) v12(83.5,86.6) v12(83.58,107.33) v12(83.74,161.46) v12(83.75,160.78) v12(83.74,160.11) v12(83.69,152.13) v12(83.69,151) v12(83.69,149.86) v12(83.69,148.78) v12(83.69,148.21) v12(83.84,102.13) v12(83.84,96.93) v12(83.84,93.03) v12(84.07,132.1) v12(84.07,116.61) v12(84.06,114.47) v12(84.06,113.25) v12(84.2,152.13) v12(84.2,151) v12(84.2,149.86) v12(84.2,148.78) v12(84.2,148.21) v12(84.47,107.33) v12(84.57,162.88) v12(84.56,161.46) v12(84.56,160.78) v12(84.56,160.11) v12(84.7,165.18) v12(84.71,152.13) v12(84.71,151) v12(84.71,149.86) v12(84.71,148.78) v12(84.71,148.21) v12(84.87,162.88) v12(84.99,130.8) v12(84.99,116.61) v12(85.03,45.2) v12(85.03,43.7) v12(85.03,42.2) v12(85.03,40.7) v12(85.09,138.95) v12(85.1,37.2) v12(85.1,36.2) v12(85.1,26.7) v12(85.1,25.7) v12(85.1,24.2) v12(85.22,152.13) v12(85.22,151) v12(85.22,149.86) v12(85.22,148.78) v12(85.22,148.21) v12(85.32,163.39) v12(85.32,163.09) v12(85.32,162.8) v12(85.33,114.47) v12(85.52,161.46) v12(85.52,160.78) v12(85.52,160.31) v12(85.52,159.87) v12(85.52,159.4) v12(85.52,159) v12(85.52,158.54) v12(85.52,158.15) v12(85.66,163.39) v12(85.66,163.09) v12(85.66,162.8) v12(85.79,152.13) v12(85.79,151) v12(85.79,149.86) v12(85.79,148.78) v12(85.79,148.21) v12(85.9,132.1) v12(85.9,115.96) v12(85.99,163.39) v12(85.99,163.09) v12(85.99,162.8) v12(85.98,160.97) v12(85.98,160.59) v12(85.98,160.19) v12(85.98,159.78) v12(85.98,159.37) v12(85.98,158.97) v12(85.98,158.59) v12(86.02,86.58) v12(86.11,113.83) v12(86.3,152.13) v12(86.3,151) v12(86.3,149.86) v12(86.3,148.78) v12(86.3,148.21) v12(86.36,119.04) v12(86.51,163.39) v12(86.51,162.83) v12(86.5,160.64) v12(86.5,159.68) v12(86.5,159.09) v12(86.5,158.15) v12(86.56,133.85) v12(86.56,132.83) v12(86.74,165.18) v12(86.8,152.13) v12(86.8,151) v12(86.8,149.86) v12(86.8,148.78) v12(86.8,148.21) v12(86.82,130.8) v12(86.82,117.91) v12(86.82,117.26) v12(86.82,116.61) v12(86.82,115.96) v12(86.9,92.01) v12(87.12,159.82) v12(87.12,159.18) v12(87.12,158.48) v12(87.22,162.17) v12(87.31,152.13) v12(87.31,151) v12(87.31,149.86) v12(87.31,148.78) v12(87.31,148.21) v12(87.73,130.8) v12(87.73,118.56) v12(87.74,114.47) v12(87.73,96.73) v12(87.73,95.77) v12(87.76,163.44) v12(87.76,152.13) v12(87.76,151) v12(87.76,149.86) v12(87.76,148.78) v12(87.76,148.21) v12(87.83,90.71) v12(87.82,89.8) v12(87.88,159.82) v12(87.88,159.18) v12(87.88,158.48) v12(87.99,161.86) v12(88.01,111.86) v12(88.07,162.12) v12(88.07,161.61) v12(88.33,162.12) v12(88.27,161.86) v12(88.33,161.61) v12(88.39,163.44) v12(88.58,162.12) v12(88.58,161.86) v12(88.58,161.61) v12(88.65,151.8) v12(88.65,150.86) v12(88.65,149.98) v12(88.65,148.6) v12(88.65,129.86) v12(88.64,118.56) v12(88.74,91.48) v12(88.77,165.18) v12(88.84,162.12) v12(88.84,161.86) v12(88.84,161.61) v12(88.82,159.81) v12(88.85,159.2) v12(88.87,158.61) v12(88.94,122.73) v12(89.01,113.63) v12(89.15,163.44) v12(89.23,92.4) v12(89.41,151.8) v12(89.43,150.86) v12(89.41,149.95) v12(89.43,148.63) v12(89.43,129.56) v12(89.41,125.93) v12(89.41,121.36) v12(89.41,120.45) v12(89.56,117.91) v12(89.56,117.26) v12(89.56,116.61) v12(89.56,115.96) v12(89.76,163.07) v12(89.76,162.43) v12(89.76,161.74) v12(89.76,159.78) v12(89.75,159.16) v12(89.75,158.52) v12(90.07,159.16) v12(90.07,158.52) v12(90.08,129.56) v12(90.06,125.93) v12(90.06,122.28) v12(90.06,120.45) v12(90.06,118.66) v12(90.3,151.5) v12(90.3,150.48) v12(90.29,114.47) v12(90.31,112.12) v12(90.63,132.16) v12(90.63,130.86) v12(90.73,129.56) v12(90.71,127.76) v12(90.71,124.1) v12(90.71,122.28) v12(90.71,118.66) v12(90.68,106.57) v12(90.8,165.18) v12(91.06,90.1) v12(91.41,151.53) v12(91.44,150.48) v12(91.38,129.56) v12(91.36,125.93) v12(91.36,122.28) v12(91.36,118.66) v12(91.44,107.08) v12(91.52,133.85) v12(91.52,132.83) v12(91.52,113.82) v12(91.52,113.17) v12(91.66,102.07) v12(91.66,98.17) v12(91.66,96.87) v12(91.82,118.56) v12(92.03,129.56) v12(92.01,125.93) v12(92.01,122.28) v12(92.01,120.45) v12(92.23,148.86) v12(92.23,148.6) v12(92.23,148.35) v12(92.2,112.19) v12(92.33,117.18) v12(92.33,116) v12(92.32,114.8) v12(92.33,107.08) v12(92.53,150.81) v12(92.53,149.87) v12(92.48,148.86) v12(92.48,148.6) v12(92.48,148.35) v12(92.46,101.42) v12(92.46,98.82) v12(92.65,129.36) v12(92.74,148.86) v12(92.74,148.6) v12(92.74,148.35) v12(92.66,127.76) v12(92.66,124.1) v12(92.66,122.28) v12(92.8,165.18) v12(92.99,148.86) v12(92.99,148.6) v12(92.99,148.35) v12(93.12,117.16) v12(93.31,125.93) v12(93.31,122.28) v12(93.31,114.61) v12(93.27,107.08) v12(93.26,98.82) v12(93.26,97.52) v12(93.5,141.95) v12(93.5,141.7) v12(93.5,141.44) v12(93.52,104.84) v12(93.63,129.25) v12(93.63,119.68) v12(93.75,141.95) v12(93.75,141.7) v12(93.75,141.44) v12(94.01,141.95) v12(94.01,141.7) v12(94.01,141.44) v12(93.96,125.93) v12(93.96,114.61) v12(94.15,112.19) v12(94.06,102.07) v12(94.06,101.42) v12(94.06,100.12) v12(94.06,99.47) v12(94.06,93.62) v12(94.16,107.08) v12(94.26,141.95) v12(94.26,141.7) v12(94.26,141.44) v12(94.28,130.6) v12(94.28,121.01) v12(94.28,116) v12(94.45,152.91) v12(94.45,152.59) v12(94.61,146.25) v12(94.61,138.1) v12(94.61,114.61) v12(94.61,113.31) v12(94.61,112.66) v12(94.79,90.1) v12(94.86,165.18) v12(94.86,102.07) v12(94.86,101.42) v12(94.86,100.12) v12(94.86,99.47) v12(94.86,98.82) v12(94.86,96.22) v12(94.86,93.62) v12(94.86,92.97) v12(95.08,152.91) v12(95.08,152.59) v12(95.2,117.7) v12(95.68,90.25) v12(96.39,158.74) v12(96.4,158.06) v12(96.39,157.39) v12(96.46,98.82) v12(96.46,96.22) v12(96.46,94.27) v12(96.7,165.19) v12(97.21,158.74) v12(97.21,158.06) v12(97.21,157.39) v12(97.28,138.95) v12(97.26,98.82) v12(97.46,90.25) v12(97.97,143.63) v12(97.97,143.37) v12(97.97,143.12) v12(98.06,98.17) v12(98.17,158.74) v12(98.17,158.06) v12(98.17,157.6) v12(98.17,157.15) v12(98.17,156.68) v12(98.17,156.28) v12(98.17,155.82) v12(98.17,155.44) v12(98.22,143.63) v12(98.22,143.37) v12(98.22,143.12) v12(98.17,138.95) v12(98.3,127.19) v12(98.32,126.33) v12(98.32,125.16) v12(98.32,124.27) v12(98.29,117.91) v12(98.48,143.63) v12(98.48,143.37) v12(98.48,143.12) v12(98.63,158.26) v12(98.63,157.88) v12(98.63,157.47) v12(98.63,157.06) v12(98.63,156.66) v12(98.63,156.25) v12(98.63,155.87) v12(98.73,143.63) v12(98.73,143.37) v12(98.73,143.12) v12(98.76,134.69) v12(98.76,133.8) v12(98.83,105.01) v12(98.93,165.18) v12(98.95,162.04) v12(98.95,161.72) v12(98.87,159.93) v12(99.11,158.13) v12(99.15,157.04) v12(99.12,156.4) v12(99.12,155.64) v12(99.2,161.13) v12(99.2,160.49) v12(99.31,159.28) v12(99.44,161.86) v12(99.42,158.55) v12(99.52,161.13) v12(99.52,160.49) v12(99.52,158) v12(99.52,157.68) v12(99.52,157.37) v12(99.52,157.05) v12(99.5,152.49) v12(99.5,151.54) v12(99.5,150.52) v12(99.5,149.44) v12(99.5,148.43) v12(99.67,127.83) v12(99.66,102.07) v12(99.66,100.77) v12(99.66,99.47) v12(99.66,97.52) v12(99.66,95.57) v12(99.66,94.27) v12(99.66,92.97) v12(99.82,158) v12(99.82,157.68) v12(99.82,157.37) v12(99.82,157.05) v12(99.82,156.4) v12(99.82,155.64) v12(99.76,126.75) v12(99.95,161.86) v12(99.95,161.16) v12(99.95,160.53) v12(99.95,159.83) v12(99.95,159.2) v12(99.95,158.56) v12(99.95,127.83) v12(100.14,158) v12(100.14,157.68) v12(100.14,157.37) v12(100.14,157.05) v12(100.06,152.49) v12(100.06,151.54) v12(100.06,150.52) v12(100.06,149.44) v12(100.06,148.43) v12(100.13,126.71) v12(100.52,161.16) v12(100.52,160.53) v12(100.52,159.83) v12(100.52,159.2) v12(100.52,158.56) v12(100.52,157.86) v12(100.52,157.23) v12(100.63,152.49) v12(100.63,151.54) v12(100.63,150.52) v12(100.63,149.44) v12(100.63,148.43) v12(100.84,165.22) v12(100.84,126.75) v12(100.86,127.83) v12(101.03,160.53) v12(101.03,159.83) v12(101.03,159.2) v12(101.03,158.56) v12(101.03,157.86) v12(101.03,157.23) v12(101.14,127.83) v12(101.22,152.49) v12(101.22,151.54) v12(101.22,150.52) v12(101.22,149.44) v12(101.22,148.43) v12(101.24,126.71) v12(101.4,157.49) v12(101.38,157.18) v12(101.4,156.86) v12(101.71,156.86) v12(101.78,152.49) v12(101.78,151.54) v12(101.78,150.52) v12(101.78,149.44) v12(101.78,148.43) v12(101.81,89.31) v12(102.03,126.71) v12(102.11,127.79) v12(102.35,152.49) v12(102.35,151.54) v12(102.35,150.52) v12(102.35,149.44) v12(102.35,148.43) v12(102.39,127.79) v12(102.41,126.68) v12(102.86,152.49) v12(102.86,151.54) v12(102.86,150.52) v12(102.86,149.44) v12(102.86,148.43) v12(102.99,165.18) v12(103.23,127.79) v12(103.28,126.71) v12(103.43,152.49) v12(103.43,151.54) v12(103.43,150.52) v12(103.43,149.44) v12(103.43,148.43) v12(103.5,127.79) v12(103.58,98.49) v12(103.58,97.6) v12(103.58,96.71) v12(103.71,126.68) v12(103.71,95.57) v12(103.71,94.68) v12(103.71,93.79) v12(103.71,90.2) v12(104.01,105.08) v12(104.2,92.84) v12(104.2,92.46) v12(104.65,165.18) v12(104.97,105.16) v12(105.46,100.99) v12(105.88,105.17) v12(106.08,164.39) v12(106.1,162.62) v12(106.15,160.35) v12(106.13,159.11) v12(106.13,158.47) v12(106.12,157.71) v12(106.11,156.97) v12(106.11,156.31) v12(106.39,100.99) v12(106.38,99.38) v12(106.46,155.84) v12(107.95,174.94) v12(107.95,173.42) v12(107.95,172.15) v12(108,170.68) v12(107.95,169.61) v12(108.13,168.01) v12(108.39,88.51) v12(108.7,88.51) v12(109.04,155.75) v12(109.58,165.09) v12(109.73,97.14) v12(109.73,96.14) v12(109.66,88.51) v12(109.91,170.07) v12(109.97,88.51) v12(111.21,141.14) v12(111.21,140.88) v12(111.21,140.63) v12(111.29,155.81) v12(111.25,146.31) v12(111.25,146.05) v12(111.25,145.8) v12(111.51,146.31) v12(111.51,146.05) v12(111.51,145.8) v12(111.47,141.14) v12(111.47,140.88) v12(111.47,140.63) v12(111.57,107.7) v12(111.57,107.32) v12(111.57,106.43) v12(111.57,106.05) v12(111.66,170.3) v12(111.72,141.14) v12(111.72,140.88) v12(111.72,140.63) v12(111.66,139.61) v12(111.66,139.36) v12(111.66,139.1) v12(111.66,138.22) v12(111.66,137.96) v12(111.66,137.71) v12(111.76,146.31) v12(111.76,146.05) v12(111.76,145.8) v12(111.84,122.75) v12(111.84,121.86) v12(111.84,120.97) v12(111.84,120.08) v12(111.91,139.61) v12(111.91,139.36) v12(111.91,139.1) v12(111.91,138.22) v12(111.91,137.96) v12(111.91,137.71) v12(112.01,146.31) v12(112.01,146.05) v12(112.01,145.8) v12(111.98,141.14) v12(111.98,140.88) v12(111.98,140.63) v12(113.11,155.75) v12(113.39,168.21) v12(113.39,167.64) v12(113.54,153.96) v12(113.46,147.84) v12(113.46,145.89) v12(113.46,143.6) v12(113.46,132.86) v12(113.54,93.16) v12(113.6,151.72) v12(113.55,149.34) v12(113.55,141.68) v12(113.6,139.53) v12(113.59,137.56) v12(113.6,135.46) v12(113.6,131.4) v12(113.61,129) v12(113.6,127.34) v12(113.63,125.46) v12(113.6,123.27) v12(113.61,116.79) v12(113.6,115.14) v12(113.63,113.2) v12(113.6,111.08) v12(113.59,109.2) v12(113.56,107.2) v12(113.56,105.14) v12(113.6,103.21) v12(113.59,100.53) v12(113.6,98.89) v12(113.61,96.62) v12(113.6,94.82) v12(113.67,86.68) v12(114.76,145.18) v12(114.9,176.96) v12(114.9,174.93) v12(114.9,172.9) v12(114.9,170.87) v12(114.9,165.01) v12(114.9,162.98) v12(114.9,160.95) v12(114.9,158.92) v12(114.9,156.88) v12(114.88,154.93) v12(114.9,150.5) v12(114.9,148.83) v12(114.9,146.8) v12(114.9,142.73) v12(114.9,140.7) v12(114.9,138.67) v12(114.9,136.64) v12(114.9,134.6) v12(114.94,132.37) v12(114.9,130.54) v12(114.9,128.51) v12(114.9,126.48) v12(114.9,124.56) v12(114.9,120.89) v12(114.9,108.19) v12(114.9,106.16) v12(114.9,104.12) v12(114.9,102.09) v12(114.92,100.43) v12(114.9,98.32) v12(114.97,168.84) v12(115,167.07) v12(114.99,150.94) v12(115.13,96.29) v12(115.74,152.02) v12(115.82,177.6) v12(115.96,176.56) v12(116.05,153.19) v12(116.31,146.29) v12(116.4,118.25) v12(116.59,146.29) v12(116.59,143.04) v12(116.87,146.29) v12(116.93,96.29) v12(117.17,177.6) v12(117.37,153.19) v12(117.49,176.56) v12(117.47,112.08) v12(117.47,111.19) v12(117.82,152) v12(119.01,176.56) v12(119,174.12) v12(119,172.72) v12(118.96,96.29) v12(119.1,153.19) v12(119.19,177.52) v12(119.29,150.8) v12(119.51,112.08) v12(119.51,111.19) v12(119.6,165.99) v12(119.89,164.72) v12(119.89,163.32) v12(119.89,162.69) v12(119.89,161.29) v12(119.89,160.66) v12(119.89,159.26) v12(119.89,158.62) v12(119.89,157.23) v12(119.89,156.59) v12(119.89,155.2) v12(119.98,173.93) v12(120.14,172.09) v12(120.14,170.69) v12(120.14,170.05) v12(120.14,168.66) v12(120.14,168.02) v12(120.14,166.63) v12(120.17,152.1) v12(120.54,176.56) v12(120.62,153.19) v12(120.99,96.29) v12(121.23,177.6) v12(121.54,112.08) v12(121.54,111.19) v12(121.55,97.92) v12(121.74,164.17) v12(121.74,156.12) v12(121.66,150.8) v12(121.95,152.1) v12(122.06,176.56) v12(122.15,153.19) v12(122.81,106.49) v12(122.81,105.6) v12(122.94,123.69) v12(122.89,105.04) v12(122.9,104.54) v12(122.99,98.13) v12(123.02,96.29) v12(123.27,177.6) v12(123.25,107.51) v12(123.25,106.49) v12(123.25,105.6) v12(123.33,105.04) v12(123.34,104.54) v12(123.34,98.13) v12(123.58,176.56) v12(123.62,135.96) v12(123.67,153.19) v12(123.7,150.8) v12(123.7,107.51) v12(123.7,106.49) v12(123.7,105.6) v12(123.83,123.69) v12(123.77,105.04) v12(123.79,104.54) v12(123.98,152.1) v12(124.09,164.17) v12(124.09,156.12) v12(124.08,131.71) v12(124.14,107.51) v12(124.14,106.49) v12(124.14,105.6) v12(124.22,105.04) v12(124.23,104.54) v12(124.59,107.51) v12(124.59,106.49) v12(124.59,105.6) v12(124.66,105.04) v12(124.68,104.54) v12(124.83,141.23) v12(124.97,131.71) v12(125.03,107.51) v12(125.03,106.49) v12(125.03,105.6) v12(125.11,176.56) v12(125.06,96.29) v12(125.2,153.19) v12(125.3,177.6) v12(125.35,166.98) v12(125.34,165.15) v12(125.34,164.56) v12(125.5,161.23) v12(125.48,107.51) v12(125.48,106.49) v12(125.48,105.6) v12(125.6,169.29) v12(125.73,150.8) v12(125.92,107.51) v12(125.92,106.49) v12(125.92,105.6) v12(126.02,168.34) v12(126.02,157.42) v12(126.02,156.78) v12(126.02,156.15) v12(126.02,155.51) v12(126.03,152.1) v12(126.11,167.27) v12(126.06,164.34) v12(126.1,160.59) v12(126.11,134.81) v12(126.23,153.19) v12(126.28,158.05) v12(126.36,169.06) v12(126.36,107.51) v12(126.36,106.49) v12(126.36,105.6) v12(126.5,173.85) v12(126.63,176.56) v12(126.57,158.82) v12(126.81,107.51) v12(126.81,106.49) v12(126.81,105.6) v12(127,168.34) v12(127,165.69) v12(127.03,93.97) v12(127.09,96.29) v12(127.21,134.06) v12(127.25,107.51) v12(127.25,106.49) v12(127.25,105.6) v12(127.46,177.61) v12(127.71,125.29) v12(127.7,107.51) v12(127.7,106.49) v12(127.7,105.6) v12(127.76,150.8) v12(128.14,107.51) v12(128.14,106.49) v12(128.14,105.6) v12(128.16,176.56) v12(128.59,107.51) v12(128.59,106.49) v12(128.59,105.6) v12(128.78,93.98) v12(129.03,107.51) v12(129.03,106.49) v12(129.03,105.6) v12(129.12,96.29) v12(129.18,177.42) v12(129.22,175.83) v12(129.21,173.8) v12(129.2,172.42) v12(129.2,169.88) v12(129.2,168.35) v12(129.2,165.81) v12(129.2,164.29) v12(129.2,161.75) v12(129.2,159.72) v12(129.2,157.91) v12(129.2,155.78) v12(129.2,152.1) v12(129.29,153.57) v12(129.48,107.51) v12(129.48,106.49) v12(129.48,105.6) v12(129.62,134.18) v12(129.79,150.8) v12(129.92,107.51) v12(129.92,106.49) v12(129.92,105.6) v12(129.97,108.08) v12(130.45,89.95) v12(130.56,114.37) v12(130.56,113.48) v12(130.56,112.97) v12(130.56,112.46) v12(130.56,111.95) v12(130.56,111.44) v12(130.56,110.94) v12(130.56,110.43) v12(130.56,109.92) v12(130.56,109.41) v12(130.56,108.9) v12(130.56,108.4) v12(130.56,107.89) v12(130.56,107.38) v12(130.56,106.87) v12(130.56,106.36) v12(130.81,115.25) v12(131.15,96.29) v12(131.32,115.25) v12(131.32,114.37) v12(131.32,113.48) v12(131.44,112.97) v12(131.44,112.46) v12(131.44,111.95) v12(131.44,111.44) v12(131.44,110.94) v12(131.44,110.43) v12(131.44,109.92) v12(131.44,109.41) v12(131.44,108.9) v12(131.44,108.4) v12(131.44,107.89) v12(131.44,107.38) v12(131.44,106.87) v12(131.44,106.36) v12(131.82,150.8) v12(132.08,115.25) v12(132.08,114.37) v12(132.08,113.48) v12(132.33,112.97) v12(132.33,112.46) v12(132.33,111.95) v12(132.33,111.44) v12(132.33,110.94) v12(132.33,110.43) v12(132.33,109.92) v12(132.33,109.41) v12(132.33,108.9) v12(132.33,108.4) v12(132.33,107.89) v12(132.33,107.38) v12(132.33,106.87) v12(132.33,106.36) v12(132.97,115.25) v12(132.97,114.37) v12(132.97,113.48) v12(133.18,96.29) v12(133.6,115.25) v12(133.6,114.37) v12(133.6,113.48) v12(133.86,150.8) v12(134.24,115.25) v12(134.24,114.37) v12(134.24,113.48) v12(134.87,115.25) v12(134.87,114.37) v12(134.87,113.48) v12(134.98,94.43) v12(135.22,96.29) v12(135.51,115.25) v12(135.51,114.37) v12(135.51,113.48) v12(135.57,135.77) v12(135.89,150.8) v12(135.95,140.64) v12(136.14,115.25) v12(136.14,114.37) v12(136.14,113.48) v12(136.54,94.39) v12(136.87,137.67) v12(137.25,96.29) v12(137.92,150.8) v12(138.3,137.53) v12(139,122.94) v12(139.22,137.5) v12(139.28,96.29) v12(139.38,122.94) v12(139.95,150.8) v12(140.21,97.92) v12(140.27,122.94) v12(140.65,122.94) v12(141.31,96.29) v12(141.54,122.94) v12(141.92,122.94) v12(141.98,150.8) v12(142.48,113.01) v12(142.48,110.98) v12(142.48,108.95) v12(142.48,106.92) v12(142.48,104.88) v12(142.48,102.85) v12(142.48,100.82) v12(142.48,98.79) v12(142.82,140.91) v12(142.81,122.94) v12(142.9,93.13) v12(143.11,115) v12(143.19,122.94) v12(143.31,93.13) v12(143.31,88.89) v12(143.33,88.58) v12(143.39,148.63) v12(143.61,88.89) v12(143.66,88.56) v12(143.76,93.13) v12(143.94,88.91) v12(143.99,88.56) v12(144.08,122.94) v12(144.4,146.94) v12(144.46,122.94) v12(145.1,131.4) v12(145.1,128.6) v12(145.14,115) v12(145.27,132.59) v12(145.34,89.3) v12(145.42,145.11) v12(145.41,122.7) v12(146.44,143.5) v12(146.57,134.49) v12(146.76,91.73) v12(147,130.1) v12(147,127.3) v12(147.18,119.19) v12(147.17,115) v12(147.29,91.76) v12(147.45,141.59) v12(147.68,91.76) v12(148.42,139.84) v12(148.51,124.14) v12(149.2,115) v12(149.48,138.07) v12(149.59,123.06) v12(150,119.69) v12(150.52,136.27) v12(151.23,115) v12(151.52,134.55) v12(151.97,142.14) v12(152.07,127.2) v12(152.5,132.77) v12(152.63,121.74) v12(152.69,123.8) v12(153.27,115) v12(153.67,137.72) v12(154.02,131.35) v12(154.69,127.4) v12(154.74,126.41) v12(155.3,115) v12(155.52,134.56) v12(155.89,131.34) v12(157.29,123.76) v12(157.68,114.95) v12(158.09,131.35) v12(159.3,138.86) v12(159.4,133.26) v12(160.16,131.34) v12(160.17,114.95) v12(161.91,128.41) v12(162,130.28) v12(162,126.21) v12(161.99,124.27) v12(162,122.66) v12(162,117.83) v12(162,115.11) v12(162.06,120.3) v13(5.65,141.31) v13(8.06,36.64) v13(8.45,137.01) v13(9.14,147.84) v13(9.46,24.96) v13(9.58,39.14) v13(9.56,27.56) v13(9.56,26.93) v13(9.56,26.29) v13(9.56,25.66) v13(9.68,41.55) v13(9.68,40.98) v13(9.68,40.41) v13(9.68,39.84) v13(9.79,162.24) v13(9.91,147.42) v13(10.16,162.66) v13(10.43,138.14) v13(10.53,162.24) v13(10.64,142.47) v13(10.64,141.97) v13(10.9,49.11) v13(10.9,47.08) v13(10.9,45.05) v13(10.9,37.08) v13(10.9,35.05) v13(10.9,33.02) v13(10.9,30.99) v13(10.9,22.86) v13(10.9,20.83) v13(10.9,18.8) v13(10.9,16.76) v13(10.96,50.64) v13(11.95,16.15) v13(12.22,17.54) v13(12.45,48.33) v13(12.62,24.59) v13(12.62,23.19) v13(12.7,42.93) v13(12.7,41.53) v13(12.7,40.9) v13(12.7,39.5) v13(12.73,28.78) v13(12.73,27.38) v13(12.8,21.53) v13(12.99,50.64) v13(13.15,162.24) v13(13.53,162.65) v13(13.9,162.24) v13(13.97,38.99) v13(13.97,37.59) v13(14.03,20.07) v13(14.03,18.67) v13(13.98,16.15) v13(14.1,36.58) v13(14.1,35.18) v13(14.43,22.01) v13(14.48,46.72) v13(14.61,33.25) v13(15.05,107.37) v13(15.04,105.34) v13(15.02,50.64) v13(15.1,143.44) v13(15.1,141.4) v13(15.1,139.37) v13(15.1,137.34) v13(15.1,135.31) v13(15.07,133.14) v13(15.1,128.13) v13(15.1,126.09) v13(15.1,124.06) v13(15.1,122.03) v13(15.1,120) v13(15.1,117.97) v13(15.1,115.93) v13(15.1,113.48) v13(15.1,111.44) v13(15.1,103.32) v13(15.1,101.28) v13(15.1,99.25) v13(15.1,97.22) v13(15.1,95.19) v13(15.1,93.16) v13(15.1,91.12) v13(15.11,44.57) v13(15.16,131.46) v13(15.27,130.15) v13(15.62,89.85) v13(15.6,71.95) v13(15.63,70.03) v13(15.6,67.89) v13(15.61,65.74) v13(15.6,63.83) v13(15.6,61.79) v13(15.6,60.27) v13(15.6,57.73) v13(15.6,55.19) v13(15.6,53.67) v13(15.6,51.63) v13(15.62,36.56) v13(15.93,17.51) v13(16,16.24) v13(16.36,131.45) v13(16.38,122.77) v13(16.37,113.41) v13(16.38,111.83) v13(16.54,132.55) v13(16.51,127.75) v13(16.51,127.5) v13(16.5,91.05) v13(16.61,97.68) v13(16.71,144.74) v13(16.7,126.68) v13(16.7,102.41) v13(16.66,86.96) v13(16.66,84.9) v13(16.69,77.84) v13(16.78,33.59) v13(16.92,69.33) v13(17.02,73.39) v13(17.04,51.14) v13(17.14,58.13) v13(17.07,28.51) v13(17.14,27.67) v13(17.14,26.23) v13(17.22,64.81) v13(17.3,130.15) v13(17.32,22.16) v13(17.37,138.77) v13(17.4,137.66) v13(17.48,124.33) v13(17.48,110.94) v13(17.51,71.95) v13(17.55,141.59) v13(17.55,123.64) v13(17.73,134.48) v13(17.68,91.06) v13(17.78,45.86) v13(18.03,113.1) v13(18.04,16.15) v13(18.08,110.94) v13(18.21,95.85) v13(18.26,114.87) v13(18.34,114.49) v13(18.39,131.45) v13(18.41,124.45) v13(18.41,38.61) v13(18.41,37.21) v13(18.41,24.39) v13(18.41,22.99) v13(18.62,119.62) v13(18.6,103.71) v13(18.69,132.63) v13(18.67,117.29) v13(18.67,45.86) v13(18.8,35.84) v13(18.76,35.24) v13(18.8,33.16) v13(18.86,127.4) v13(18.96,91.05) v13(19.01,56.71) v13(19.13,77.15) v13(19.1,63.57) v13(19.34,130.15) v13(19.32,106.02) v13(19.3,94.81) v13(19.39,20.77) v13(19.55,105.4) v13(19.51,99.98) v13(19.54,71.95) v13(19.46,45.32) v13(19.6,21.4) v13(19.7,139.46) v13(19.72,32.81) v13(19.68,31.38) v13(19.76,99.95) v13(19.81,89.68) v13(20.02,125.1) v13(19.96,122.57) v13(19.96,122.26) v13(20.04,53.07) v13(20.07,86.3) v13(20.07,16.15) v13(20.19,66.07) v13(20.19,65.38) v13(20.45,141.47) v13(20.43,131.45) v13(20.57,139.46) v13(20.61,35.24) v13(20.57,30.47) v13(20.92,91.05) v13(21.01,42.33) v13(21.01,40.83) v13(21.01,39.46) v13(20.98,38.09) v13(21.12,135.92) v13(21.11,49.6) v13(21.11,48.68) v13(21.13,27.88) v13(21.13,26.51) v13(21.13,25.13) v13(21.13,23.76) v13(21.21,141.76) v13(21.22,59.22) v13(21.25,20.77) v13(21.27,60.9) v13(21.27,60.01) v13(21.37,130.15) v13(21.46,139.46) v13(21.62,106.62) v13(21.57,71.95) v13(21.59,62.39) v13(21.75,95.36) v13(22.02,86.3) v13(22.11,16.15) v13(22.42,127.45) v13(22.54,58.19) v13(22.56,90.34) v13(22.74,57.04) v13(22.86,31.09) v13(22.96,91.05) v13(23.04,72.76) v13(23.1,72.02) v13(23.11,34.82) v13(23.18,156.25) v13(23.16,122.34) v13(23.24,42.36) v13(23.19,40.83) v13(23.19,39.46) v13(23.24,38.09) v13(23.32,86.77) v13(23.28,45.53) v13(23.29,27.88) v13(23.29,26.51) v13(23.29,25.13) v13(23.29,23.76) v13(23.37,135.9) v13(23.4,130.15) v13(23.55,17.36) v13(23.62,106.03) v13(23.57,54.19) v13(23.75,138.8) v13(23.88,20.47) v13(24.13,124.07) v13(24.13,59.12) v13(24.14,16.15) v13(24.19,103.84) v13(24.23,85.88) v13(24.23,84.99) v13(24.23,84) v13(24.43,106.11) v13(24.49,131.45) v13(24.5,128.71) v13(24.54,127.07) v13(24.52,126.05) v13(24.69,141.8) v13(24.73,111.2) v13(24.79,104.71) v13(24.94,123.32) v13(24.98,142.56) v13(25.02,121.64) v13(25.02,91.06) v13(25.21,156.25) v13(25.35,134) v13(25.35,132.63) v13(25.32,73.12) v13(25.44,139.77) v13(25.41,30) v13(25.49,70.49) v13(25.5,20.82) v13(25.6,137.23) v13(25.64,71.95) v13(25.78,46.1) v13(25.97,102.92) v13(26.1,121.55) v13(26.13,74.51) v13(26.53,95.01) v13(26.45,39.05) v13(26.68,49.77) v13(26.68,16.15) v13(26.96,142.56) v13(27.13,112.8) v13(27.05,103.01) v13(27.24,156.41) v13(27.17,71.99) v13(27.19,30) v13(27.38,141.8) v13(27.41,124.4) v13(27.53,132.86) v13(27.55,130.17) v13(27.52,19.41) v13(27.56,105.73) v13(27.57,49.77) v13(27.76,24.7) v13(28.14,82.49) v13(28.12,44.97) v13(28.24,66.94) v13(28.24,66.05) v13(28.19,31.76) v13(28.24,18.1) v13(28.2,16.15) v13(28.4,122.77) v13(28.63,68.65) v13(28.57,49.75) v13(28.7,135.65) v13(28.83,139.93) v13(28.84,95.26) v13(28.85,131.43) v13(29.08,97.19) v13(29.11,36.23) v13(29.27,156.25) v13(29.4,161.67) v13(29.5,130.15) v13(29.51,71.95) v13(29.54,21.5) v13(29.59,124.91) v13(29.72,141.76) v13(29.77,91.05) v13(29.9,52.74) v13(30.02,136.84) v13(30.02,135.96) v13(30.1,147.31) v13(30.13,123.3) v13(30.1,45.33) v13(30.18,161.66) v13(30.2,74.59) v13(30.21,61.65) v13(30.23,16.15) v13(30.25,132.93) v13(30.26,120.63) v13(30.33,118.4) v13(30.33,112.8) v13(30.3,106.07) v13(30.34,67.57) v13(30.34,65.47) v13(30.34,64.58) v13(30.34,63.69) v13(30.34,62.8) v13(30.25,37.07) v13(30.4,141.7) v13(30.63,66.82) v13(30.63,66.23) v13(30.61,25.44) v13(30.66,73.47) v13(30.73,50.26) v13(30.96,161.66) v13(30.98,160.08) v13(31.04,146.85) v13(31.04,124.08) v13(31.05,47.26) v13(30.99,45.33) v13(31.04,30.24) v13(31.16,105.75) v13(31.19,56.12) v13(31.3,156.25) v13(31.27,145.9) v13(31.34,32.96) v13(31.45,104.05) v13(31.5,37.1) v13(31.64,160.85) v13(31.65,133.31) v13(31.59,130.16) v13(31.74,161.66) v13(31.73,71.95) v13(31.67,31.43) v13(31.81,59.97) v13(31.88,48.27) v13(32.01,120.64) v13(31.95,99.51) v13(32.19,145.86) v13(32.18,126.89) v13(32.27,16.15) v13(32.51,145.67) v13(32.64,160.85) v13(32.56,111.47) v13(32.64,108.19) v13(32.68,161.65) v13(32.79,131.46) v13(32.83,122.61) v13(32.79,24.73) v13(32.89,20.56) v13(33.03,107.76) v13(32.99,53.02) v13(33.12,112.49) v13(33.19,67.34) v13(33.19,62.33) v13(33.34,156.25) v13(33.3,121.17) v13(33.38,128.59) v13(33.38,128.26) v13(33.35,81.62) v13(33.35,17.9) v13(33.5,114.06) v13(33.64,160.85) v13(33.59,142.97) v13(33.61,135.98) v13(33.59,89.93) v13(33.6,87.64) v13(33.6,85.61) v13(33.62,83.26) v13(33.66,116.14) v13(33.71,114.24) v13(33.66,100.89) v13(33.77,122.68) v13(33.77,71.95) v13(33.87,121.17) v13(34.11,73.52) v13(34.23,82.55) v13(34.21,75.25) v13(34.3,16.15) v13(34.54,66.36) v13(34.62,34.91) v13(34.75,112.69) v13(34.69,65.84) v13(34.77,121.07) v13(34.77,120.79) v13(34.85,95.95) v13(34.87,30.34) v13(34.92,26.18) v13(35.05,58.42) v13(35.06,56.52) v13(35.19,65.84) v13(35.19,65.34) v13(35.19,64.84) v13(35.19,64.33) v13(35.31,66.36) v13(35.36,156.25) v13(35.53,154.24) v13(35.59,130.15) v13(35.56,97.35) v13(35.63,77.01) v13(35.74,152.08) v13(35.69,128.66) v13(35.71,128.39) v13(35.69,108.7) v13(35.66,108.4) v13(35.69,64.84) v13(35.69,64.33) v13(35.8,71.95) v13(35.89,162.07) v13(35.94,69.84) v13(35.94,66.36) v13(35.94,56.52) v13(35.98,163.06) v13(36.02,31.61) v13(36.13,77.01) v13(36.25,154.01) v13(36.19,64.84) v13(36.19,64.33) v13(36.27,82.55) v13(36.33,16.22) v13(36.45,166.08) v13(36.45,161.67) v13(36.55,162.69) v13(36.69,163.46) v13(36.73,154.95) v13(36.7,66.36) v13(36.69,64.84) v13(36.69,64.33) v13(36.69,63.83) v13(36.69,62.83) v13(36.8,131.48) v13(36.83,56.52) v13(37.15,164.01) v13(37.08,65.72) v13(37.08,65.22) v13(37.08,64.58) v13(37.08,64.07) v13(37.16,166.68) v13(37.19,161.93) v13(37.24,152.52) v13(37.26,149.93) v13(37.27,148.16) v13(37.34,137) v13(37.29,136.11) v13(37.29,135.24) v13(37.29,134.35) v13(37.41,167.46) v13(37.43,163.06) v13(37.44,70.74) v13(37.52,158.05) v13(37.54,155.01) v13(37.49,88.63) v13(37.49,77.76) v13(37.55,163.65) v13(37.55,158.92) v13(37.63,156.94) v13(37.63,74.51) v13(37.59,56.94) v13(37.69,164.52) v13(37.71,162.46) v13(37.67,118.48) v13(37.73,91.77) v13(37.8,161.66) v13(37.81,160.78) v13(37.8,159.81) v13(37.78,94.82) v13(37.92,156.22) v13(37.87,124.47) v13(37.95,75.93) v13(37.9,19.37) v13(38.02,163.29) v13(37.97,106.75) v13(38.02,90.74) v13(38.1,111.19) v13(38.2,165.05) v13(38.23,113.65) v13(38.15,23.56) v13(38.15,22.67) v13(38.2,17.9) v13(38.43,163.73) v13(38.38,162.97) v13(38.38,162.31) v13(38.36,16.15) v13(38.76,33.54) v13(38.81,27.83) v13(38.94,167.46) v13(38.94,162.56) v13(38.93,161.61) v13(38.89,131.46) v13(38.86,59.68) v13(38.98,160.73) v13(39.03,159.63) v13(39.04,158.32) v13(39.01,157.19) v13(39.12,130.24) v13(39.12,52.59) v13(39.24,163.98) v13(39.27,93.29) v13(39.27,73.45) v13(39.4,155.83) v13(39.4,153.8) v13(39.4,151.77) v13(39.4,149.73) v13(39.4,143.64) v13(39.39,139.62) v13(39.4,135.51) v13(39.4,128.75) v13(39.4,126.79) v13(39.37,54.1) v13(39.53,147.64) v13(39.46,141.15) v13(39.62,165.77) v13(39.93,124.68) v13(39.93,31.59) v13(40.33,82.55) v13(40.28,36.08) v13(40.39,16.15) v13(40.46,167.46) v13(40.59,136.81) v13(40.58,67.95) v13(40.65,165.38) v13(40.7,163.06) v13(40.7,161.02) v13(40.7,158.99) v13(40.7,156.96) v13(40.68,154.47) v13(40.7,152.9) v13(40.7,150.86) v13(40.7,148.83) v13(40.7,144.77) v13(40.7,140.56) v13(40.7,125.96) v13(40.7,123.93) v13(40.7,121.89) v13(40.7,119.86) v13(40.7,117.83) v13(40.7,115.47) v13(40.7,113.77) v13(40.7,94.8) v13(40.84,133.97) v13(40.84,132.04) v13(40.84,130.01) v13(40.79,98.41) v13(40.94,51.75) v13(41.24,141.53) v13(41.35,64.84) v13(41.35,62.8) v13(41.35,61.79) v13(41.48,109.75) v13(41.48,97.58) v13(41.5,20.87) v13(41.62,165.79) v13(41.66,55.78) v13(41.91,108.45) v13(41.99,167.46) v13(42.01,24.14) v13(42.1,74.56) v13(42.25,142.85) v13(42.36,82.55) v13(42.43,16.15) v13(42.49,158.59) v13(42.64,141.55) v13(42.72,155.79) v13(42.72,18.38) v13(42.85,32.37) v13(42.8,29.25) v13(42.98,34.56) v13(43.14,165.79) v13(43.24,67.71) v13(43.26,64.84) v13(43.51,167.46) v13(43.61,151.75) v13(43.81,117.31) v13(43.85,92.36) v13(43.94,108.45) v13(43.93,71.95) v13(44.09,84.11) v13(44.17,158.43) v13(44.2,156) v13(44.28,142.85) v13(44.39,82.55) v13(44.48,149.98) v13(44.45,74.78) v13(44.46,16.15) v13(44.67,165.79) v13(44.68,141.55) v13(44.75,127.53) v13(44.75,122.53) v13(44.79,102.25) v13(44.78,101.91) v13(44.88,117.35) v13(44.86,101.2) v13(45.03,167.46) v13(44.98,41.95) v13(45.11,70.12) v13(45.15,67.82) v13(45.15,65.79) v13(45.05,63.95) v13(45.15,61.72) v13(45.05,59.89) v13(45.15,57.66) v13(45.05,55.82) v13(45.14,53.89) v13(45.07,51.65) v13(45.05,47.69) v13(45.05,45.45) v13(45.05,43.63) v13(45.09,39.85) v13(45.05,35.5) v13(45.05,33.47) v13(45.05,31.44) v13(45.05,29.41) v13(45.05,27.37) v13(45.05,25.34) v13(45.05,23.31) v13(45.06,21.64) v13(45.05,19.25) v13(45.14,17.6) v13(45.36,109.75) v13(45.67,158.56) v13(45.72,74.78) v13(45.91,119.3) v13(45.98,108.45) v13(46.15,98.31) v13(46.15,91.81) v13(46.1,86.93) v13(46.19,165.79) v13(46.23,79.37) v13(46.31,142.85) v13(46.29,138.95) v13(46.27,39.71) v13(46.35,37.14) v13(46.35,12.76) v13(46.35,10.73) v13(46.35,8.69) v13(46.38,149.95) v13(46.43,82.55) v13(46.4,35.1) v13(46.4,33.06) v13(46.4,31.03) v13(46.4,29) v13(46.4,26.97) v13(46.4,22.9) v13(46.4,20.87) v13(46.4,18.84) v13(46.4,16.81) v13(46.35,14.63) v13(46.56,167.46) v13(46.71,141.55) v13(46.81,41.34) v13(46.99,148.35) v13(47.4,109.75) v13(47.6,158.51) v13(47.71,165.79) v13(48.01,108.45) v13(47.96,26.61) v13(47.98,11.37) v13(48.08,167.46) v13(48.34,142.85) v13(48.29,29.38) v13(48.31,7.95) v13(48.41,127.4) v13(48.46,82.55) v13(48.54,22.47) v13(48.65,97.31) v13(48.74,141.55) v13(48.72,36.51) v13(48.74,33.52) v13(48.84,20.89) v13(48.97,39.03) v13(49.24,165.79) v13(49.19,135.65) v13(49.35,158.71) v13(49.43,109.75) v13(49.53,163.78) v13(49.61,167.46) v13(49.63,157.42) v13(50.04,160.01) v13(49.96,131.76) v13(50.04,108.45) v13(50.34,7.95) v13(50.37,142.85) v13(50.36,121.48) v13(50.36,120.21) v13(50.44,59.86) v13(50.41,41.35) v13(50.47,100.61) v13(50.62,55.82) v13(50.63,16.19) v13(50.76,165.79) v13(50.77,141.55) v13(50.83,9.67) v13(50.93,36.62) v13(50.93,33.8) v13(50.9,29.76) v13(50.95,145.86) v13(51.13,167.46) v13(51.08,144.41) v13(51.08,18.99) v13(51.44,87.44) v13(51.46,109.75) v13(51.49,89.73) v13(51.49,85.16) v13(51.82,102.85) v13(52.03,117.41) v13(52.07,108.45) v13(52.2,106.94) v13(52.18,106.59) v13(52.29,165.79) v13(52.27,19.75) v13(52.41,142.85) v13(52.37,7.95) v13(52.5,137.53) v13(52.52,82.55) v13(52.5,52.08) v13(52.58,127.8) v13(52.65,167.46) v13(52.68,91) v13(52.8,141.55) v13(52.83,136.3) v13(53.26,157.9) v13(53.26,60.49) v13(53.34,23.38) v13(53.49,109.75) v13(53.54,55.44) v13(53.52,25.27) v13(53.47,13.36) v13(53.47,12.68) v13(53.64,155.96) v13(53.63,15.6) v13(53.64,10.45) v13(53.75,39.26) v13(53.75,34.66) v13(53.81,165.79) v13(53.85,41.34) v13(53.9,149.51) v13(53.91,146.75) v13(53.91,146.45) v13(53.87,36.72) v13(54.01,108.47) v13(54.06,142.83) v13(54.18,167.46) v13(54.19,159.58) v13(54.19,156.99) v13(54.22,146.75) v13(54.22,146.45) v13(54.15,130.14) v13(54.15,123.13) v13(54.15,122.24) v13(54.23,13.36) v13(54.23,12.68) v13(54.28,157.98) v13(54.36,154.04) v13(54.44,7.95) v13(54.58,141.62) v13(54.55,82.55) v13(54.66,151.09) v13(54.74,19.5) v13(54.74,19.12) v13(54.8,18.29) v13(54.8,17.34) v13(55.13,19.1) v13(55.13,17.6) v13(55.13,17.1) v13(55.33,165.79) v13(55.37,19.5) v13(55.63,19.1) v13(55.63,18.6) v13(55.63,18.1) v13(55.63,17.6) v13(55.7,167.46) v13(55.75,88.79) v13(55.77,86.11) v13(55.95,158.48) v13(55.94,156.72) v13(55.88,19.5) v13(55.96,96.13) v13(55.96,94.58) v13(56.1,134.81) v13(56.1,133.54) v13(56.11,109.82) v13(56.14,108.45) v13(56.08,93.61) v13(56.13,19.1) v13(56.13,18.6) v13(56.13,18.1) v13(56.13,17.6) v13(56.39,25.29) v13(56.39,23.38) v13(56.39,19.5) v13(56.44,7.95) v13(56.47,142.85) v13(56.53,124.06) v13(56.62,82.55) v13(56.55,41.33) v13(56.63,19.1) v13(56.63,18.6) v13(56.63,18.1) v13(56.63,17.6) v13(56.86,165.79) v13(56.87,141.55) v13(56.9,19.5) v13(57.13,19.1) v13(57.23,167.46) v13(57.29,124.06) v13(57.34,19.5) v13(57.4,129.15) v13(57.43,108.43) v13(57.53,143.91) v13(57.56,109.75) v13(57.81,100.52) v13(57.81,10.5) v13(58.13,19.1) v13(58.29,124.37) v13(58.38,165.79) v13(58.42,121.95) v13(58.42,23.38) v13(58.5,142.85) v13(58.55,126.23) v13(58.47,7.95) v13(58.62,82.55) v13(58.6,41.23) v13(58.63,15.6) v13(58.66,156.26) v13(58.66,154.17) v13(58.66,152.07) v13(58.75,167.46) v13(58.9,141.55) v13(59,144.39) v13(59.33,142.84) v13(59.3,108.46) v13(59.44,23.38) v13(59.64,113.02) v13(59.77,129.1) v13(59.91,165.79) v13(59.9,106.93) v13(59.9,104.9) v13(59.9,103.22) v13(59.9,100.83) v13(59.9,98.8) v13(59.9,96.77) v13(59.9,94.74) v13(59.9,92.71) v13(59.94,89.85) v13(59.9,88.64) v13(59.9,86.61) v13(59.9,84.58) v13(59.9,82.55) v13(60.15,41.34) v13(60.27,167.46) v13(60.33,123.47) v13(60.53,142.85) v13(60.5,7.95) v13(60.58,143.93) v13(60.76,156.26) v13(60.76,154.17) v13(60.76,152.07) v13(60.93,141.55) v13(60.88,129.86) v13(61.01,92.83) v13(60.96,92.14) v13(61.01,69.69) v13(61.09,10.5) v13(61.2,107.94) v13(61.19,105.13) v13(61.2,103.88) v13(61.2,99.81) v13(61.2,97.78) v13(61.19,95.82) v13(61.2,89.37) v13(61.2,87.62) v13(61.43,165.79) v13(61.39,113.35) v13(61.47,131.43) v13(61.57,35.75) v13(61.8,167.46) v13(61.79,87.17) v13(61.8,85.27) v13(61.82,57.77) v13(61.87,55.16) v13(62.08,62.93) v13(62.13,46.62) v13(62.18,43.14) v13(62.36,51.02) v13(62.48,142.69) v13(62.53,37.23) v13(62.53,17.21) v13(62.53,7.95) v13(62.61,112.51) v13(62.56,21.9) v13(62.74,128.92) v13(62.81,67.35) v13(62.85,156.26) v13(62.85,154.17) v13(62.85,152.07) v13(62.95,165.79) v13(62.96,141.55) v13(63.02,58.92) v13(62.99,53.23) v13(62.97,44.82) v13(63.23,123.13) v13(63.25,77.76) v13(63.22,56.4) v13(63.2,48.73) v13(63.32,167.46) v13(63.42,144.25) v13(63.52,138.84) v13(63.5,79.87) v13(63.75,112.51) v13(63.91,121.4) v13(64.31,87.21) v13(64.31,58.03) v13(64.26,54.88) v13(64.26,16.61) v13(64.39,127.84) v13(64.44,71.69) v13(64.48,165.79) v13(64.49,149.85) v13(64.49,149.47) v13(64.52,65.7) v13(64.49,60.8) v13(64.47,50.46) v13(64.6,142.85) v13(64.57,46.88) v13(64.63,41.35) v13(64.56,7.95) v13(64.74,63.26) v13(64.85,167.46) v13(64.77,112.51) v13(64.8,40.12) v13(64.95,145.71) v13(64.95,72.89) v13(65,144.29) v13(65,141.55) v13(65.23,10.53) v13(65.39,129.73) v13(65.41,43.32) v13(65.48,23.84) v13(65.66,128.42) v13(65.85,121.74) v13(65.79,112.51) v13(65.94,22.44) v13(66,165.79) v13(65.99,134.99) v13(65.99,125.48) v13(66.12,131.83) v13(66.15,121.74) v13(66.21,87.21) v13(66.32,158.61) v13(66.32,153.79) v13(66.32,152.92) v13(66.32,151.98) v13(66.32,150.21) v13(66.37,167.46) v13(66.42,151.2) v13(66.45,148.93) v13(66.36,132.91) v13(66.37,120.46) v13(66.38,41.33) v13(66.51,134.47) v13(66.51,134.16) v13(66.53,133.89) v13(66.47,121.74) v13(66.48,115.55) v13(66.63,142.85) v13(66.6,7.95) v13(66.7,126.48) v13(66.8,113.01) v13(66.87,159.17) v13(66.89,135.81) v13(66.89,135.39) v13(66.9,132.73) v13(67.03,141.55) v13(67.11,152.49) v13(67.11,150.03) v13(67.21,132.75) v13(67.21,131.64) v13(67.23,131.05) v13(67.23,130.49) v13(67.21,40.12) v13(67.32,158.36) v13(67.26,129.91) v13(67.28,15.24) v13(67.39,151.2) v13(67.4,129.07) v13(67.4,128.66) v13(67.4,127.93) v13(67.4,127.52) v13(67.53,165.79) v13(67.48,125.25) v13(67.48,124.94) v13(67.48,124.63) v13(67.56,47.36) v13(67.59,9.95) v13(67.72,123.81) v13(67.74,123.23) v13(67.74,122.67) v13(67.84,162.75) v13(67.84,162.37) v13(67.85,159.68) v13(67.79,148.83) v13(67.89,167.46) v13(67.94,150) v13(68.02,116.91) v13(67.97,28.42) v13(68.05,26.05) v13(68.06,159.21) v13(68.1,155.79) v13(68.1,154.91) v13(68.1,153.4) v13(68.1,152.41) v13(68.19,162.75) v13(68.19,162.37) v13(68.22,158.51) v13(68.19,138.51) v13(68.24,87.21) v13(68.48,151.17) v13(68.45,73.37) v13(68.5,45.3) v13(68.5,41.3) v13(68.45,38.11) v13(68.63,7.95) v13(68.73,149.98) v13(68.71,148.73) v13(68.66,142.85) v13(68.73,70.14) v13(68.78,76.16) v13(68.91,162.92) v13(68.91,162.61) v13(68.91,157.96) v13(69.05,165.79) v13(68.98,154.96) v13(68.96,152.49) v13(69.14,153.38) v13(69.06,141.55) v13(69.33,120.23) v13(69.34,38.11) v13(69.42,167.46) v13(69.37,162.92) v13(69.37,162.61) v13(69.43,66.95) v13(69.57,151.2) v13(69.62,117.71) v13(69.57,43.96) v13(69.72,149.98) v13(69.72,148.76) v13(69.91,113.88) v13(70.03,120.03) v13(69.98,9.87) v13(70.13,154.09) v13(70.1,78.7) v13(70.18,157.96) v13(70.15,153.35) v13(70.18,152.47) v13(70.15,117.69) v13(70.31,151.12) v13(70.27,87.21) v13(70.45,99.07) v13(70.46,57.77) v13(70.57,165.79) v13(70.59,150) v13(70.56,148.88) v13(70.69,142.85) v13(70.74,127.19) v13(70.74,126.05) v13(70.74,25.9) v13(70.68,16.7) v13(70.74,7.95) v13(70.79,128.34) v13(70.76,127.75) v13(70.76,126.61) v13(70.76,125.46) v13(70.82,124.91) v13(70.76,124.3) v13(70.76,123.74) v13(70.78,121.79) v13(70.78,121.49) v13(70.78,121.17) v13(70.85,101.02) v13(70.76,42.94) v13(70.94,167.46) v13(70.94,117.59) v13(71.09,123.18) v13(71.09,122.62) v13(71.07,41.35) v13(71.07,29.28) v13(71.07,28.39) v13(71.25,120.03) v13(71.25,19.17) v13(71.35,148.91) v13(71.33,99.96) v13(71.33,99.07) v13(71.32,97.22) v13(71.27,54.62) v13(71.4,153.28) v13(71.4,152.41) v13(71.42,151.12) v13(71.37,149.95) v13(71.37,96.13) v13(71.38,91.89) v13(71.45,157.96) v13(71.5,154.09) v13(71.48,122.06) v13(71.5,121.48) v13(71.53,120.84) v13(71.58,135.62) v13(71.75,28.03) v13(71.86,135.62) v13(71.91,129.05) v13(71.93,120.03) v13(71.92,95.04) v13(71.92,94.15) v13(71.92,93.26) v13(71.87,90.74) v13(71.91,60.06) v13(71.93,12.54) v13(72.1,165.79) v13(72.12,9.32) v13(72.31,87.21) v13(72.36,15.94) v13(72.47,167.46) v13(72.54,153.28) v13(72.54,135.57) v13(72.5,67.05) v13(72.64,154.09) v13(72.57,137.53) v13(72.56,135.87) v13(72.62,131.66) v13(72.57,130.93) v13(72.57,130.34) v13(72.72,157.96) v13(72.69,152.49) v13(72.73,142.85) v13(72.67,133.16) v13(72.72,120.16) v13(72.72,119.57) v13(72.82,135.88) v13(72.82,135.57) v13(72.8,118.38) v13(72.77,50.92) v13(72.92,137.53) v13(72.99,115) v13(73.03,26.3) v13(73.1,135.88) v13(73.13,135.57) v13(73.2,47.66) v13(73.36,118.38) v13(73.49,41.34) v13(73.48,35.68) v13(73.48,30.55) v13(73.51,28.56) v13(73.62,165.79) v13(73.59,10.81) v13(73.94,154.07) v13(73.91,153.23) v13(73.91,118.35) v13(73.91,26.3) v13(73.91,17.18) v13(73.99,167.46) v13(73.99,157.96) v13(74.04,111.76) v13(74.12,152.39) v13(74.14,148.99) v13(74.09,27.88) v13(74.22,151.25) v13(74.17,150) v13(74.34,87.21) v13(74.45,118.38) v13(74.44,90.29) v13(74.76,142.85) v13(74.8,19.17) v13(74.85,39.79) v13(74.96,154.09) v13(75.02,127.69) v13(75.02,127.28) v13(75.01,126.42) v13(75.01,126.01) v13(74.99,125.07) v13(74.99,124.77) v13(74.99,124.45) v13(75.01,122.31) v13(75.01,121.9) v13(75.03,15.33) v13(75.04,12.22) v13(75.15,165.79) v13(75.06,123.58) v13(75.06,123.17) v13(75.06,118.38) v13(75.14,41.35) v13(75.23,67.05) v13(75.26,157.96) v13(75.26,148.05) v13(75.3,34.79) v13(75.3,33.9) v13(75.3,33.01) v13(75.39,148.99) v13(75.36,121.22) v13(75.36,120.72) v13(75.51,167.46) v13(75.51,37.46) v13(75.51,36.57) v13(75.65,126.42) v13(75.65,126.01) v13(75.65,122.31) v13(75.65,121.9) v13(75.64,118.38) v13(75.63,105.93) v13(75.7,127.67) v13(75.7,127.26) v13(75.65,125.1) v13(75.65,124.79) v13(75.65,124.47) v13(75.7,123.55) v13(75.7,123.14) v13(75.84,102.13) v13(75.84,100.83) v13(75.84,99.53) v13(75.84,95.63) v13(75.84,94.33) v13(75.84,93.03) v13(76.05,44.11) v13(76.06,121.03) v13(76.2,118.38) v13(76.3,154.1) v13(76.33,109.98) v13(76.43,32.48) v13(76.53,157.96) v13(76.52,105.93) v13(76.46,13.68) v13(76.67,165.79) v13(76.71,17.06) v13(76.79,142.85) v13(76.78,118.89) v13(76.81,82.49) v13(76.81,19.45) v13(77.04,167.46) v13(77.04,148.02) v13(77.09,152.62) v13(77.06,151.6) v13(77.11,150.56) v13(77.11,149.72) v13(77.23,154.1) v13(77.17,148.96) v13(77.19,141.55) v13(77.17,41.35) v13(77.19,23.67) v13(77.34,118.89) v13(77.44,98.23) v13(77.44,96.93) v13(77.62,105.93) v13(77.65,78.81) v13(77.8,157.96) v13(77.91,25.69) v13(77.9,15.17) v13(77.96,67.05) v13(77.98,49.95) v13(78.11,118.92) v13(78.13,60.14) v13(78.19,165.79) v13(78.24,98.88) v13(78.24,96.28) v13(78.41,30.24) v13(78.55,154.09) v13(78.54,148.07) v13(78.56,167.46) v13(78.59,118.23) v13(78.61,87.19) v13(78.74,149.24) v13(78.74,40.07) v13(78.82,142.85) v13(78.8,25.68) v13(78.87,130.94) v13(78.87,130.37) v13(78.87,129.8) v13(78.87,129.22) v13(78.87,128.65) v13(78.87,118.9) v13(78.9,117.12) v13(79.04,98.88) v13(79.02,55.59) v13(79.07,157.96) v13(79.09,133.01) v13(79.09,132.6) v13(79.07,131.7) v13(79.11,124.54) v13(79.11,124.23) v13(79.11,123.92) v13(79.12,106.36) v13(79.12,105.09) v13(79.12,73.17) v13(79.22,141.55) v13(79.2,76.87) v13(79.2,41.35) v13(79.44,130.93) v13(79.44,130.37) v13(79.44,129.8) v13(79.44,129.22) v13(79.44,128.65) v13(79.44,118.9) v13(79.36,16.57) v13(79.5,109.98) v13(79.59,125.96) v13(79.59,125.55) v13(79.62,122.95) v13(79.62,122.54) v13(79.72,165.79) v13(79.77,90.36) v13(79.78,44.13) v13(79.88,147.99) v13(79.88,83.05) v13(80.01,154.01) v13(80.01,150.2) v13(80.01,148.93) v13(80.04,133.01) v13(80.04,132.6) v13(80.01,118.9) v13(80.09,167.46) v13(80.09,153.33) v13(80.09,152.31) v13(80.06,151.3) v13(80.15,136.27) v13(80.15,135.97) v13(80.15,135.65) v13(80.15,134.52) v13(80.15,134.22) v13(80.15,133.9) v13(80.07,79.94) v13(80.18,137.69) v13(80.18,137.38) v13(80.16,76.93) v13(80.34,157.96) v13(80.59,118.9) v13(80.64,102.13) v13(80.64,101.48) v13(80.64,100.18) v13(80.64,99.53) v13(80.64,98.88) v13(80.64,95.63) v13(80.75,32.06) v13(80.72,17.97) v13(80.85,142.85) v13(80.86,134.73) v13(80.86,134.31) v13(80.9,130.37) v13(80.9,129.8) v13(80.91,23.13) v13(81.24,165.79) v13(81.2,153.94) v13(81.23,152.74) v13(81.17,118.9) v13(81.23,41.35) v13(81.25,141.55) v13(81.34,27.55) v13(81.44,102.13) v13(81.44,101.48) v13(81.44,100.18) v13(81.44,99.53) v13(81.44,95.63) v13(81.53,105.81) v13(81.61,167.46) v13(81.61,157.96) v13(81.64,32.06) v13(81.75,119.51) v13(81.76,118.94) v13(81.84,40.02) v13(82.04,37.48) v13(82.04,36.59) v13(82.04,35.7) v13(82.04,34.81) v13(82.04,33.92) v13(82.24,100.18) v13(82.24,99.53) v13(82.24,98.88) v13(82.24,97.58) v13(82.24,93.03) v13(82.23,27.55) v13(82.23,19.44) v13(82.27,153.96) v13(82.35,152.57) v13(82.42,105.81) v13(82.52,32.06) v13(82.72,142.84) v13(82.77,165.79) v13(82.98,157.96) v13(83.04,101.48) v13(83.04,100.83) v13(83.04,98.88) v13(83.04,93.03) v13(82.99,27.78) v13(83.13,167.46) v13(83.06,130.94) v13(83.06,130.3) v13(83.06,129.73) v13(83.06,129.16) v13(83.06,128.59) v13(83.24,151.14) v13(83.28,141.55) v13(83.27,41.35) v13(83.54,149.93) v13(83.46,148.43) v13(83.64,122.91) v13(83.64,122.61) v13(83.6,118.91) v13(83.67,153.96) v13(83.74,131.64) v13(83.74,130.75) v13(83.67,125.86) v13(83.67,125.55) v13(83.77,152.59) v13(83.84,102.13) v13(83.84,96.93) v13(83.84,93.03) v13(83.78,20.96) v13(83.9,132.37) v13(84.05,32.4) v13(84.14,124.49) v13(84.14,124.18) v13(84.14,123.86) v13(84.15,157.96) v13(84.29,165.79) v13(84.54,162.33) v13(84.49,125.41) v13(84.47,122.98) v13(84.57,162.83) v13(84.57,161.66) v13(84.58,161.13) v13(84.66,167.46) v13(84.71,134.75) v13(84.71,134.43) v13(84.85,162.33) v13(84.8,125.41) v13(84.77,122.98) v13(84.77,118.77) v13(84.87,162.83) v13(84.87,161.66) v13(84.89,161.13) v13(84.92,142.85) v13(85.01,151.12) v13(85.06,153.91) v13(85.09,152.72) v13(85.13,124.49) v13(85.13,124.18) v13(85.13,123.86) v13(85.08,22.3) v13(85.24,148.4) v13(85.32,141.55) v13(85.3,41.35) v13(85.42,157.96) v13(85.42,149.87) v13(85.41,130.81) v13(85.43,106.66) v13(85.69,125.41) v13(85.66,122.98) v13(85.81,165.79) v13(86.03,130.9) v13(85.99,125.41) v13(85.97,122.98) v13(86.04,38.8) v13(86.02,28.25) v13(86.04,24.16) v13(86.13,153.94) v13(86.1,40.46) v13(86.1,36.4) v13(86.11,33.97) v13(86.1,32.33) v13(86.1,30.32) v13(86.1,26.24) v13(86.18,167.46) v13(86.21,152.54) v13(86.51,151.17) v13(86.53,119.38) v13(86.53,118.81) v13(86.55,130.81) v13(86.69,157.96) v13(86.74,148.45) v13(86.91,125.41) v13(86.88,122.98) v13(87,149.9) v13(87.12,130.81) v13(87.21,125.41) v13(87.19,122.98) v13(87.34,165.79) v13(87.35,141.55) v13(87.53,153.94) v13(87.63,152.57) v13(87.71,167.46) v13(87.73,130.95) v13(87.8,119.45) v13(87.8,118.81) v13(87.77,98.36) v13(87.77,97.47) v13(87.86,151.09) v13(87.96,157.96) v13(88.09,148.38) v13(88.16,149.87) v13(88.23,106.66) v13(88.27,130.81) v13(88.46,119.41) v13(88.53,92.07) v13(88.86,165.79) v13(89.03,132.73) v13(89.03,130.75) v13(89.03,119.41) v13(89.08,153.99) v13(89.1,152.8) v13(89.23,167.46) v13(89.23,157.96) v13(89.33,107.41) v13(89.33,106.49) v13(89.41,109.17) v13(89.53,142.84) v13(89.81,130.42) v13(89.9,131.7) v13(89.98,125.59) v13(90.14,154.01) v13(90.12,130.43) v13(90.22,152.62) v13(90.35,124.6) v13(90.35,90.24) v13(90.39,165.79) v13(90.42,130.43) v13(90.5,157.96) v13(90.6,124.63) v13(90.75,167.46) v13(90.88,124.63) v13(91.07,125.54) v13(91.39,142.8) v13(91.41,141.55) v13(91.38,125.54) v13(91.54,154.01) v13(91.64,152.64) v13(91.69,131.46) v13(91.69,129.68) v13(91.69,125.54) v13(91.66,102.07) v13(91.66,98.17) v13(91.66,96.87) v13(91.77,157.96) v13(91.91,165.79) v13(92.15,124.14) v13(92.28,167.46) v13(92.34,138.1) v13(92.53,125.54) v13(92.46,102.07) v13(92.46,96.22) v13(92.58,148.53) v13(92.71,146.32) v13(92.69,138.37) v13(92.75,130.62) v13(92.84,125.54) v13(93.04,157.96) v13(92.99,144.54) v13(93.05,142.85) v13(92.99,124.12) v13(93.05,130.62) v13(93.15,125.54) v13(93.26,102.07) v13(93.26,101.42) v13(93.26,97.52) v13(93.26,96.22) v13(93.43,165.79) v13(93.37,90.24) v13(93.8,167.46) v13(93.93,130.88) v13(93.99,125.54) v13(94.06,102.07) v13(94.06,101.42) v13(94.06,100.12) v13(94.06,99.47) v13(94.06,93.62) v13(94.23,130.88) v13(94.31,157.96) v13(94.3,125.54) v13(94.36,153.91) v13(94.39,152.72) v13(94.44,90.24) v13(94.49,151.2) v13(94.49,149.34) v13(94.61,147.89) v13(94.55,130.88) v13(94.61,125.54) v13(94.64,124.68) v13(94.74,138.11) v13(94.72,124.42) v13(94.79,146.27) v13(94.75,87.08) v13(94.86,102.07) v13(94.86,101.42) v13(94.86,100.12) v13(94.86,99.47) v13(94.86,98.82) v13(94.86,96.22) v13(94.86,93.62) v13(94.86,92.97) v13(94.96,165.79) v13(94.97,124.42) v13(95.1,144.54) v13(95.15,89.87) v13(95.33,167.46) v13(95.48,141.55) v13(95.58,157.96) v13(95.64,130.88) v13(95.61,124.5) v13(95.77,125.54) v13(95.95,130.88) v13(95.91,124.5) v13(96.08,125.54) v13(96.19,154.01) v13(96.22,152.82) v13(96.23,124.5) v13(96.32,151.3) v13(96.32,149.44) v13(96.27,130.88) v13(96.28,87.08) v13(96.44,147.99) v13(96.39,125.54) v13(96.48,165.79) v13(96.46,98.82) v13(96.46,96.22) v13(96.46,94.27) v13(96.62,146.37) v13(96.67,157.82) v13(96.67,157.21) v13(96.85,167.46) v13(96.93,144.64) v13(97.11,142.85) v13(97.18,156.8) v13(97.26,98.82) v13(97.51,141.55) v13(97.79,156.78) v13(98.01,165.79) v13(98.06,98.17) v13(98.27,156.85) v13(98.31,87.08) v13(98.37,167.46) v13(98.4,153.94) v13(98.42,152.74) v13(98.53,151.22) v13(98.53,149.37) v13(98.65,147.92) v13(98.78,159.09) v13(98.78,158.54) v13(98.76,157.82) v13(98.76,157.33) v13(98.82,155.44) v13(98.83,146.29) v13(98.76,90.24) v13(98.95,156.68) v13(99.09,159.09) v13(99.09,158.54) v13(99.06,157.82) v13(99.06,157.33) v13(99.14,144.57) v13(99.14,142.85) v13(99.53,165.79) v13(99.54,141.55) v13(99.59,126.73) v13(99.68,128.03) v13(99.66,102.07) v13(99.66,100.77) v13(99.66,99.47) v13(99.66,97.52) v13(99.66,95.57) v13(99.66,94.27) v13(99.66,92.97) v13(99.9,167.46) v13(99.92,153.2) v13(99.99,128.03) v13(99.97,126.73) v13(100.2,158.38) v13(100.15,154.73) v13(100.33,157.27) v13(100.34,87.08) v13(100.39,90.24) v13(100.51,147.99) v13(100.46,146.34) v13(100.66,126.71) v13(100.79,145.07) v13(100.89,128.03) v13(101.04,156.25) v13(101.04,126.73) v13(101.05,165.79) v13(101.17,142.85) v13(101.19,128.03) v13(101.23,105.73) v13(101.23,104.78) v13(101.42,167.46) v13(101.63,157.72) v13(101.57,141.55) v13(101.65,153.23) v13(101.83,126.68) v13(102.1,128.03) v13(102.25,126.67) v13(102.41,156.25) v13(102.44,148.05) v13(102.41,144.97) v13(102.4,128.03) v13(102.37,87.08) v13(102.58,165.79) v13(102.59,154.57) v13(102.95,167.46) v13(103.07,126.68) v13(103.21,142.85) v13(103.21,128) v13(103.52,128) v13(103.52,126.67) v13(103.61,157.7) v13(103.6,141.55) v13(103.71,104.4) v13(103.71,103.44) v13(103.71,102.43) v13(103.71,101.41) v13(103.71,100.4) v13(103.71,99.38) v13(103.71,98.36) v13(103.94,148.07) v13(104.1,165.79) v13(104.09,156.25) v13(104.09,154.65) v13(104.15,157.67) v13(104.17,152.95) v13(104.17,150.13) v13(104.24,144.97) v13(104.2,92.01) v13(104.2,90.74) v13(104.41,87.08) v13(104.47,167.46) v13(105.24,142.85) v13(105.63,165.79) v13(105.6,163.15) v13(105.6,160.92) v13(105.6,159.09) v13(105.6,157.05) v13(105.6,155.02) v13(105.6,152.99) v13(105.6,150.96) v13(105.6,148.93) v13(105.6,146.89) v13(105.59,144.65) v13(106.44,87.08) v13(107.57,141.77) v13(107.81,167.58) v13(107.95,175.71) v13(108,173.94) v13(107.95,172.66) v13(107.95,170.88) v13(107.99,169.08) v13(108.38,168.05) v13(108.47,87.08) v13(108.62,168.99) v13(109.7,141.55) v13(109.8,168.14) v13(109.93,168.85) v13(110.5,87.08) v13(110.87,167.45) v13(111.48,168.12) v13(111.91,138.65) v13(111.99,139.82) v13(111.96,135.14) v13(112,133.43) v13(112,131.39) v13(112,129.34) v13(112,127.33) v13(112,125.3) v13(112,123.25) v13(112,121.21) v13(112,119.18) v13(112,117.17) v13(112,115.12) v13(112,113.09) v13(112,111.05) v13(112,109.04) v13(112,106.99) v13(112,104.98) v13(112,102.93) v13(112,100.89) v13(112,96.83) v13(111.99,94.59) v13(112,92.79) v13(112,88.72) v13(112.03,87.08) v13(112.13,168.91) v13(112.27,167.45) v13(112.64,168.1) v13(112.71,168.9) v13(113.3,152) v13(113.3,149.97) v13(113.3,147.93) v13(113.3,145.9) v13(113.3,143.87) v13(113.3,141.84) v13(113.3,139.81) v13(113.3,137.77) v13(113.3,135.74) v13(113.3,133.71) v13(113.3,131.83) v13(113.3,129.65) v13(113.28,127.85) v13(113.3,125.58) v13(113.27,123.29) v13(113.3,121.52) v13(113.3,119.49) v13(113.3,117.45) v13(113.3,115.42) v13(113.3,113.39) v13(113.3,111.36) v13(113.3,109.33) v13(113.3,107.29) v13(113.3,105.26) v13(113.3,103.23) v13(113.3,101.2) v13(113.3,99.17) v13(113.3,97.13) v13(113.3,94.53) v13(113.65,168.09) v13(114.05,168.85) v13(114.22,94.35) v13(114.27,152.7) v13(114.64,174.98) v13(114.59,171.77) v13(114.78,168.04) v13(115.06,172.58) v13(115.3,168.7) v13(115.65,167.17) v13(115.82,164.72) v13(115.82,163.36) v13(115.82,162.5) v13(116.07,167.98) v13(116.3,152.7) v13(116.25,94.35) v13(116.62,167.46) v13(116.7,162.69) v13(116.76,164.72) v13(116.78,163.44) v13(117.2,158.43) v13(118.33,152.7) v13(118.29,94.35) v13(119.07,161.71) v13(119.4,156.66) v13(119.4,156.02) v13(120.32,94.35) v13(120.36,152.7) v13(122.35,94.35) v13(122.94,168.34) v13(122.94,166.31) v13(122.94,163.64) v13(123.37,126.05) v13(123.42,89.4) v13(123.55,158.45) v13(123.67,162.13) v13(124,152.7) v13(124.08,92.98) v13(124.21,167.71) v13(124.21,164.91) v13(124.59,160.09) v13(124.59,158.18) v13(124.76,141.23) v13(124.88,155.01) v13(126.36,161.15) v13(126.49,92.93) v13(126.58,156.01) v13(127.15,92.93) v13(127.25,94.63) v13(127.58,88.46) v13(129.06,94.32) v13(131.05,152.92) v13(132.54,152.93) v13(132.89,131.76) v13(134.58,152.93) v13(134.7,141.52) v13(134.71,131.73) v13(134.75,94.43) v13(135.59,131.75) v13(136.21,120.89) v13(136.61,152.93) v13(136.59,139.68) v13(136.92,149.54) v13(136.95,94.35) v13(138.07,132.55) v13(138.2,136.15) v13(138.47,138.27) v13(138.47,137.89) v13(138.47,137.5) v13(138.64,152.93) v13(138.87,120.89) v13(138.94,112.03) v13(138.98,94.35) v13(139.22,147) v13(139.83,112.03) v13(140.16,128.59) v13(140.16,127.7) v13(140.21,89.05) v13(140.27,122.94) v13(140.64,93.16) v13(140.67,152.93) v13(140.65,122.94) v13(140.97,136.51) v13(141.01,94.35) v13(141.22,148.78) v13(141.54,122.94) v13(141.65,139.11) v13(141.78,93.16) v13(141.92,122.94) v13(142.04,135.69) v13(142.18,91.34) v13(142.18,90.72) v13(142.18,88.93) v13(142.32,149.53) v13(142.62,141.29) v13(142.72,152.7) v13(142.81,122.94) v13(143.03,144.85) v13(143.05,94.35) v13(143.05,134.94) v13(143.22,134.18) v13(143.19,122.94) v13(143.66,88.53) v13(144.08,122.94) v13(144.46,122.94) v13(144.75,152.7) v13(144.87,144.91) v13(144.87,144.27) v13(144.87,143.64) v13(144.87,143) v13(144.87,142.37) v13(144.87,141.73) v13(145.08,94.35) v13(145.41,122.7) v13(145.45,140.4) v13(146.49,147.51) v13(146.78,152.7) v13(147.11,94.35) v13(147.4,149.86) v13(147.45,89.05) v13(147.93,93.16) v13(148.81,152.7) v13(148.81,148.4) v13(148.81,147.77) v13(149.1,137.91) v13(149.14,94.35) v13(149.28,134.05) v13(149.28,129.61) v13(149.44,93.13) v13(149.42,91.34) v13(149.42,90.72) v13(149.42,88.93) v13(149.55,141.96) v13(149.55,141.16) v13(149.5,115.12) v13(149.5,113.09) v13(149.5,111.06) v13(149.5,109.03) v13(149.5,107) v13(149.5,104.96) v13(149.5,102.93) v13(149.5,100.9) v13(149.5,96.84) v13(149.5,95.3) v13(150.11,135.9) v13(150.19,132.27) v13(150.75,143.56) v13(150.75,141.96) v13(150.75,141.56) v13(150.84,152.7) v13(150.96,88.52) v13(151.13,146.45) v13(151.19,138.39) v13(151.38,92.62) v13(151.55,141.56) v13(151.54,115.12) v13(151.95,141.56) v13(151.92,138.42) v13(152.7,147.39) v13(152.88,152.7) v13(152.98,115.2) v13(153.21,136.3) v13(153.21,135.7) v13(153.21,132.7) v13(153.21,129.1) v13(153.21,127.3) v13(153.21,125.5) v13(153.21,123.7) v13(153.21,121.9) v13(153.21,120.1) v13(153.29,141.5) v13(153.62,148.91) v13(153.58,136.95) v13(154.43,145.05) v13(154.43,142.36) v13(154.69,139.1) v13(154.91,152.7) v13(155.01,115.2) v13(155.23,146.5) v13(155.32,139.1) v13(156.09,133) v13(156.09,129.4) v13(156.09,127.6) v13(156.09,125.8) v13(156.09,124) v13(156.09,122.2) v13(156.09,120.4) v13(156.09,118.6) v13(156.94,152.7) v13(157.04,115.2) v13(158.97,152.7) v13(158.95,133.8) v13(158.95,132.02) v13(158.95,130.24) v13(158.95,129.35) v13(159.08,115.2) v13(161,152.69) v13(161,150.66) v13(161,148.63) v13(161,146.59) v13(161,144.56) v13(161,142.53) v13(161,140.5) v13(161,138.47) v13(161,136.43) v13(161,134.4) v13(161,132.37) v13(161,130.34) v13(161,128.31) v13(161,126.27) v13(161,124.24) v13(161,122.21) v13(161,120.18) v13(161,118.15) v13(161,116.11) v13(161,115.22) v14(22.92,107.82) v14(24.85,95.47) v14(25.36,99.89) v14(32.07,106.81) v14(34.54,83.25) v14(38.86,88.58) v14(39.37,81.22) v14(39.62,83.5) v14(40.64,90.62) v14(42.57,106.96) v14(44.96,82.49) v14(51.23,159.51) v14(51.31,111.7) v14(51.61,158.76) v14(51.79,159.7) v14(51.97,41.62) v14(52.25,158.74) v14(52.54,159.67) v14(53,158.79) v14(53.28,159.41) v14(55.12,110.68) v14(55.37,103.51) v14(55.54,162.47) v14(55.51,161.25) v14(55.58,161.86) v14(55.68,160.69) v14(56.25,163.23) v14(56.29,160.57) v14(56.9,163.22) v14(56.93,160.72) v14(57.02,162.55) v14(57.04,161.94) v14(57.02,161.34) v14(57.18,36.54) v14(58.34,123.46) v14(58.94,161.34) v14(58.99,162) v14(59.05,162.64) v14(59.12,160.76) v14(59.06,123.96) v14(59.65,162.8) v14(59.77,160.68) v14(60.31,162.79) v14(60.85,160.62) v14(61,162.78) v14(61.49,160.76) v14(61.57,162.65) v14(61.63,161.38) v14(61.68,162.02) v14(62.18,31.54) v14(62.52,162.23) v14(62.55,161.57) v14(62.59,162.89) v14(63.26,163.02) v14(63.28,161.56) v14(63.92,162.96) v14(64.05,161.7) v14(64.14,162.32) v14(67.06,26.71) v14(74.41,161.9) v14(74.47,162.65) v14(74.83,161.37) v14(75.01,162.98) v14(75.08,159.03) v14(75.17,159.67) v14(75.2,158.42) v14(75.34,161.76) v14(75.58,162.03) v14(75.69,162.98) v14(75.81,159.77) v14(75.79,158.32) v14(76.12,162.03) v14(76.33,162.97) v14(76.38,159.73) v14(76.38,158.29) v14(76.71,162.04) v14(76.95,162.96) v14(76.99,159.78) v14(76.97,158.29) v14(77.25,162.04) v14(77.58,162.98) v14(77.61,159.78) v14(77.65,158.29) v14(77.85,162.04) v14(78.05,161.52) v14(78.17,162.98) v14(78.23,158.48) v14(78.27,159.59) v14(78.55,161.22) v14(78.51,159.04) v14(78.75,162.96) v14(79.22,161.22) v14(79.34,162.94) v14(79.93,161.24) v14(79.97,162.93) v14(80.44,161.67) v14(80.57,162.79) v14(80.72,162.22) v14(91.68,161.51) v14(91.8,162.22) v14(91.99,160.82) v14(92.29,162.68) v14(92.57,160.28) v14(93,162.89) v14(93.41,160.28) v14(93.66,162.74) v14(93.74,162.13) v14(93.73,161.51) v14(93.76,160.83) v14(95.53,162.47) v14(95.57,161.69) v14(95.63,161.04) v14(95.69,160.39) v14(96.02,162.9) v14(96.35,160.3) v14(96.67,162.9) v14(97.09,160.21) v14(97.32,162.92) v14(97.74,161.11) v14(97.66,160.44) v14(97.78,162.47) v14(97.79,161.82) v15(11.61,130.01) v15(11.66,125.95) v15(13.11,133.52) v15(28.21,49.42) v15(34.8,61.13) v15(36.02,61.03) v15(37.13,49.56) v15(39.64,49.56) v15(39.67,30.34) v15(39.85,77.46) v15(39.9,48.81) v15(42.09,164.01) v15(42.29,59.91) v15(42.27,58.08) v15(43.17,164.01) v15(43.69,60.64) v15(43.84,161.08) v15(43.84,57.04) v15(43.87,163.23) v15(43.87,161.96) v15(43.87,159.42) v15(43.87,158.15) v15(43.87,156.88) v15(43.87,155.61) v15(44.26,164.01) v15(44.27,66.36) v15(45.53,164.01) v15(46.8,164.01) v15(47.9,70.98) v15(48.07,164.01) v15(49.15,17.31) v15(49.16,19.81) v15(49.2,18.12) v15(49.34,164.01) v15(49.25,74.56) v15(49.96,22.19) v15(50.46,20.51) v15(50.61,164.01) v15(51.28,158.97) v15(51.45,159.7) v15(51.88,164.01) v15(51.93,158.75) v15(52.13,159.69) v15(52.13,134.69) v15(52.15,74.84) v15(52.58,158.75) v15(52.73,14.7) v15(53.15,164.01) v15(53.06,159.65) v15(53.26,159.08) v15(53.64,17.11) v15(54.1,56.83) v15(54.23,62.17) v15(54.33,26.05) v15(54.33,15.31) v15(54.42,164.01) v15(54.66,52.39) v15(54.79,50.03) v15(55.04,44.64) v15(55.04,35.63) v15(55.02,31.87) v15(55.3,45.58) v15(55.51,162.8) v15(55.52,162.17) v15(55.52,161.56) v15(55.52,160.95) v15(55.47,61.23) v15(55.52,57.24) v15(55.52,52.01) v15(55.69,164.01) v15(55.93,163.25) v15(55.97,160.57) v15(56.11,46.9) v15(56.24,57.19) v15(56.21,15.31) v15(56.29,68.47) v15(56.26,51.53) v15(56.36,46.09) v15(56.36,32.35) v15(56.57,163.22) v15(56.63,160.57) v15(56.62,77.56) v15(56.62,71.46) v15(56.59,44.46) v15(56.57,37.71) v15(56.57,34.53) v15(56.96,164.01) v15(57.02,162.89) v15(57.04,162.26) v15(57.04,161.65) v15(57.07,161.01) v15(57.15,81.35) v15(57.15,37.68) v15(57.15,34.53) v15(57.45,30.82) v15(57.53,16.63) v15(57.68,70.22) v15(57.71,51.17) v15(57.68,43.55) v15(57.66,14.8) v15(58.09,72.2) v15(58.23,164.01) v15(58.34,51.6) v15(58.32,44.03) v15(58.32,34.74) v15(58.39,75.6) v15(58.42,70.22) v15(58.52,79.57) v15(58.57,39.69) v15(58.65,20.69) v15(58.67,32.27) v15(58.94,161.67) v15(58.94,161.04) v15(58.97,162.32) v15(59,17.41) v15(59.33,162.8) v15(59.42,160.64) v15(59.41,43.91) v15(59.41,38.62) v15(59.5,164.01) v15(59.66,15.43) v15(59.92,75.2) v15(59.98,162.8) v15(59.97,33.49) v15(60.15,44.03) v15(60.12,38.85) v15(60.16,160.69) v15(60.52,160.64) v15(60.6,28.72) v15(60.66,162.78) v15(60.77,164.01) v15(61.09,19.12) v15(61.2,160.62) v15(61.19,73.09) v15(61.3,162.79) v15(61.32,71.69) v15(61.39,107.43) v15(61.68,162.36) v15(61.66,161.71) v15(61.7,161.05) v15(61.7,84.14) v15(61.77,135.47) v15(62.04,164.01) v15(62.46,162.55) v15(62.46,161.89) v15(62.66,28.36) v15(62.88,163.01) v15(62.93,161.47) v15(62.87,83.35) v15(63.04,19.75) v15(63.31,164.01) v15(63.47,29.2) v15(63.53,18.2) v15(63.59,163.02) v15(63.62,102.43) v15(63.62,96.92) v15(63.67,91) v15(63.73,14.09) v15(63.75,161.51) v15(63.8,25.08) v15(64.14,162.68) v15(64.11,162) v15(64.38,22.49) v15(64.58,164.01) v15(64.92,24.86) v15(65.2,21.38) v15(65.85,164.01) v15(67.12,164.01) v15(68.05,22.98) v15(68.39,164.01) v15(69.32,87.76) v15(69.27,23.46) v15(69.66,164.01) v15(69.72,21.5) v15(70.93,164.01) v15(72.2,164.01) v15(73.47,164.01) v15(73.53,87.8) v15(74.5,162.26) v15(74.47,161.55) v15(74.74,164.01) v15(74.68,162.93) v15(75.04,159.36) v15(75.07,158.71) v15(75.16,161.47) v15(75.35,162.98) v15(75.27,162.1) v15(75.5,159.79) v15(75.5,158.28) v15(75.86,162.08) v15(76.01,164.01) v15(76.01,162.97) v15(76.1,159.78) v15(76.1,158.29) v15(76.25,134.74) v15(76.43,162.09) v15(76.64,162.97) v15(76.7,159.79) v15(76.66,158.29) v15(77,162.08) v15(77.28,164.01) v15(77.27,162.98) v15(77.28,159.78) v15(77.28,158.28) v15(77.56,162.07) v15(77.88,162.99) v15(77.93,159.78) v15(77.98,158.31) v15(78.13,162.08) v15(78.27,161.29) v15(78.28,159.25) v15(78.35,158.76) v15(78.31,133.64) v15(78.55,164.01) v15(78.49,162.97) v15(78.74,162.1) v15(78.87,161.28) v15(79.02,162.96) v15(79.25,92.68) v15(79.63,162.94) v15(79.58,161.25) v15(79.82,164.01) v15(80.3,162.9) v15(80.26,161.39) v15(80.31,90.7) v15(80.49,161.99) v15(80.73,162.51) v15(81.09,164.01) v15(81.6,157.6) v15(82.35,158.04) v15(82.35,157.18) v15(82.36,164.01) v15(82.82,162.57) v15(82.83,162.05) v15(82.82,161.51) v15(83.15,157.62) v15(83.3,162.74) v15(83.29,162.04) v15(83.29,161.34) v15(83.63,164.01) v15(83.73,162.04) v15(83.82,162.6) v15(83.79,161.52) v15(84.9,164.01) v15(86.17,164.01) v15(86.23,91.07) v15(87.44,164.01) v15(88.71,164.01) v15(89.98,164.01) v15(91.25,164.01) v15(91.67,161.86) v15(91.67,161.13) v15(92.08,162.38) v15(92.2,91.07) v15(92.27,160.58) v15(92.52,164.01) v15(92.61,162.9) v15(92.96,160.28) v15(93.37,162.9) v15(93.7,160.49) v15(93.79,164.01) v15(93.78,162.45) v15(93.76,161.81) v15(93.75,161.18) v15(94.89,159.88) v15(95.06,164.01) v15(95.54,161.36) v15(95.54,160.68) v15(95.49,159.15) v15(95.59,162.1) v15(95.62,160.05) v15(95.57,158.56) v15(95.71,162.83) v15(96,160.25) v15(96.14,158.43) v15(96.33,164.01) v15(96.34,162.9) v15(96.3,159.35) v15(96.8,160.3) v15(96.88,159.36) v15(96.99,162.9) v15(97.07,159.83) v15(97.4,160.22) v15(97.6,164.01) v15(97.66,162.78) v15(97.71,162.14) v15(97.73,161.49) v15(97.7,160.78) v15(98.87,164.01) v15(100.14,164.01) v15(101.41,164.01) v15(102.68,164.01) v15(103.84,164.01) v15(105.08,164.02) v15(106.26,164.02) v15(118.69,157.98) v15(120.14,160.09) v15(125.63,155.01) v15(126.72,157.75) v15(136.37,128.67) v15(136.6,131.15) v15(137.41,132.15) v15(137.64,127.22) v15(140.74,151.07) v15(141.43,141.52) v15(142.14,148.32) v15(142.65,142.23) v15(143.97,147.41) v15(150.19,123.23) v15(150.39,127.95) v15(152.5,131.79) v16(6.05,27.98) v16(7.33,123.58) v16(7.92,30.39) v16(9.11,119.16) v16(9.8,128.96) v16(10.42,128.24) v16(10.97,114.43) v16(13.71,133) v16(14.28,132.05) v16(15.98,105.78) v16(16.96,136.2) v16(17.4,19.8) v16(17.86,135.69) v16(18.98,17.08) v16(19.7,100.27) v16(19.7,96.33) v16(21.39,24.12) v16(21.69,25.67) v16(21.98,17.64) v16(22.44,35.23) v16(22.52,20.77) v16(23.77,20.11) v16(24.13,27.29) v16(25.46,17.64) v16(25.55,28.54) v16(26.64,22.93) v16(27.66,29.17) v16(31.8,81.8) v16(31.8,79.34) v16(31.95,77.38) v16(32.93,22.84) v16(33.93,32.73) v16(34.39,37.4) v16(34.52,39.08) v16(35.66,67.3) v16(36.83,47.56) v16(37.01,160.73) v16(37.83,161.55) v16(38.19,165.19) v16(38.19,164.38) v16(38.23,57.09) v16(38.89,20.79) v16(39.08,162.79) v16(39.33,166.22) v16(39.38,164.64) v16(39.5,53.72) v16(39.84,163.67) v16(40.02,18.24) v16(40.5,165.79) v16(40.61,167.45) v16(40.84,20.64) v16(41.1,166.35) v16(41.06,164.91) v16(41.33,39.38) v16(41.58,78.68) v16(41.71,85.23) v16(41.71,73.7) v16(41.78,58.29) v16(42.14,167.45) v16(42.14,20.69) v16(42.41,166.36) v16(42.74,62.87) v16(42.81,18.24) v16(43.61,82.36) v16(43.66,167.45) v16(43.74,85.71) v16(44.08,166.36) v16(44.65,39.21) v16(44.96,68.9) v16(45.02,56.33) v16(45.19,167.45) v16(45.16,44.82) v16(45.69,166.37) v16(46.71,167.45) v16(47.09,166.36) v16(48.23,167.45) v16(48.41,42.81) v16(48.62,166.36) v16(48.64,48.27) v16(48.82,40.81) v16(49.76,167.45) v16(50,166.36) v16(50.14,129.73) v16(50.75,130.6) v16(51.28,167.45) v16(51.33,166.36) v16(51.89,81.4) v16(52.69,166.36) v16(52.81,167.45) v16(53.01,47.66) v16(53.06,44.82) v16(53.85,81.06) v16(54.33,167.45) v16(54.33,166.9) v16(55.14,49.49) v16(55.85,167.45) v16(55.85,166.9) v16(56.31,76.01) v16(56.34,59.04) v16(56.36,72.53) v16(56.41,66.16) v16(56.41,48.63) v16(57.38,167.45) v16(57.38,166.9) v16(58.9,167.45) v16(58.9,166.9) v16(60.33,52.01) v16(60.43,167.45) v16(60.43,166.9) v16(61.95,167.45) v16(61.95,166.9) v16(63.47,167.45) v16(63.47,166.9) v16(65,167.45) v16(65,166.9) v16(66.52,167.45) v16(66.52,166.9) v16(67.69,166.9) v16(68.05,167.45) v16(69.22,14.92) v16(69.57,167.45) v16(69.57,166.9) v16(71.09,167.45) v16(71.09,166.9) v16(71.86,41.92) v16(72.09,61.28) v16(72.24,50.69) v16(72.62,167.45) v16(72.62,166.9) v16(74.04,63.62) v16(74.14,167.45) v16(74.14,166.9) v16(74.57,43.45) v16(74.57,42.03) v16(74.68,58.56) v16(74.65,53.61) v16(74.7,47.77) v16(75.21,62.09) v16(75.62,60.85) v16(75.67,167.45) v16(75.67,166.9) v16(76.73,61.15) v16(76.78,63.18) v16(76.81,57.62) v16(77.19,167.45) v16(77.19,166.9) v16(77.6,54.98) v16(77.6,49.24) v16(77.72,45.12) v16(78.71,167.45) v16(78.71,166.9) v16(78.66,61.3) v16(78.84,44.79) v16(79.53,50.92) v16(80.06,49.06) v16(80.24,167.45) v16(80.24,166.9) v16(81.74,74.46) v16(81.76,167.45) v16(81.76,166.9) v16(82.07,49.39) v16(82.12,47.46) v16(82.32,44.64) v16(83.29,167.45) v16(83.29,166.9) v16(83.59,43.47) v16(84.34,143.53) v16(84.81,167.45) v16(84.81,166.9) v16(86.33,167.45) v16(86.33,166.9) v16(86.97,146.04) v16(87.86,167.45) v16(87.86,166.9) v16(88.81,167.45) v16(89.38,166.9) v16(89.36,144.06) v16(90.91,167.45) v16(90.91,166.9) v16(92.43,167.45) v16(92.43,166.9) v16(93.95,167.45) v16(93.95,166.9) v16(95.48,167.45) v16(95.48,166.9) v16(97,167.45) v16(97,166.9) v16(98.53,167.45) v16(98.53,166.9) v16(100.05,167.45) v16(100.05,166.9) v16(101.57,167.45) v16(101.57,166.9) v16(102.18,123.89) v16(103.1,167.45) v16(103.1,166.9) v16(104.62,167.45) v16(104.62,166.9) v16(105.23,87.19) v16(105.47,132.08) v16(106.15,167.45) v16(106.15,166.9) v16(106.78,123.98) v16(107.14,87.77) v16(107.67,167.45) v16(107.67,166.9) v16(107.95,175.96) v16(108.01,174.25) v16(107.95,171.64) v16(108.18,169.33) v16(108.33,167.45) v16(109.96,87.87) v16(110.49,167.45) v16(112.47,89.24) v16(112.59,169.42) v16(123.7,89.68) v16(127.76,89.22) v16(129.26,88.56) v16(131.65,89.4) v16(135.51,90.34) v16(135.78,94.43) v16(137.79,89.24) v16(139.5,99.99) v16(140.11,91.71) v16(140.77,95.82) v16(140.77,94.65) v16(140.97,99.96) v16(141.83,90.79) v16(142.47,97.42) v16(143.76,95.95) v16(144.15,91.17) v16(145.14,88.33) v16(145.36,92.32) v16(145.75,97.52) v16(146.84,93.03) v16(147.93,88.3) v16(151.51,131.45) v16(151.57,129.41) v16(156.78,131.64) v16(156.91,128.91) v17(5.33,147.58) v17(10.31,116.91) v17(10.31,115.15) v17(10.35,119) v17(11.2,107.13) v17(11.18,106.55) v17(11.23,105.35) v17(11.49,147.7) v17(14.48,123) v17(15.05,125.73) v17(15.11,136.72) v17(15.11,118.87) v17(16.36,115) v17(17.91,168.85) v17(17.97,163.2) v17(18.77,113.04) v17(19.11,80.84) v17(19.24,68.29) v17(21.29,66.77) v17(22.33,68.73) v17(23.32,61.09) v17(24.74,63.76) v17(24.68,33.14) v17(24.89,99.06) v17(25.02,135.89) v17(24.96,96.71) v17(25.32,67.79) v17(25.78,65.94) v17(25.98,61.57) v17(26.49,34.08) v17(26.72,33.01) v17(27.85,65.47) v17(29.13,64.21) v17(29.6,64.58) v17(29.57,63.57) v17(30.4,68.38) v17(30.73,67.54) v17(30.99,164.76) v17(31.94,64.77) v17(32.51,164.76) v17(32.51,69.86) v17(32.83,67.08) v17(32.8,63.88) v17(33.79,164.78) v17(35.13,71.19) v17(35.24,83.06) v17(35.32,164.78) v17(35.71,68.11) v17(36.58,167.45) v17(37.1,165.33) v17(37.08,164.76) v17(37.87,166.1) v17(37.87,77.08) v17(38.1,167.45) v17(38.66,166.79) v17(38.79,165.63) v17(39.31,166.12) v17(39.62,167.45) v17(39.95,166.73) v17(40.14,162.83) v17(40.93,163.62) v17(41.22,167.46) v17(41.53,164.28) v17(41.45,123.59) v17(41.91,124.86) v17(42.23,164.97) v17(42.37,123.66) v17(42.75,167.46) v17(44.27,167.46) v17(44.65,26.43) v17(45.62,74.16) v17(45.8,167.46) v17(47.18,37.68) v17(47.32,167.46) v17(47.74,36.3) v17(48.67,71.01) v17(48.84,167.46) v17(49.96,26.43) v17(50.37,167.46) v17(50.58,38.89) v17(51.82,29.59) v17(51.89,167.46) v17(52.98,113.07) v17(53.42,167.46) v17(53.53,25.02) v17(54.94,167.46) v17(55.45,110.91) v17(56.46,167.46) v17(57.99,167.46) v17(59.07,37.2) v17(59.31,107.18) v17(59.41,40.98) v17(59.51,167.46) v17(61.04,167.46) v17(60.99,38.9) v17(62.08,41.04) v17(62.56,167.46) v17(62.6,39.66) v17(64.08,167.46) v17(65.61,167.46) v17(66.87,154.09) v17(67.13,167.46) v17(67.5,154.09) v17(68.14,154.09) v17(68.66,167.46) v17(68.77,154.09) v17(69.41,154.09) v17(70.18,167.46) v17(70.85,154.09) v17(71.7,167.46) v17(72.1,154.09) v17(73.23,167.46) v17(73.28,154.09) v17(74.43,154.09) v17(74.75,167.46) v17(75.49,154.09) v17(76.28,167.46) v17(76.73,154.1) v17(77.8,167.46) v17(77.81,154.09) v17(79.13,154.09) v17(79.32,167.46) v17(80.61,154.09) v17(80.85,167.46) v17(81.74,154.08) v17(82.37,167.46) v17(83.08,154.09) v17(83.9,167.46) v17(84.42,154.07) v17(85.42,167.46) v17(85.6,154.07) v17(86.94,167.46) v17(86.92,154.05) v17(88.35,154.05) v17(88.47,167.46) v17(89.61,154.04) v17(89.99,167.46) v17(90.86,154.05) v17(91.52,167.46) v17(92.3,154.01) v17(93.04,167.46) v17(93.36,154.03) v17(94.56,167.46) v17(95.26,154.07) v17(96.09,167.46) v17(97.24,154.05) v17(97.61,167.46) v17(99.14,167.46) v17(100.66,167.46) v17(102.18,167.46) v17(103.71,167.46) v17(105,160.06) v17(105.23,167.46) v17(106.48,157.62) v17(106.71,150) v17(106.76,167.46) v17(107.01,153.79) v17(107.11,160.39) v17(107.49,158.87) v17(107.59,148.55) v17(107.75,155.26) v17(107.95,174.82) v17(107.95,172.02) v17(108.08,170.18) v17(108.2,156.71) v17(108.18,151.63) v17(108.53,167.49) v17(109.22,149.87) v17(109.98,151.64) v17(110.17,149.04) v17(110.72,150.81) v17(110.77,148.48) v17(111.63,133.86) v17(111.73,149.77) v17(112.6,153.94) v17(112.6,150.92) v17(112.97,140.72) v17(113.51,154.19) v17(114.68,169.99) v17(114.86,161.58) v17(115.82,156.48) v17(116.2,149.61) v17(117.04,159.45) v17(117.63,162.27) v17(119.38,166.82) v17(120.14,174.25) v17(120.65,164.4) v17(121.13,161.96) v17(121.41,157.55) v17(121.41,154.5) v17(122.49,175.77) v17(122.78,169.53) v17(123.22,169.18) v17(123.29,170.44) v17(123.44,154.37) v17(123.75,170) v17(124.21,168.56) v17(124.27,169.36) v17(124.97,168.33) v17(125.15,168.95) v17(125.21,162.75) v17(125.73,162.24) v17(125.88,168.31) v17(126.2,168.91) v17(126.72,168.28) v17(126.87,166.88) v17(126.97,168.81) v17(127.57,161.04) v17(127.57,154.75) v17(127.57,152.86) v17(127.76,164.02) v17(128.54,154.62) v17(131.52,152.76) v17(131.83,151.57) v17(135.89,151.57) v17(137.53,152.76) v17(142.62,151.57) v17(143.78,152.69) v17(146.69,151.57) v17(147.51,149.48) v17(147.83,146.24) v17(149.56,152.04) v17(150.3,87.5) v17(151.96,91.82) v17(152.95,88.94) v17(156.57,94.29) v17(159.45,97.03) v17(160.02,104.27)
