# Allegro board Dell Latitude 5290 2-IN-1 LA-F371P Boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ISH_I2C0_SDA: length 123.2
  TOP w0.112: RS16.1 RS18.1 4.38,121.44 4.69,121.75 4.69,122.49 v7(4.59,122.59)
  IN1 w0.066: v8(55.93,128.66) 56.03,128.56 56.97,128.56 57.72,129.32 58.21,129.32 58.33,129.2 59.52,129.2 60.63,130.31 60.86,130.31 61.41,130.85 64.68,130.85 65.33,131.5 65.33,132.66 65.78,133.11 65.78,134.03 64.86,134.96 64.86,135.16 62.88,137.14 62.84,137.18 62.84,138.57 63.1,138.83 63.1,139.28 61.49,140.89 57.91,140.89 56.82,141.98 53.93,141.98 53.73,141.78 44.8,141.78 43.18,143.41 43.18,144.75 v10(43.09,144.85)
  IN2 w0.066: v7(4.59,122.59) 4.59,122.4 4.8,122.19 5.92,122.19 6.22,122.49 6.22,124.51 17.78,136.06 23.65,136.06 32.83,145.24 43.02,145.24 43.18,145.08 43.18,144.94 v10(43.09,144.85)
  IN4 w0.066: v7(4.59,122.59) 4.78,122.78 4.78,124.04 6.79,126.06 6.79,135.89 5.14,137.55 5.14,141.56 4.57,142.13 4.57,143.04 4.9,143.37 v7(5.07,143.37)
  BOTTOM w0.112: LGA1.14 8.44,142.97 8.31,142.84 7.21,142.84 6.86,143.19 5.25,143.19 v7(5.07,143.37)
ITP_PMODE: length 121.9
  TOP w0.076: 57.96,136.21 58.22,135.96 58.22,134.15 58.36,134 58.36,132.76 58.47,132.66 UCPU1.E8
  TOP w0.112: v2(55.83,139.88) 55.91,139.8 55.91,138.58 56.39,138.1 RC10.1 56.39,137.78 57.96,136.21
  IN2 w0.066: v3(56.26,137.96) 56.26,138.42 56.46,138.62 56.95,138.62 57.37,139.04 57.37,139.52 v4(57.18,139.71)
  IN3 w0.066: v6(56.72,140.48) 57.18,140.02 v4(57.18,139.71) ; v6(114.17,134.36) 123.64,134.36 124.2,133.8 125.11,133.8 125.39,133.52 129.27,133.52 130.72,132.07 131.47,132.07 132.55,131 138.67,131 140.58,129.09 147.62,129.09 148.18,129.64 154.08,129.64 156.09,131.65 v5(156.09,131.8)
  IN4 w0.066: v6(114.17,134.36) 114.17,136.01 107.91,142.27 95.49,142.27 92.27,139.05 87.21,139.05 86.67,139.59 75.5,139.59 75.49,139.58 71.72,139.58 71.25,139.11 69.73,139.11 68.6,140.24 62.06,140.24 61.66,140.64 56.88,140.64 v6(56.72,140.48)
JACK_PLUG#: length 7.3
  BOTTOM w0.112: RA13.2 31.36,141.66 CA40.1 RA14.2 30.87,143 28.05,143 v2(27.79,143.26) 27.28,143.78 26.9,143.78 26.71,143.97 UA1.1
JTAG_CLK: length 36.6
  TOP w0.112: RE6.2 37.53,89.18 37.35,89.36 37.2,89.36 36.93,89.63 v2(36.93,89.75) 37.16,89.98 37.35,89.98 v3(37.44,90.07) 37.71,90.34 JDEG3.4
  IN2 w0.066: v3(37.44,90.07) 37.12,90.07 36.92,90.27 36.92,91.09 37.87,92.04 37.87,98.44 34.32,101.99 34.32,106.77 32.61,108.48 32.61,114.77 v4(33.27,115.43)
  IN3 w0.066: v5(29.11,114.43) 29.11,114.64 29.84,115.38 33.22,115.38 v4(33.27,115.43)
  BOTTOM w0.076: UE3.C8 29.08,114.4 v5(29.11,114.43)
JTAG_RST#: length 4.6
  BOTTOM w0.112: UE3.G13 25.53,119.08 25.55,119.1 25.56,119.1 25.69,119.23 25.69,119.86 26.1,120.27 CE24.1 26.06,120.68 RE41.1 24.26,120.68 RE42.2
JTAG_TDI: length 38.2
  TOP w0.112: RE8.2 39.48,89.41 v2(39.48,89.89) 39.48,89.96 39.36,90.08 38.95,90.08 38.71,90.33 v3(38.71,90.95)
  IN2 w0.066: v4(33.78,115.61) 34.62,115.61 35.55,114.68 35.55,107.67 35.15,107.28 35.15,102.43 38.78,98.8 38.78,91.02 v3(38.71,90.95)
  IN3 w0.076: v4(33.78,115.61) 33.56,115.83 29.54,115.83 28.5,114.79 v5(27.04,114.79)
  BOTTOM w0.076: UE3.E9 27.13,114.88 v5(27.04,114.79)
JTAG_TDO: length 39.7
  TOP w0.112: v2(35.51,89.68) 36.35,88.84 RE5.2 36.82,88.98 36.44,89.36 36.44,89.99 36.93,90.49 37.1,90.49 37.21,90.6 JDEG3.5
  IN2 w0.066: v3(37.21,90.95) 37.5,90.95 38.39,91.83 38.39,98.64 34.77,102.27 34.77,107.48 35.13,107.84 35.13,112.87 33.63,114.37 v4(33.63,114.75)
  IN3 w0.066: v5(26.33,112.8) 27.88,112.8 28.14,112.54 28.5,112.54 28.72,112.76 28.89,112.76 29.97,113.83 30.08,113.95 30.32,114.19 32.54,114.19 32.81,114.46 32.81,114.71 33.01,114.91 33.47,114.91 v4(33.63,114.75)
JTAG_TMS: length 35.3
  TOP w0.112: RE7.2 38.21,88.84 v2(38.21,89.7) v3(38.21,90.95)
  IN2 w0.066: v4(34.8,114.82) 34.9,114.72 34.9,113.73 35.33,113.3 35.33,107.76 34.96,107.39 34.96,102.35 38.58,98.72 38.58,91.75 38.21,91.37 v3(38.21,90.95)
  IN3 w0.066: v5(28.73,112) 28.73,112.05 30.48,113.8 32.7,113.8 32.94,114.04 33.41,114.04 34.18,114.82 v4(34.8,114.82)
JUSBC1_GND:
  vias: v2(3,34.77)
JUSBC2_GND:
  vias: v2(2.73,32.49)
K52: length 1.3
  TOP w0.203: UCPU1.K52 83.61,129.87 v3(83.62,129.86)
  IN2 w0.203: v3(83.62,129.86) v4(83.62,129.48)
  IN3 w0.203: v5(83.74,129.86) 83.62,129.73 v4(83.62,129.48)
KICKSTD_SW_DET#: length 149.3
  IN3 w0.066: v5(19.17,73.7) 19.75,73.13 20.95,73.13 21.53,73.7 v5(22.02,73.7) 22.53,73.19 42.68,73.19 47.76,68.11 66.85,68.11 v6(67.58,68.84) ; v6(62.84,97.97) 62.58,98.23 61.99,98.23 59.68,100.55 57.58,100.55 v6(56.43,101.69) 55.74,101.69 50.19,107.24 45.84,107.24 45.36,107.72 44.26,107.72 39.45,112.54 39.45,113.4 38.53,114.31 37.24,114.31 v6(37.11,114.19) ; v6(36.63,119.67) 36.63,120.17 35.88,120.92 32.54,120.92 31.58,121.88 29.51,121.88 28.74,122.65 27.71,122.65 v5(27.43,122.37)
  IN4 w0.066: v6(67.58,68.84) 67.58,79.07 65.43,81.22 65.43,82.68 63.65,84.47 63.65,89.02 62.99,89.68 62.99,90.87 62.96,90.9 62.96,97.85 v6(62.84,97.97) ; v6(37.11,114.19) 37.01,114.29 37.01,115.79 37.22,116 37.22,117.12 36.7,117.63 36.7,119.52 36.63,119.6 v6(36.63,119.67) ; v13(55.95,111.16) 55.95,110.84 56.4,110.39 56.4,108.88 57.16,108.12 57.16,106.82 56.11,105.77 56.11,102.28 56.43,101.95 v6(56.43,101.69)
  BOTTOM w0.112: v9(17.91,74.6) 18.81,73.7 v5(19.17,73.7) ; v5(27.43,122.37) 27.57,122.42 27.67,122.42 RE118.2 27.7,122.2 27.41,121.91 27.41,121.36 27.69,121.08 RE119.1 ; v5(22.02,73.7) 23.11,73.7 R488.2
KICKSTD_SW_DET#_PCH: length 7.2
  IN1 w0.066: v10(56.64,111.06) 56.52,111.19 56.52,113.22 56.85,113.55 57.35,113.55 57.73,113.93 v8(57.73,114.15)
  IN2 w0.066: v10(56.64,111.06) 56.39,110.81 v4(56.39,110.56)
  IN3 w0.066: v4(56.39,110.56) 56.39,110.81 v5(56.52,110.94)
  BOTTOM w0.112: RC391.1 57.62,111.88 D109.2 57.3,110.94 v5(56.52,110.94)
KICKSTD_SW_DET#_R: length 11.2
  IN3 w0.066: v5(26.95,119.95) 26.82,120.08 25.66,120.08 24.7,121.05 22.9,121.05 v5(22.82,120.97)
  BOTTOM w0.076: UE3.L11 22.61,117.09 22.61,117.72 22.36,117.97 22.35,117.97 22.04,118.29 22.04,118.54 21.79,118.79 21.79,118.86 21.55,119.1 21.55,119.32
  BOTTOM w0.112: v5(22.82,120.97) 22.82,120.25 22.47,119.89 21.72,119.89 21.55,119.72 21.55,119.32 ; v5(26.95,119.95) 27.05,119.95 27.47,120.37 RE119.2
LAN_WAKE#: length 84
  TOP w0.074: UCPU1.AM15 62.28,118.56 v7(62.61,118.23)
  IN3 w0.066: v6(37.01,130.37) 37.34,130.37 37.39,130.32 40.39,130.32 40.88,129.82 43.48,129.82 46.34,126.96 46.34,124.62 47.09,123.86 47.09,123.38 47.98,122.49 50.06,122.49 50.59,121.96 55.43,121.96 56.15,121.24 57.15,121.24 58.63,119.75 60.08,119.75 60.6,120.28 61.68,120.28 61.98,119.98 61.98,119 62.61,118.37 v7(62.61,118.23) ; v5(22.33,110.4) 22.77,109.96 25.27,109.96 26,109.23 26.33,109.23 26.45,109.12 27.9,109.12 28.17,108.85 28.91,108.85 29.62,109.56 29.62,109.84 32.05,112.27 35.38,112.27 38.43,109.22 39.2,109.22 40.46,107.96 v6(40.56,107.96)
  IN4 w0.066: v6(40.56,107.96) 40.54,107.96 40.41,108.09 40.41,115.94 39.83,116.52 39.83,117.21 39.83,120.91 39.76,120.98 39.76,123 38.3,124.47 38.3,124.71 37.54,125.46 37.54,126.94 37.08,127.4 37.08,129.51 37.01,129.59 v6(37.01,130.37)
  BOTTOM w0.112: v7(62.61,118.23) 62.29,118.56 61.49,118.56 v2(61.39,118.66) 61.16,118.89 61.16,118.91 60.8,119.27 60.17,119.27 RC143.2
LCD_POWER_20V: length 0.9
  TOP w0.508: PR104.1 PC112.1
  vias: v2(31.61,33.43) v3(81.66,80.11) v3(81.66,79.81) v3(81.66,79.5) v3(81.94,80.11) v3(81.94,79.81) v3(81.94,79.5) v4(82.12,66.36) v4(82.52,67.1) v4(82.52,66.61) v7(54.74,31.18) v7(54.76,30.6) v7(54.79,29.94) v7(63.73,64.61) v7(63.68,63.95) v7(63.7,63.36) v8(38.81,32.02) v8(38.81,31.71) v8(38.81,31.36) v8(39.14,32.04) v8(39.14,31.69) v8(39.14,31.33) v10(81.84,67.35) v10(81.79,67.07) v10(81.81,66.77) v10(82.12,67.4) v10(82.07,67.07) v10(82.09,66.77)
LCD_TST: length 151.9
  IN2 w0.066: v3(85.1,38.2) v4(84.77,38.2)
  IN3 w0.066: v4(84.77,38.2) 84.42,38.55 82.95,38.55 79.81,41.69 65.75,41.69 62.56,38.49 58.55,38.49 v6(58.55,38.5) ; v6(22.1,79.11) 22.89,79.11 23.11,79.34 35.69,79.34 37.47,81.12 43.61,81.12 45.19,79.54 50.8,79.54 51.46,78.88 58.39,78.88 v6(58.52,79.01) ; v5(16.84,111.83) 16.99,111.83 18.05,110.77 19.97,110.77 21.14,109.6 v5(21.53,109.6)
  IN4 w0.066: v6(58.55,38.5) 58.27,38.77 58.27,42.23 58.7,42.66 58.7,76.87 58.52,77.05 v6(58.52,79.01) ; v5(16.84,111.83) 16.84,111.67 16.23,111.06 16.23,109.79 14.98,108.55 14.98,107.73 14.77,107.52 14.77,107.21 14.94,107.05 14.94,105.65 14.75,105.46 14.75,104.89 14.94,104.7 14.94,104.01 14.43,103.5 14.43,97.42 16.54,95.32 16.54,95.16 18.49,93.2 18.49,89.93 18,89.44 18,82.8 21.69,79.11 v6(22.1,79.11)
LCD_VCC_TEST_EN: length 135.6
  TOP w0.112: v3(37.85,23.31) 37.7,23.45 D60.3
  IN2 w0.066: v4(40.41,26.15) 40.41,25.87 v3(37.85,23.31) ; v4(11.51,110.38) 11.73,110.15 11.73,100.22 14.35,97.6 14.35,93.44 15.57,92.22 15.57,88.3 16,87.87 16,76.7 16.57,76.13 16.57,51.27 21.79,46.05 21.79,44.55 22.8,43.53 22.8,34.8 19.94,31.94 v4(19.94,28.94)
  IN3 w0.066: v4(40.41,26.15) 40.16,26.4 36.42,26.4 33.73,29.1 27.21,29.1 26.81,29.49 24.3,29.49 23.78,28.97 19.99,28.97 19.96,28.94 v4(19.94,28.94) ; v5(28.42,106.73) 28.41,106.75 26.95,106.75 26.85,106.84 26.57,106.84 26.44,106.84 26.26,106.67 24.26,106.67 23.47,107.46 23.02,107.46 22.17,107.46 21.68,107.95 20.35,107.95 19.98,107.58 19.61,107.58 18.89,108.3 14.35,108.3 12.27,110.38 v4(11.51,110.38)
  BOTTOM w0.076: 27.64,108.08 27.63,108.08 27.51,108.2 27.45,108.2 27.13,108.52 UE3.E1
  BOTTOM w0.112: v5(28.42,106.73) 28.42,107.29 27.64,108.08
LDO_1.0VA: length 1.4
  TOP w0.112: PC712.1 v2(132.82,144.39)
LDO_IN: length 72.6
  IN4 w0.508: 35.31,22.8 36.26,21.85 44.16,21.85 44.55,22.24 44.55,23.09 44.37,23.27 44.37,35.52 42.5,37.4 42.5,47.02 41.78,47.74 36.91,47.74 33.88,50.77 30.53,50.77 30.03,50.27 20.36,50.27 19.43,49.34 15.62,49.34 14.12,47.84 v7(14.12,47.79)
  BOTTOM w0.508: v7(14.12,47.79) 15.04,48.71 17.09,48.71 18.01,49.62 PR149.1
  vias: v3(34.42,23.81) v3(34.67,23.81) v4(34.29,23.43) v6(34.54,23.18) v6(34.67,23.43)
LED_IFB1: length 60.3
  TOP w0.203: PU400.7 76.32,81.7 76.47,81.85 v3(76.47,82.08) 76.47,83 77.22,83.75 77.22,85.55 76.85,85.92 PC408.1
  IN1 w0.066: v10(82.7,39.1) 83.09,38.71 83.09,33.71 v8(85.1,31.7)
  IN2 w0.066: v10(82.7,39.1) 82.19,39.61 82.19,42.39 80.54,44.04 80.54,50.42 80.97,50.85 80.97,64.53 80.14,65.36 80.14,69.08 80.97,69.91 80.97,72.95 78.99,74.93 78.99,79.56 v3(76.47,82.08)
LED_IFB2: length 58.7
  TOP w0.203: PC409.1 75.77,83.12 75.42,83.12 v3(75.42,83.12) 75.31,83.12 75.11,82.92 PU400.8
  IN1 w0.066: v10(82.68,39.5) 83.26,38.91 83.26,34.04 v8(85.1,32.2)
  IN2 w0.066: v3(75.42,83.12) 75.81,83.12 79.16,79.78 79.16,75 81.14,73.02 81.14,69.84 80.31,69.01 80.31,65.43 81.14,64.6 81.14,50.78 80.71,50.35 80.71,44.11 82.36,42.46 82.36,39.82 v10(82.68,39.5)
LED_IFB3: length 58.1
  TOP w0.203: PC410.1 v3(75.38,83.62) 74.71,82.95 PU400.9
  IN1 w0.066: v10(82.68,39.88) 83.43,39.13 83.43,34.37 v8(85.1,32.7)
  IN2 w0.066: v3(75.38,83.62) 75.55,83.62 76.63,82.54 79.32,79.85 79.32,75.07 81.3,73.09 81.3,69.77 80.47,68.94 80.47,65.5 81.3,64.67 81.3,50.71 80.88,50.28 80.88,44.17 82.52,42.53 82.52,40.03 v10(82.68,39.88)
LED_IFB4: length 58.2
  TOP w0.203: PU400.10 74.31,82.98 74.93,83.6 v3(74.93,84.06)
  IN1 w0.066: v8(85.1,33.2) 83.59,34.71 83.59,39.33 v10(83.07,39.86)
  IN2 w0.066: v10(83.07,39.86) 82.69,40.23 82.69,42.6 81.05,44.24 81.05,50.21 81.47,50.64 81.47,64.74 80.64,65.57 80.64,68.87 81.47,69.7 81.47,73.16 79.49,75.14 79.49,79.91 76.8,82.61 75.34,84.06 v3(74.93,84.06)
LED_IFB5: length 58.9
  TOP w0.203: PU400.12 73.51,83.53 v3(74.04,84.06)
  IN1 w0.066: v10(83.44,39.86) 83.76,39.54 83.76,35.04 v8(85.1,33.7)
  IN2 w0.066: v10(83.44,39.86) 82.86,40.44 82.86,42.67 81.21,44.31 81.21,50.14 81.64,50.57 81.64,64.81 80.81,65.64 80.81,68.73 81.64,69.56 81.64,73.23 79.66,75.21 79.66,79.98 76.96,82.68 75.32,84.32 74.3,84.32 v3(74.04,84.06)
LED_IFB6: length 59.4
  TOP w0.203: PU400.13 73.11,84.02 v3(73.15,84.06)
  IN1 w0.066: v8(85.1,34.2) 83.93,35.37 83.93,39.77 v10(83.12,40.58)
  IN2 w0.066: v3(73.15,84.06) 73.58,84.49 75.39,84.49 77.13,82.75 77.13,82.75 79.83,80.05 79.83,75.28 81.81,73.3 81.81,69.49 80.98,68.66 80.98,65.71 81.81,64.88 81.81,50.5 81.38,50.07 81.38,44.38 83.12,42.64 v10(83.12,40.58)
LED_IFB7: length 60
  IN1 w0.066: v10(83.5,40.58) 84.1,39.98 84.1,35.7 v8(85.1,34.7)
  IN2 w0.066: v3(71.3,85.92) 72.39,84.83 75.53,84.83 77.47,82.89 80.16,80.19 80.16,75.42 82.14,73.44 82.14,69.35 81.31,68.52 81.31,65.85 82.14,65.02 82.14,50.36 81.72,49.93 81.72,44.52 83.73,42.51 83.73,40.81 v10(83.5,40.58)
LED_IFB8: length 60.7
  IN1 w0.066: v8(85.1,35.2) 84.26,36.04 84.26,40.19 83.49,40.96 v10(83.47,40.96)
  IN2 w0.066: v3(69.39,84.39) 69.66,84.66 75.46,84.66 77.3,82.82 79.99,80.12 79.99,75.35 81.97,73.37 81.97,69.42 81.15,68.59 81.15,65.78 81.97,64.95 81.97,50.43 81.55,50 81.55,44.45 83.47,42.53 v10(83.47,40.96)
LED_PWM: length 10.3
  TOP w0.112: v2(81.31,84.49) 81.31,83.62 v8(80.4,82.72)
  TOP w0.203: PU400.1 76.83,79.3 76.97,79.45 v8(77.64,79.45)
  IN1 w0.254: v8(77.64,79.45) 78.27,78.82 v8(79.45,78.82) 79.45,81.76 v8(80.4,82.72)
LED_SD: length 2.7
  TOP w0.254: PR408.1 PC411.1 PR409.1 PR407.2
LED_SOURCE: length 6.9
  TOP w0.112: PC283.1 31.88,21.08 PU105.4 ; PC283.1 31.88,22.59 PR137.1 32.46,23.18 33.27,23.18 PR253.1 33.63,22.82 PR119.2 ; PC283.1 31.62,22.16 30.77,21.31 PR272.1 30.73,21.11 PR249.2
LED_SW:
  vias: v2(70.47,76.6)
LID_CL_SIO#: length 164.2
  TOP w0.112: JIO1.24 133.65,93.57 133.32,93.89 130.91,93.89 v9(130.9,93.91) 130.74,94.06 129.94,94.06 128.63,92.75 v7(128.63,92.11)
  IN3 w0.066: v6(39.42,87.4) 39.42,87.39 39.45,87.42 42.07,87.42 45.04,84.44 46.23,84.44 48.14,82.53 65.64,82.53 66.75,81.42 v6(68.58,81.42)
  IN4 w0.066: v7(128.63,92.11) 128.63,92.47 127.84,93.26 126.42,93.26 126.06,93.61 123.82,93.61 123.19,92.98 113.9,92.98 109.87,88.95 95.04,88.95 94.58,89.4 78.5,89.4 74.54,85.44 70.7,85.44 69.89,84.63 69.58,84.63 69.19,84.25 69.19,83.35 68.76,82.93 68.43,82.93 68.02,82.52 68.02,81.98 v6(68.58,81.42) ; v1(20.7,116.78) 20.38,117.1 20.38,117.55 21.83,119 22.29,119 22.41,118.88 25.79,118.88 27.84,116.83 27.84,116.83 28.5,116.83 28.52,116.84 29.14,116.84 30.59,118.3 30.59,119.54 30.86,119.81 31.33,119.81 31.53,119.6 31.53,119.57 31.68,119.42 31.68,119.3 31.68,118.87 33.29,117.26 33.29,116.93 34.06,116.16 34.06,114.26 34.59,113.72 34.59,113.21 35.84,111.97 35.84,108.99 36.04,108.79 36.04,108.31 35.88,108.15 35.88,107.87 36.25,107.51 36.25,103.67 36.35,103.56 36.35,102.66 36.35,102.65 36.6,102.4 36.6,102.4 37.11,101.89 37.11,99.76 38.02,98.85 38.02,97.04 39,96.06 39,93.14 39.26,92.88 39.26,91.22 38.25,90.21 38.25,88.25 39.11,87.4 v6(39.42,87.4)
  BOTTOM w0.076: 19.81,118.05 20.32,117.54 20.32,117.16 v1(20.7,116.78)
  BOTTOM w0.112: UE3.N11 v1(20.7,116.78) ; RE115.2 17.5,118.68 17.69,118.5 19.36,118.5 19.81,118.05
LINE1-L: length 21.1
  IN3 w0.254: v5(10.6,157.93) 11.24,157.29 15.35,157.29 22.52,150.12 25.09,150.12 26.1,151.13 v5(26.1,151.13)
  BOTTOM w0.112: v2(11.04,156.96) 10.6,157.39 v5(10.6,157.93)
  BOTTOM w0.203: v5(26.1,151.13) 25.91,150.94 UA1.34
LINE1-R: length 21.5
  IN3 w0.254: v5(25.51,151.26) 24.88,150.62 22.73,150.62 15.56,157.8 11.52,157.8 10.93,158.38 10.05,158.38 v5(9.59,157.93)
  BOTTOM w0.112: v5(9.59,157.93) 9.59,157.29 v2(9.25,156.95)
  BOTTOM w0.203: UA1.33 v5(25.51,151.26)
LX_1.0VA: length 4.8
  IN2 w0.508: v7(128.14,142.43) 128.14,138.86 v3(127.88,138.6)
  BOTTOM w0.112: v2(128.59,141.77) 128.14,142.22 v7(128.14,142.43)
  vias: v7(127.51,142.43)
LX_PRIM:
  vias: v7(46.99,144.85) v7(46.99,144.27)
LX_VCCIO: length 0.8
  BOTTOM w0.112: v7(121.09,127.07) v2(121.09,127.89)
  vias: v7(120.46,127.07)
M2280_PCIE_SATA#: length 63.8
  TOP w0.076: UCPU1.H2 54.94,130.65 54.67,130.92 53.34,130.92
  TOP w0.112: R66.1 55.99,87.85 v3(55.41,87.27) ; v12(51.94,131.09) 52.12,130.92 53.34,130.92
  GND1 w0.066: v12(51.94,131.09) v4(51.94,131.76)
  IN2 w0.066: v3(55.41,87.27) v4(55.41,86.87)
  IN3 w0.066: v4(51.94,131.76) 51.82,131.76 51.75,131.83 v6(51.44,131.83) ; v6(53.89,87.67) 54.68,86.88 55.4,86.88 v4(55.41,86.87)
  IN4 w0.066: v6(53.89,87.67) 53.89,88.2 53.33,88.76 v1(53.33,90.49) 53.29,90.53 53.29,93.04 51.92,94.42 51.92,101.07 51.26,101.73 51.26,105.17 50.4,106.03 50.4,114.98 49.74,115.65 49.74,116.26 48.39,117.6 48.39,120.13 47.49,121.02 46.63,121.02 46.47,121.18 46.47,121.51 45.9,122.09 45.9,123.52 45.71,123.71 45.71,123.92 46,124.21 46,127.93 48.99,130.92 48.99,130.93 49.19,131.14 49.21,131.14 49.43,131.36 50.97,131.36 v6(51.44,131.83)
  BOTTOM w0.112: v1(53.33,90.49) 53.18,90.34 51.24,90.34 RC195.1 51.09,91 v2(50.76,91.33)
M3042_PCIE#_SATA: length 92.3
  TOP w0.076: UCPU1.G4 55.93,131.33 55.63,131.64 53.34,131.64
  TOP w0.112: 53.34,131.64 v8(52.6,131.64)
  IN1 w0.066: v8(52.6,131.64) 52.48,131.64 52.32,131.48 52.32,131.17 52.2,131.06 52.2,130.4 52.12,130.32 52.12,128.79 51.9,128.58 48.25,128.58 46.46,130.37 44.1,130.37 v10(42.7,131.76)
  IN2 w0.066: v4(42.38,131.93) 42.59,131.71 42.7,131.71 v10(42.7,131.76)
  IN3 w0.066: v6(41.22,104.02) 40.75,104.02 40.36,104.41 40.36,104.61 40.09,104.88 39.78,104.88 39.44,105.22 37.82,105.22 37.67,105.37 37.28,105.37 37.16,105.48 35.35,105.48 34.36,104.49 33.47,104.49 33.47,104.49 32.95,103.97 32.46,103.48 31.36,103.48 30.54,104.3 29.36,104.3 27.67,106 26.45,106 26.28,106.17 24.05,106.17 23.26,106.96 22.25,106.96 22.2,106.91 19.33,106.91 18.8,107.45 v6(17.25,107.45) ; v6(38.53,131.32) 41.2,131.32 41.83,131.96 42.35,131.96 v4(42.38,131.93)
  IN4 w0.066: v1(23.55,116.4) 23.37,116.4 22.78,115.81 22.25,115.81 21.82,115.38 21.82,115.05 21.64,114.87 21.13,114.87 20.68,114.42 20.68,113.74 19.42,112.48 19.42,109.86 17.25,107.69 v6(17.25,107.45) ; v6(41.22,104.02) 41.01,104.23 41.01,107.97 40.72,108.27 40.72,112.74 41,113.02 41,116.76 40.43,117.32 40.43,120.31 41.39,121.26 41.39,122.68 39.29,124.79 39.29,126.26 39.12,126.43 39.12,127.19 38.84,127.47 38.84,129.76 38.53,130.06 v6(38.53,131.32)
  BOTTOM w0.076: UE3.J12 23.62,117.3 23.62,116.47 v1(23.55,116.4)
ME_FWP: length 15.7
  IN4 w0.066: v1(28.45,127.7) 28.45,127.67 27.88,127.1 27.88,126.47 26.92,125.52 v1(26.92,124.83)
  BOTTOM w0.076: 25.9,119.32 25.9,119.13 25.82,119.05 25.82,117.9 UE3.G12
  BOTTOM w0.112: RE54.1 27.42,122.77 RE61.2 ; RE61.2 26.78,122.33 26.6,122.14 26.6,120.38 25.9,119.69 25.9,119.32 ; RE61.2 26.97,122.82 26.66,123.13 26.66,123.76 26.59,123.83 26.59,124.5 v1(26.92,124.83) ; Q25.5 27.88,127.98 28.15,127.7 v1(28.45,127.7) 28.57,127.83 28.57,128.11 R5774.1
ME_RESET#: length 2.5
  BOTTOM w0.112: RC97.2 RC96.1 UC3.2
ME_SUS_PWR_ACK: length 53.9
  TOP w0.074: UCPU1.AR13 60.79,116.19 v7(60.73,116.19)
  IN3 w0.066: v5(29.53,118.4) 29.81,118.12 32.27,118.12 32.4,118.25 40.14,118.25 42.11,116.27 42.11,112.27 44.34,110.04 44.71,109.66 49.6,109.66 53.7,105.56 53.88,105.56 54.32,105.13 58.51,105.13 58.88,104.76 v6(59.31,104.76)
  IN4 w0.066: v6(59.31,104.76) 59.63,105.08 59.63,107.71 59.9,107.98 59.9,110.61 60.38,111.09 60.38,115.22 60.32,115.28 60.32,115.77 v7(60.73,116.19)
  BOTTOM w0.112: RC162.2 58.88,114.77 59.09,114.99 59.92,114.99 60.31,115.38 60.31,115.77 v7(60.73,116.19)
MEC_XTAL1: length 6
  BOTTOM w0.076: UE3.A1 30.04,109.09 30.04,109.72 30.21,109.89 30.89,109.89 31.18,109.6 31.24,109.6
  BOTTOM w0.112: Y2.1 34.04,109.46 33.9,109.6 CE12.1 31.24,109.6
MEC_XTAL2: length 4.5
  BOTTOM w0.076: UE3.A3 30.66,110.4 30.76,110.3 31.24,110.3
  BOTTOM w0.112: Y2.2 34.04,110.62 33.9,110.48 32.52,110.48 CE11.1 32.32,110.3 31.24,110.3
MEDIACARD_IRQ#: length 108.1
  IN4 w0.066: v1(48.6,125.31) 48.6,124.08 49.49,123.2 49.79,123.2 50.03,122.96 50.03,122.67 51.92,120.77 51.92,117.99 52.34,117.57 52.34,116.08 52.71,115.72 52.71,110.81 53.21,110.3 53.21,109.18 53.64,108.75 53.64,106.76 55.1,105.3 55.1,101.78 55.27,101.61 55.27,99.65 57.59,97.33 57.59,92.06 58.02,91.63 58.02,88.37 58.54,87.85 58.54,84.02 59.26,83.3 59.26,45.04 59.68,44.62 59.68,38.08 59.4,37.8 59.4,32.78 62.48,29.71 v1(65.34,29.71)
  BOTTOM w0.112: RC199.2 RC197.2 48.68,125.31 v1(48.6,125.31) ; RR12.1 65.63,28.44 65.34,28.73 v2(65.34,28.81) v1(65.34,29.71)
MEM_CONFIG0: length 13.4
  TOP w0.076: 52.45,116.39 52.62,116.39 52.75,116.26 53.42,116.26 53.64,116.49 54.13,116.49 54.37,116.73 UCPU1.AP2
  TOP w0.112: RH17.1 42.8,116.84 43.56,116.84 44.05,117.33 RH18.2 44.89,117.33 v2(44.95,117.28) 44.98,117.24 45.24,117.24 45.33,117.33 45.4,117.33 45.4,117.33 47.15,117.33 47.15,117.33 47.3,117.18 48.61,117.18 49.4,116.39 52.45,116.39
MEM_CONFIG1: length 13.9
  TOP w0.076: 52.45,116.7 52.6,116.7 52.83,116.93 52.83,117.33 53.1,117.59 53.41,117.59 53.72,117.29 53.72,117.16 53.98,116.9 UCPU1.AP1
  TOP w0.112: 52.45,116.7 49.54,116.7 v2(49.21,117.04) 48.84,117.41 47.37,117.41 47.24,117.54 45.44,117.54 44.55,118.43 RH16.2 43.96,118.43 43.45,117.92 42.81,117.92 RH15.1
MEM_CONFIG2: length 14.8
  TOP w0.076: 52.45,117.16 53.03,117.75 53.47,117.75 53.87,117.35 53.87,117.23 54.13,116.97 54.8,116.97 55.04,116.73 UCPU1.AP3
  TOP w0.112: RH12.1 RH13.2 43.68,118.94 44.48,118.94 45.61,117.81 47.27,117.81 47.46,117.62 49.12,117.62 49.7,117.04 v2(51.14,117.04) 52.33,117.04 52.45,117.16
MEM_CONFIG3: length 15.8
  TOP w0.076: UCPU1.AN3 55.34,117.12 54.19,117.12 54.02,117.29 54.02,117.41 53.53,117.9 52.73,117.9 52.45,117.62 52.45,117.46
  TOP w0.112: 52.45,117.46 52.34,117.35 49.71,117.35 49.22,117.84 47.55,117.84 47.26,118.12 v2(46.39,118.12) 45.64,118.12 44.5,119.26 44.5,119.9 44.39,120.02 43.61,120.02 RH10.2 RH9.1
MIC2-VREFO-L: length 14.5
  IN4 w0.254: v1(12.83,158.27) 13.34,157.76 17.24,157.76 22.73,152.27 v1(22.73,151.72)
  BOTTOM w0.203: v1(22.73,151.72) 22.96,151.72 v2(23.11,151.57) UA1.27
MIC2-VREFO-R: length 17
  IN4 w0.254: v1(14.22,158.27) 17.45,158.27 23.25,152.47 23.25,151.25 v1(23.43,151.07)
  BOTTOM w0.127: v2(16.52,159.96) 16.52,159.23 15.56,158.27 v1(14.22,158.27)
  BOTTOM w0.203: v1(23.43,151.07) 23.51,150.99 UA1.28
MONO_IN: length 1.4
  BOTTOM w0.112: UA1.32 25.11,151.57 CA14.2
MSCLK: length 42.5
  TOP w0.112: v2(35.95,88.46) 35.57,88.84 RE4.2 34.95,89 34.95,89.78 35.24,90.07 35.8,90.07 36,89.87 v3(36.14,89.87) 36.14,90.06 36.71,90.62 JDEG3.6
  IN2 w0.066: v4(36.42,90.54) 36.42,90.15 v3(36.14,89.87)
  IN3 w0.066: v4(36.42,90.54) 36.88,90.54 v6(37.08,90.34)
  IN4 w0.066: v1(24.73,116) 25.72,116 26.15,115.57 26.64,115.57 26.81,115.41 27.92,115.41 28.25,115.74 28.84,115.74 29.26,116.17 30.1,116.17 30.35,115.91 30.35,115.2 30.1,114.95 29.88,114.95 29.54,114.62 29.54,111.82 29.88,111.49 29.88,108.42 31.36,106.93 31.58,106.93 31.85,106.66 32.02,106.66 32.59,106.1 33.4,106.1 33.83,105.67 33.83,102.8 34.58,102.06 34.58,99.03 35.99,97.62 35.99,96.42 36.95,95.46 36.95,91.64 36.95,91.54 36.89,91.49 36.89,90.53 v6(37.08,90.34)
MSDATA: length 35.8
  TOP w0.112: JDEG3.7 36.21,90.6 36.01,90.4 34.94,90.4 v2(34.23,89.69) 34.23,89.36 34.49,89.09 RE2.2 RE3.2 v3(32.92,89.78)
  IN2 w0.066: v3(32.92,89.78) 32.89,89.8 32.6,89.8 v4(32.59,89.79)
  IN3 w0.066: v6(32.47,89.46) 32.47,89.68 v4(32.59,89.79)
  IN4 w0.066: v6(32.47,89.46) 32.38,89.55 32.38,96.43 32.58,96.63 32.58,99.84 31.6,100.83 31.6,101.81 31.02,102.39 31.02,104.26 31.14,104.38 31.14,104.74 30.56,105.32 30.21,105.32 28.68,106.85 28.68,107.08 28.19,107.57 28.19,108.49 28.32,108.63 28.32,109.69 28.15,109.85 28.15,110.73 27.56,111.32 v1(27.56,111.62)
  BOTTOM w0.076: UE3.G9 25.83,114.9 25.83,114.64 25.83,114.63 25.83,114.43 25.83,114.42 25.83,114.28 26.21,113.9 26.44,113.9 26.69,113.65 26.69,113.42 26.96,113.15 27.2,113.15 27.48,112.87 27.48,111.7 v1(27.56,111.62)
MUX1_ADDR: length 4.3
  BOTTOM w0.112: UV1.3 21.5,43.59 20.45,44.64 RV5.1 20.43,44.95 19.95,45.43 19.95,46.2 RV6.1
MUX1_CEXT: length 5.6
  BOTTOM w0.112: RV61.2 RV19.1 CV61.1 v2(18.75,43.98) 18.86,43.87 20.46,43.87 20.7,43.63 UV1.1
MUX1_CSCL: length 19.3
  TOP w0.112: v3(29.92,39.23) 30.23,38.93 RV91.1 29.72,38.29 QC2.1
  IN2 w0.066: v4(29.92,42.05) v3(29.92,39.23) 29.92,39.1 29.6,38.79 29.6,36.81 v4(30.18,36.23)
  IN3 w0.066: v4(30.18,36.23) 29.57,35.63 v5(26.92,35.63) ; v4(29.92,42.05) 28.92,42.05 28.13,42.84 v5(28.13,43.79)
  BOTTOM w0.112: UV1.21 23.5,36.3 RV57.2 v2(26.25,35.41) 26.71,35.41 v5(26.92,35.63)
MUX1_CSDA: length 22.2
  TOP w0.112: QC2.4 31.62,36.48 v3(31.62,35.63)
  IN2 w0.066: v4(26.29,34.61) 26.16,34.61 25.41,35.36 25.41,42.94 v4(25.5,43.03) ; v3(31.62,35.63) v4(31.62,35.24)
  IN3 w0.066: v5(25.86,43.46) 25.86,43.38 v4(25.5,43.03) ; v5(25.03,34.06) 25.74,34.06 v4(26.29,34.61) 30.99,34.61 v4(31.62,35.24)
  BOTTOM w0.112: v5(25.03,34.06) 24.92,33.95 v2(24.47,33.95) 24.03,34.39 24.03,35.13 23.75,35.41 RV58.2 23.69,35.69 23.1,36.28 UV1.22
MUX1_I2C_EN: length 9.5
  IN3 w0.066: v5(19.3,36.76) 17.39,36.76 15.86,35.23 v5(15.86,33.59)
  BOTTOM w0.112: UV1.29 19.52,38 19.43,37.91 19.43,37.12 19.3,37 v5(19.3,36.76) ; v2(14.92,33.72) 15.05,33.59 v5(15.86,33.59) RV13.1
MUX1_REXT: length 5.4
  BOTTOM w0.112: UV1.2 21.1,43.61 20.26,44.45 19.16,44.45 RV7.1 19.11,45.39 19.11,45.66 19.35,45.9 RV76.2 RV75.1
MUX1_TUSB_DPEQ0: length 8.7
  IN3 w0.066: v5(24.83,40.48) 24.83,40.92 27.26,43.36 v5(27.53,43.36)
  BOTTOM w0.112: v5(27.53,43.36) 27.37,43.36 27.18,43.55 27.18,44.62 RV78.2 27.25,45.25 27.19,45.25 RV77.1 27.06,45.66 27.55,45.66 v2(27.75,45.86) ; UV1.14 24.75,40.4 v5(24.83,40.48)
MUX1_TUSB_SSEQ0: length 6.4
  IN3 w0.066: v5(26.91,43.41) 26.9,43.41 25.23,41.73 v5(24.92,41.73)
  BOTTOM w0.112: RV80.2 25.79,45.51 RV79.1 26.35,45.5 26.85,45.01 26.85,43.45 26.9,43.4 26.9,43.41 v5(26.91,43.41) ; v5(24.92,41.73) 24.78,41.6 UV1.11
MUX2_ADDR: length 4
  BOTTOM w0.112: UV2.3 21.63,29.54 21.05,30.12 21.05,31.26 20.93,31.38 RV31.1 RV32.1
MUX2_CEXT: length 5.7
  BOTTOM w0.112: UV2.1 20.82,29.29 20.71,29.4 19.88,29.4 18.8,30.48 RV62.2 CV62.1 RV43.1
MUX2_CSCL: length 20.6
  TOP w0.112: v3(32.11,27.88) 32.13,27.85 v2(32.13,27.37) 32.13,27.28 31.04,26.19 RV59.2 30.38,25.83 QC3.1 29.03,24.96 RV93.1
  IN2 w0.066: v4(32.44,27.85) 32.41,27.88 v3(32.11,27.88)
  IN3 w0.066: v4(32.44,27.85) 33.13,27.16 33.13,23.13 32.75,22.75 v5(26.47,22.75)
  BOTTOM w0.112: v5(26.47,22.75) 25.35,22.75 24.71,22.11 23.83,22.11 23.77,22.16 23.77,22.21 23.63,22.36 UV2.21
MUX2_CSDA: length 23.6
  TOP w0.112: RV60.2 27.52,27.41 27.8,27.13 QC3.4 28.54,27.66 RV94.1 28.54,28.26 28.78,28.5 30.04,28.5 v2(30.3,28.23) 30.61,27.93 v3(30.63,27.93)
  IN2 w0.066: v3(30.63,27.93) v4(31.01,27.93)
  IN3 w0.066: v4(31.01,27.93) 31.32,28.23 32.56,28.23 33.32,27.47 33.32,23.03 32.79,22.49 26.81,22.49 v5(26.47,22.15)
  BOTTOM w0.112: v5(26.47,22.15) 25.13,22.15 24.77,21.78 24.5,21.78 24.41,21.87 23.73,21.87 23.72,21.87 23.66,21.87 23.42,22.11 23.42,22.16 23.22,22.36 UV2.22
MUX2_I2C_EN: length 3.4
  BOTTOM w0.112: UV2.29 19.72,23.65 RV40.1 RV41.1
MUX2_REXT: length 6.8
  BOTTOM w0.112: RV81.1 20.07,33.66 20.07,32.48 19.94,32.35 19.85,32.35 RV82.2 20.13,31.82 20.13,30.91 RV30.1 19.68,30.18 20.07,29.8 20.88,29.8 21.23,29.45 UV2.2
MUX2_TUSB_DPEQ0: length 6.3
  IN3 w0.066: v5(26.19,28.98) 25.51,28.31 25.51,26.58 v5(25.05,26.12)
  BOTTOM w0.112: v5(25.05,26.12) 24.98,26.05 UV2.14 ; v5(26.19,28.98) 26.59,29.39 RV83.1 RV84.2 27.98,29.41 v2(28.09,29.53)
MUX2_TUSB_SSEQ0: length 5.6
  IN3 w0.066: v5(25.06,27.25) 25.06,28.38 v5(25.67,28.98)
  BOTTOM w0.112: UV2.11 v5(25.06,27.25) ; v2(25.13,30.88) 25.08,30.82 25.08,29.65 25.31,29.41 RV86.2 RV85.1 25.98,29.3 v5(25.67,28.98)
NB_MUTE#: length 29.4
  IN4 w0.066: v1(27.52,133.89) 27.96,133.45 27.96,130.37 27.98,130.35 27.98,129.99 27.96,129.97 27.96,128.55 28.17,128.34 28.85,128.34 28.98,128.21 28.98,126.51 29.31,126.18 29.31,124.55 28.98,124.22 28.98,122.87 28.05,121.94 v1(28.05,119.76)
  BOTTOM w0.076: 28.09,119.32 28.09,118.64 28.21,118.52 28.21,118.29 28.05,118.12 28.02,118.12 27.77,117.88 27.77,117.86 27.6,117.68 27.6,116.62 27.44,116.47 27.44,114.32 27.25,114.12 27.24,114.12 26.84,113.72 26.84,113.48 27.03,113.3 27.14,113.3 27.27,113.3 27.64,112.93 27.64,112.7 27.64,112.69 27.64,112.54 27.72,112.46 28.02,112.46 28.3,112.18 28.3,112.03 28.63,111.7 29.72,111.7 30.21,111.2 UE3.A4
  BOTTOM w0.112: Q22.1 26.4,135.01 v1(27.52,133.89) ; v1(28.05,119.76) 28.09,119.72 28.09,119.32
NFC_DET#: length 5.1
  TOP w0.076: UCPU1.BA5 56.58,112.51 56.9,112.19 56.9,111.2 57.34,110.76 57.34,109.68 57.07,109.41
  TOP w0.112: RC68.2 56.87,108.8 57.07,109.01 57.07,109.41
NGFF_COEX1: length 10.7
  TOP w0.112: v3(24.7,64.13) 26.22,62.61 JNGFF3.48
  IN2 w0.066: v4(23.14,69.42) 24.09,68.47 24.09,64.74 v3(24.7,64.13)
  GND3 w0.066: v4(23.14,69.42) 23.04,69.52 v13(23.04,69.92)
NGFF_COEX2: length 10.7
  TOP w0.112: v3(24.7,64.64) 26.72,62.63 JNGFF3.46
  IN2 w0.066: v3(24.7,64.64) 24.37,64.97 24.37,68.62 23.66,69.33 v4(23.66,69.41)
  GND3 w0.066: v13(23.62,69.92) 23.66,69.88 v4(23.66,69.41)
NGFF_COEX3: length 10.7
  TOP w0.112: v3(24.7,65.09) 27.22,62.57 JNGFF3.44
  IN2 w0.066: v4(24.17,69.41) 24.17,69.19 24.63,68.73 24.63,65.16 v3(24.7,65.09)
  GND3 w0.066: v4(24.17,69.41) 24.17,69.86 v13(24.22,69.92)
NGFF_CONFIG_0: length 24.6
  TOP w0.112: JNGFF1.21 27.88,115.52 v3(27.7,115.7)
  IN2 w0.066: v4(28.5,109.21) 28.47,109.24 28.47,110.26 28.17,110.57 28.17,110.59 28.16,110.59 28.16,111.27 26.9,112.53 26.9,114.89 v3(27.7,115.7)
  IN3 w0.066: v5(20.73,115.2) 20.73,114.54 19.68,113.5 19.68,112.08 20.76,111 21.37,111 21.46,111.1 22,111.1 22.97,110.13 25.34,110.13 26.07,109.4 26.44,109.4 26.56,109.29 28.02,109.29 28.09,109.21 v4(28.5,109.21)
  BOTTOM w0.076: v5(20.73,115.2) 19.81,115.2
  BOTTOM w0.112: 19.81,115.2 19.76,115.2 19.33,115.64 RE56.2
NGFF_CONFIG_1: length 55.9
  TOP w0.112: JNGFF1.69 15.88,118.26 17.22,119.6 18.34,119.6 21.72,116.22 v3(21.72,115.74) ; U4.9 26.38,92.55 26.16,92.33 v3(26.16,92.14)
  IN1 w0.066: v10(29.81,106.34) 29.81,107.39 29.25,107.95 29.25,108 28.93,108.32 28.82,108.32 28.45,108.69 28.45,108.8 27.64,109.62 27.64,111.37 27.05,111.95 27.05,116.5 26.19,117.36 23.15,117.36 22.05,116.26 22.05,116.07 v3(21.72,115.74)
  IN2 w0.066: v10(29.81,106.34) 29.81,100.2 30.93,99.07 30.93,97.13 31.28,96.78 31.28,94.08 29.34,92.14 v3(26.16,92.14) ; v3(21.72,115.74) 21.79,115.81 21.79,116.02 v4(21.87,116.09)
  IN3 w0.066: v5(21.53,116) 21.78,116 v4(21.87,116.09)
  BOTTOM w0.076: v5(21.53,116) 21.38,116
  BOTTOM w0.112: 21.38,116 20.99,116.4 20.62,116.4 20.09,116.93 20.09,117.39 19.2,118.28 17.48,118.28 RE53.2
NGFF_CONFIG_2: length 18.2
  TOP w0.112: JNGFF1.75 14.38,117.14 17.07,119.83 18.9,119.83 v3(21.97,116.75)
  IN2 w0.066: v3(21.97,116.75) 21.64,116.75 21.51,116.63 v4(21.51,116.55)
  IN3 w0.066: v5(19.79,117.16) 20.07,116.88 20.8,116.88 21.13,116.55 v4(21.51,116.55)
  BOTTOM w0.112: UE3.N10 20.51,116 19.81,116.7 19.81,117.13 v5(19.79,117.16) 19.02,117.92 RE63.2
NGFF_CONFIG_3: length 20.1
  TOP w0.112: v2(32.59,113.22) 32.85,113.22 33.15,113.51 v3(33.15,113.63) 32.88,113.9 JNGFF1.1
  IN2 w0.066: v4(33.15,114.57) 33.17,114.57 33.32,114.42 33.32,113.81 v3(33.15,113.63)
  IN3 w0.066: v4(33.15,114.57) 33,114.42 33,114.38 32.62,114 30.4,114 30.16,113.75 30.16,113.75 28.92,112.52 28.78,112.52 28.62,112.35 28.13,112.35 26.95,111.16 26.37,111.16 v5(26.33,111.2)
  IN4 w0.066: v1(28.46,104.06) 28.15,104.06 26.79,105.42 26.79,110.35 26.62,110.51 26.62,110.91 v5(26.33,111.2)
  BOTTOM w0.112: RE40.2 28.49,104.03 v1(28.46,104.06)
NGFF_WWAN_PWREN: length 106
  IN1 w0.066: v10(55.78,129.71) 56.43,129.71 v8(56.64,129.5)
  IN2 w0.066: v4(55.91,130.01) 55.91,129.83 v10(55.78,129.71)
  IN3 w0.066: v6(49.25,127.45) 49.66,127.45 50.37,128.16 51.13,128.16 51.54,128.56 51.54,129.55 51.71,129.73 53.21,129.73 53.42,129.94 55.83,129.94 v4(55.91,130.01) ; v6(57.18,81.83) 47.89,81.83 45.79,83.94 42.92,83.94 42.85,83.86 42.57,83.86 42.5,83.94 42.2,83.94 41.35,84.78 40.04,84.78 32.96,91.86 27.81,91.86 27.23,92.44 19.62,92.44 v5(17.18,90.01)
  IN4 w0.066: v6(57.18,81.83) 57.18,82.98 56.03,84.13 56.03,90.99 55.42,91.59 55.42,94.22 53.99,95.65 53.99,97.96 53.83,98.12 53.83,105.02 52.5,106.34 52.5,108.55 52.25,108.8 52.25,109.85 51.81,110.29 51.81,115.29 51.81,115.29 51.81,115.43 51.1,116.13 51.1,116.67 51.11,116.67 51.11,116.95 50.83,117.23 50.83,118.47 50.09,119.2 50.09,120.82 48.01,122.91 48.01,126.38 49.07,127.45 v6(49.25,127.45)
  BOTTOM w0.112: D61.3 17.01,90.01 v5(17.18,90.01)
NRB_BIT: length 16.3
  TOP w0.076: UCPU1.AR7 57.55,116.61 57.55,116.44 57.94,116.05 v7(57.94,115.6)
  IN2 w0.066: v4(46.78,120.33) 46.79,120.33 46.79,120.33 46.81,120.33 46.89,120.41 v3(46.89,120.7)
  IN3 w0.066: v4(46.78,120.33) 46.97,120.14 47.31,120.14 47.73,120.55 49.08,120.55 50.29,119.34 54.82,119.34 55.62,118.55 56.53,118.55 56.65,118.42 56.65,116.71 56.96,116.4 57.47,116.4 57.94,115.93 v7(57.94,115.6)
OSC_IN: length 4.2
  BOTTOM w0.112: U12.B1 153.1,143.56 153.42,143.24 R104.1 153.57,143.27 C71.1 155.07,143.27 Y1.1
OSC_OUT: length 6.1
  BOTTOM w0.112: U12.A1 153.34,143.96 R104.2 154.41,144.16 C67.1 154.74,143.83 156.47,143.83 Y1.3
OTG_ID: length 4.6
  TOP w0.076: 52.45,121.08 54.88,121.08 55.26,120.7 UCPU1.AG3
  TOP w0.112: RC62.1 51.34,121.07 RH90.1 51.83,121.08 52.45,121.08
P_SENSOR_ACT#: length 307.7
  IN1 w0.066: v10(39.19,158.31) 32.27,151.39 32.27,142.92 29.28,139.93 v10(28.15,139.93)
  IN2 w0.066: v10(28.15,139.93) 23.84,135.62 18.33,135.62 8.28,125.56 8.28,122.19 9.57,120.89 9.57,118.05 v4(9.68,117.95) 9.96,117.67 v4(9.96,116.52) ; v10(39.19,158.31) 39.19,161.47 43.18,165.47 53.67,165.47 54.27,166.07 111.01,166.07 111.4,166.46 112.04,166.46 v4(112.38,166.12)
  IN3 w0.066: v5(19.16,113.12) 19.16,112.19 18.87,111.9 17.79,111.9 15.25,114.43 10.14,114.43 9.96,114.62 v4(9.96,116.52) ; v6(28.7,128.03) 29.51,127.22 31.07,127.22 32.17,126.13 35.79,126.13 35.79,126.12 36.15,126.12 36.91,125.36 38.51,125.36 38.84,125.03 v6(39.62,125.03) ; v4(9.68,117.95) 10.34,118.61 15.52,118.61 15.98,119.06 17.17,119.06 18.44,120.33 19.46,120.33 20.37,121.25 24.82,121.25 25.7,120.36 v6(26.67,120.36) ; v5(117.2,160.69) 117.2,161.29 v4(112.38,166.12)
  IN4 w0.066: v7(55.45,30.04) 55.78,30.37 55.78,45.62 55.48,45.91 55.48,49.94 51.14,54.28 51.14,66.44 52.69,67.99 52.69,79.55 51.1,81.14 51.1,81.68 49.65,83.13 49.65,86.91 47.88,88.68 46.96,88.68 46.19,89.44 45.25,89.44 44.41,90.29 44.41,93.06 44.67,93.32 44.67,95.56 44.41,95.82 44.41,100.27 42.21,102.47 42.21,106.97 42.21,107.6 42.21,109.76 41.6,110.38 41.6,112.22 41.84,112.47 41.84,117.84 41.86,117.86 41.86,123.13 39.96,125.03 v6(39.62,125.03) ; v6(28.7,128.03) 28.81,127.92 28.81,126.44 29.14,126.11 29.14,124.62 28.2,123.68 28.2,123.15 27.91,122.86 27.38,122.86 27.17,122.65 27.17,121.74 27.24,121.67 27.24,120.93 v6(26.67,120.36)
  BOTTOM w0.076: 19.25,113.04 19.48,112.8 UE3.N6
  BOTTOM w0.112: v7(55.45,30.04) 55.91,30.49 v2(55.91,30.62) ; U1.A2 T3.1 v5(117.2,160.69) ; 19.25,113.04 v5(19.16,113.12)
P_SYS_R: length 213.2
  IN2 w0.066: v4(106.71,163.11) 106.71,163.59 105.19,165.1 55.23,165.1 53.72,163.59 53.72,158.54 v4(53.49,158.31)
  IN3 w0.066: v6(40.38,116.67) 40.03,117.03 35.56,117.03 35.36,117.23 33.55,117.23 33.19,116.87 29.21,116.87 29.08,117.01 27.35,117.01 27.26,117.1 25.48,117.1 23.46,115.08 23.46,111.76 v6(23.69,111.53) ; v4(53.49,158.31) 53.49,158.58 v5(53.35,158.72) ; v4(106.71,163.11) v6(106.71,163.77)
  IN4 w0.066: v5(53.35,158.72) 49.66,155.03 43.16,155.03 42.09,153.95 42.09,148.99 41.02,147.92 41.02,144.01 38.39,141.39 38.39,140.96 38.4,140.95 38.4,134.76 38.61,134.56 38.61,132.58 37.85,131.81 37.85,128.57 37.85,128.57 38.01,128.42 38.01,127.39 38.71,126.68 38.71,126.28 38.89,126.1 38.89,124.63 41,122.52 41,121.63 40.39,121.02 40.39,120.94 40,120.56 40,117.28 40,117.06 v6(40.38,116.67) ; v1(139.26,124.07) 139.26,124.99 137.26,126.99 135.33,126.99 134.98,127.34 134.98,130.14 134.44,130.67 134.44,132.73 135.18,133.47 135.18,137.44 134.7,137.93 134.7,138.22 135.06,138.59 135.06,148.01 134.58,148.5 128.61,148.5 121.77,155.34 121.77,161.11 117.89,164.98 108.6,164.98 107.99,164.38 107.01,164.38 106.71,164.08 v6(106.71,163.77) ; v6(23.69,111.53) 23.69,111.08 22.47,109.86 22.47,108.68 22.6,108.55 22.61,108.55 v1(22.66,108.5)
  BOTTOM w0.076: 21.72,105.86 22.02,106.16 22.02,107.02 22.38,107.38 22.38,108.22 v1(22.66,108.5)
  BOTTOM w0.112: PR949.1 v5(53.35,158.72) ; RE125.2 21.72,105.86 ; v1(139.26,124.07) v2(140.23,124.07)
PANEL_BKEN_EC: length 110.7
  IN1 w0.066: v14(66.56,92.22) 65.79,91.46 65.79,90.09 67.82,88.06 73.69,88.06 v3(73.85,88.22)
  GND1 w0.066: v4(66.58,92.66) 66.58,92.25 v14(66.56,92.22)
  IN2 w0.066: v4(70.61,81.41) 69.13,82.89 69.13,85.45 70.21,86.53 72.16,86.53 72.65,87.02 v3(73.85,88.22)
  IN3 w0.066: v6(50.84,81.57) 50.93,81.66 56.97,81.66 57.07,81.57 57.28,81.57 57.38,81.66 60.77,81.66 62.71,79.72 69.26,79.72 69.82,80.28 69.82,80.62 v4(70.61,81.41) ; v6(41.3,117.69) 40.94,117.69 40.22,118.41 32.33,118.41 32.2,118.29 30.01,118.29 29.64,118.67 29.4,118.67 29.06,118.33 24.77,118.33 v5(24.36,117.92)
  GND3 w0.066: v4(66.58,92.66) 66.87,92.37 v13(67.17,92.37)
  IN4 w0.066: v6(50.84,81.57) 49.48,82.93 49.48,86.77 47.73,88.51 46.89,88.51 46.12,89.27 45.18,89.27 44.24,90.22 44.24,93.16 44.46,93.38 44.46,95.49 44.24,95.7 44.24,100.2 42.04,102.4 42.04,107.91 41.58,108.37 41.58,109.36 41.76,109.54 41.76,109.92 41.43,110.25 41.43,112.29 41.65,112.51 41.65,117.35 v6(41.3,117.69)
  BOTTOM w0.076: v5(24.36,117.92) 24.36,115.64 UE3.J9
  BOTTOM w0.112: v13(67.17,92.37) 66.82,92.71 D39.3 v2(66.82,95.92)
PANEL_BKLEN: length 84.5
  TOP w0.076: UCPU1.R12 60.61,126.63 v7(60.37,126.38)
  TOP w0.112: v3(68.05,89.66) 68.27,89.43 69.48,89.43 v2(69.88,89.04) 70.94,89.04 73.07,86.92 v3(73.85,86.92)
  IN2 w0.066: v3(73.85,86.92) 72.9,85.97 v4(72.19,85.97) ; v3(68.05,89.66) 68.05,90.47 v4(67.8,90.72)
  IN3 w0.066: v4(72.19,85.97) 71.89,86.27 68.38,86.27 67.27,87.37 59.1,87.37 v6(58.89,87.58) ; v6(50.24,125.87) 50.43,126.06 50.82,126.06 51,125.88 54.6,125.88 55.11,126.38 59.29,126.38 59.66,126.75 60,126.75 v7(60.37,126.38) ; v4(67.8,90.72) 66.45,90.72 v5(65.24,91.93)
  IN4 w0.066: v6(58.89,87.58) 58.89,87.74 58.18,88.44 58.18,91.7 57.75,92.13 57.75,97.4 55.44,99.72 55.44,101.68 55.27,101.85 55.27,105.62 54.53,106.36 54.53,109.44 52.88,111.09 52.88,115.78 52.51,116.15 52.51,117.68 52.09,118.1 52.09,118.15 52.09,118.29 52.09,118.29 52.09,121.38 50.11,123.36 49.56,123.36 49.1,123.82 49.1,124.53 50.24,125.67 v6(50.24,125.87)
  BOTTOM w0.112: v5(65.24,91.93) 65.24,93.52 65.52,93.8 D39.2
PBAT_SMBCLK: length 181.4
  TOP w0.112: PD104.2 140.71,100.31 v3(140.84,100.45)
  IN2 w0.066: v3(140.84,100.45) 140.43,100.45 140.37,100.38 140.37,99.96 140.07,99.67 140.07,96.42 138.52,94.87 130.46,94.87 129.07,93.47 123.42,93.47 122.69,92.73 116.48,92.73 113.53,89.79 109.49,89.79 108.9,90.38 108.9,90.62 v4(108.78,90.74)
  IN3 w0.066: v5(20.02,108.03) 19.79,108.03 19.07,108.75 14.53,108.75 12.39,110.9 10.89,110.9 9.28,112.51 9.28,116.78 10.61,118.11 15.92,118.11 16.4,118.6 17.4,118.6 18.41,119.62 19.89,119.62 20.85,120.58 24.47,120.58 25.43,119.62 29.67,119.62 30.35,118.93 31.85,118.93 31.98,119.05 40.6,119.05 42.81,116.84 42.81,112.47 44.98,110.3 49.33,110.3 49.33,110.31 49.86,110.31 53.96,106.2 54.26,106.2 54.65,105.81 59.1,105.81 59.51,105.4 62,105.4 64.32,103.08 64.32,100.01 64.32,100 64.32,99.92 74.4,89.84 79.32,89.84 80.81,91.33 94.19,91.33 94.86,91.05 107.28,91.05 107.95,90.38 108.41,90.38 v4(108.78,90.74)
  BOTTOM w0.076: v5(20.02,108.03) 20.12,108.03 20.24,108.16 20.24,109.25 20.6,109.6 UE3.N2 ; 19.91,108.03 19.86,108.03 19.57,107.74 19.57,107.42 19.25,107.1 18.75,107.1 18.12,106.47 RE38.1
  BOTTOM w0.112: 19.91,108.03 v5(20.02,108.03)
PBAT_SMBDAT: length 181.3
  TOP w0.112: v3(139.7,100.45) 139.71,100.44 PD104.3
  IN2 w0.066: v3(139.7,100.45) 140.11,100.45 140.17,100.38 140.17,100.04 139.88,99.75 139.88,96.5 138.44,95.06 130.38,95.06 128.99,93.66 123.34,93.66 122.61,92.93 116.4,92.93 113.45,89.98 109.57,89.98 109.09,90.46 109.09,90.53 v4(109.31,90.74)
  IN3 w0.066: v4(109.31,90.74) 108.75,90.19 107.87,90.19 107.2,90.86 94.82,90.86 94.15,91.14 80.89,91.14 79.4,89.65 74.32,89.65 64.13,99.84 64.13,99.92 64.12,99.93 64.12,103 61.92,105.2 59.43,105.2 59.02,105.61 54.57,105.61 54.18,106.01 53.88,106.01 49.78,110.11 49.57,110.11 44.9,110.11 42.62,112.39 42.62,116.76 40.52,118.86 32.06,118.86 31.94,118.74 30.27,118.74 29.59,119.42 25.35,119.42 24.39,120.38 20.93,120.38 19.97,119.42 18.5,119.42 17.48,118.4 16.48,118.4 16,117.92 10.69,117.92 9.47,116.7 9.47,112.59 10.97,111.09 12.47,111.09 14.61,108.94 19.15,108.94 19.75,108.35 19.84,108.35 19.92,108.43 v5(19.92,108.43)
  BOTTOM w0.076: UE3.M3 21.16,110.4 20.64,109.89 20.6,109.89 19.99,109.28 19.99,108.51 v5(19.92,108.43) 19.92,108.38 19.36,107.82 19.36,107.5 19.16,107.3 18.67,107.3 18.36,107 RE35.1
PCH_3.3V_TS_EN: length 115.9
  TOP w0.076: UCPU1.AP5 56.62,117.26 v7(56.24,117.64)
  IN4 w0.066: v1(73.91,18.1) 71.37,18.1 69.98,19.5 69.98,20.77 70.23,21.02 70.23,23.65 72.43,25.85 72.43,34.43 72.25,34.61 72.25,38 65.53,44.71 65.53,66.41 60.5,71.44 60.5,74.39 60.77,74.66 60.77,78.66 60.94,78.83 60.94,79.55 60.73,79.75 60.73,87.65 60.21,88.16 60.21,91.54 59.13,92.63 59.13,97.72 57.21,99.64 57.21,101.14 57.3,101.22 57.3,103.87 57.3,104.81 58.7,106.21 58.7,109.18 58.76,109.25 58.76,109.38 58.76,109.39 58.76,115.11 58.55,115.32 58.55,115.86 56.77,117.64 v7(56.24,117.64)
  BOTTOM w0.112: v7(56.24,117.64) 56.24,118.17 v2(55.98,118.43) RC396.2 ; R5764.1 v1(73.91,18.1)
PCH_AUD_PWR_EN: length 42.8
  IN2 w0.066: v4(55.55,123.66) 55.93,123.66 56.31,124.04 57.53,124.04 57.86,124.37 57.86,124.4 58.01,124.55 v3(58.01,124.71)
  IN3 w0.066: v4(55.55,123.66) 55.19,124.02 54.67,124.02 53.92,123.27 51.13,123.27 50.93,123.46 49.55,123.46 49.47,123.55 49.32,123.7 47.74,123.7 46.69,124.75 46.69,127.09 42.53,131.24 41.77,131.24 41.32,130.8 35.84,130.8 35.41,130.37 30.05,130.37 29.29,131.13 27.74,131.13 v6(27.66,131.21)
  IN4 w0.066: v6(27.66,131.21) 27.66,130.43 27.81,130.28 27.81,130.06 27.79,130.04 27.79,128.45 27.85,128.39 27.85,128.09 27.61,127.85 v1(27.61,126.67)
  BOTTOM w0.112: v1(27.61,126.67) 27.06,126.67 26.75,126.35 RE120.1
PCH_DDI1_AUXN: length 192.9
  TOP w0.076: UCPU1.G50 82.24,130.91 82.38,131.04 82.39,131.04 82.39,131.05 82.61,131.05 82.75,130.9 v3(82.75,130.8)
  IN2 w0.081: v3(82.75,130.8) 82.98,131.02 83.18,131.02 83.27,130.94 83.27,130.61 82.96,130.31 82.96,128.96 82.27,128.27 82.27,123.67 81.87,123.27 80.31,123.27 79.99,122.95 67.96,122.95 66.65,121.64 64.39,121.64 63.8,121.05 61.43,121.05 61.42,121.05 60.18,121.05 58.44,119.32 57.36,118.23 57.36,117.32 57.51,117.18 57.51,116.51 57.32,116.32 56.99,116.32 56.89,116.22 56.88,116.22 56.41,115.74 56.41,115.38 55.68,114.65 55.68,111.85 54.98,111.15 54.98,110.46 54.03,109.51 54.03,107.78 54.93,106.88 54.93,106.56 54.93,98.14 57.73,95.34 57.73,94.54 62.02,90.25 62.02,87.23 60.54,85.75 60.54,79.13 57.44,76.03 57.44,48.03 36.74,27.33 27.34,27.33 23.66,23.66 23.66,21.52 22.89,20.74 22.89,20.54 v4(22.71,20.36)
  IN3 w0.081: v4(22.71,20.36) 22.71,20.33 22.7,20.33 v5(22.7,20.03)
  IN4 w0.066: v1(49.17,11.84) 49.07,11.73 48.62,11.73 48.37,11.98 48.37,13.22 44.62,16.98 26.86,16.98 23.36,20.49 23.05,20.49 22.9,20.33 22.9,20.22 v5(22.7,20.03)
  BOTTOM w0.112: v5(22.7,20.03) 22.7,20.38 CV59.1
PCH_DDI1_AUXN_C: length 2.7
  BOTTOM w0.112: RV45.2 CV59.2 22.61,21.35 22.49,21.46 22.35,21.46 22.23,21.59 22.23,21.78 22.15,21.85 22.15,22.29 22.02,22.41 UV2.25
PCH_DDI1_AUXP: length 192.9
  TOP w0.076: UCPU1.F50 82.47,131.23 v3(82.8,131.23)
  IN2 w0.081: v3(82.8,131.23) 83.27,131.23 83.47,131.03 83.47,130.52 83.17,130.22 83.17,128.88 82.47,128.18 82.47,123.59 81.95,123.06 80.39,123.06 80.07,122.75 68.05,122.75 66.74,121.44 64.48,121.44 63.88,120.84 61.35,120.84 61.34,120.85 60.27,120.85 58.53,119.11 58.53,119.11 58.05,118.64 57.56,118.15 57.56,117.41 57.71,117.26 57.71,117.04 57.71,117.04 57.71,116.87 57.71,116.87 57.71,116.42 57.4,116.12 57.08,116.12 56.97,116.01 56.96,116.01 56.61,115.66 56.61,115.3 55.88,114.57 55.88,111.77 55.18,111.07 55.18,111 55.18,110.38 54.23,109.43 54.23,107.87 55.14,106.97 55.14,106.48 55.14,98.22 57.93,95.43 57.93,94.62 62.22,90.33 62.22,87.14 60.74,85.66 60.74,79.04 57.65,75.95 57.65,47.95 36.83,27.13 27.42,27.13 23.87,23.57 23.87,21.43 23.09,20.66 23.09,20.54 v4(23.24,20.39)
  IN3 w0.081: v4(23.24,20.39) 23.19,20.33 v5(23.19,20.03)
  IN4 w0.066: v1(49.16,11.27) 49.16,11.48 49.07,11.58 48.56,11.58 48.22,11.92 48.22,13.16 44.55,16.83 26.8,16.83 23.29,20.34 23.11,20.34 23.05,20.27 23.05,20.17 v5(23.19,20.03)
  BOTTOM w0.112: CV58.1 23.19,20.42 v5(23.19,20.03)
PCH_DDI1_AUXP_C: length 2.8
  BOTTOM w0.112: UV2.24 22.42,22.32 22.36,22.26 22.36,21.94 23.24,21.07 CV58.2 RV44.2
PCH_DDI2_AUXN: length 213.6
  TOP w0.076: v3(81.09,131.76) 81.33,132 UCPU1.E48
  IN2 w0.081: v4(38.01,29.77) 38.21,29.97 38.41,29.97 39.07,30.63 39.07,35.16 39.81,35.9 40.64,35.9 42.11,37.38 42.11,38.53 55.08,51.5 55.08,76.4 58.97,80.29 58.97,88.17 57.05,90.09 57.05,93 56.16,93.89 56.16,94.69 53.37,97.49 53.37,106.23 52.69,106.91 52.47,107.13 52.47,110.43 52.81,110.77 52.81,113.2 53.86,114.25 53.86,115.97 55.17,117.28 55.17,118.68 57.57,121.08 57.83,121.08 60.53,123.77 60.53,124.11 60.53,124.12 60.53,124.42 60.53,124.43 60.53,124.45 60.72,124.64 60.8,124.64 60.8,124.64 61.33,124.64 61.86,125.17 65.72,125.17 66.47,125.92 67.84,125.92 68.47,126.54 77.19,126.54 77.95,127.31 78.26,127.31 79.06,128.11 79.06,128.82 79.7,129.46 79.7,129.8 80.46,130.56 80.97,130.56 81.28,130.88 81.28,131.45 81.09,131.65 v3(81.09,131.76)
  IN3 w0.081: v5(21.84,34.79) 22,34.79 22.02,34.76 22.02,34.4 22.27,34.15 23.57,34.15 24.26,33.47 26.71,33.47 28.44,31.74 35.6,31.74 37.41,29.94 37.85,29.94 v4(38.01,29.77) 38.18,29.94 45.32,29.94 45.53,30.14 45.53,30.42 v6(45.6,30.49)
  IN4 w0.066: v1(26.14,68.44) 26.26,68.33 26.66,68.33 26.81,68.17 26.81,65.22 28.31,63.72 28.31,62.14 29.16,61.29 30.4,61.29 31.08,60.62 32.35,60.62 33.53,59.44 33.53,58.33 34.74,57.12 34.74,50.96 37.21,48.49 42.09,48.49 43.24,47.33 43.24,37.7 44.56,36.38 45.02,36.38 45.49,35.92 45.49,30.61 v6(45.6,30.49)
  BOTTOM w0.112: v1(26.14,68.44) 26.22,68.36 26.35,68.36 CT35.1
PCH_DDI2_AUXP: length 213
  TOP w0.076: UCPU1.F48 81.02,131.45 v3(80.77,131.21)
  IN2 w0.081: v4(38.01,30.3) 38.13,30.19 38.34,30.19 38.86,30.72 38.86,35.24 39.73,36.11 40.56,36.11 41.91,37.46 41.91,38.62 54.88,51.59 54.88,76.49 58.77,80.37 58.77,88.08 56.85,90 56.85,92.92 55.96,93.8 55.96,94.61 53.16,97.41 53.16,106.15 52.61,106.71 52.26,107.05 52.26,110.51 52.6,110.85 52.6,113.28 53.66,114.33 53.66,116.05 54.97,117.36 54.97,118.76 57.48,121.28 57.75,121.28 60.33,123.85 60.33,124.03 60.32,124.03 60.32,124.51 60.33,124.51 60.33,124.54 60.63,124.85 60.89,124.85 61.25,124.85 61.77,125.37 65.63,125.37 66.38,126.13 67.76,126.13 68.38,126.75 77.1,126.75 77.87,127.51 78.17,127.51 78.86,128.2 78.86,128.9 79.49,129.54 79.49,129.88 80.38,130.77 80.88,130.77 81.08,130.96 81.08,131.37 80.89,131.56 80.73,131.56 80.6,131.43 80.6,131.32 80.71,131.21 v3(80.77,131.21)
  IN3 w0.081: v5(22.48,34.79) 22.3,34.61 22.23,34.61 22.23,34.48 22.35,34.36 23.66,34.36 24.34,33.67 26.8,33.67 28.52,31.94 35.69,31.94 37.49,30.14 37.85,30.14 v4(38.01,30.3) 38.18,30.14 45.24,30.14 45.33,30.23 45.33,30.39 v6(45.22,30.49)
  IN4 w0.066: v1(26.14,68.06) 26.26,68.18 26.59,68.18 26.66,68.11 26.66,65.15 28.16,63.66 28.16,62.08 29.1,61.14 30.34,61.14 31.01,60.47 32.28,60.47 33.38,59.38 33.38,58.27 34.59,57.05 34.59,50.89 37.15,48.34 42.03,48.34 43.09,47.27 43.09,37.64 44.5,36.23 44.96,36.23 45.34,35.85 45.34,30.61 v6(45.22,30.49)
  BOTTOM w0.112: CT34.1 26.33,68.14 26.22,68.14 v1(26.14,68.06)
PCH_DDI2_N0: length 146.7
  TOP w0.076: v3(81.92,133.16) UCPU1.C50
  IN2 w0.081: v3(81.92,133.16) 81.92,133.1 81.79,132.98 81.64,132.98 80.95,132.28 80.62,132.28 79.68,131.34 79.68,130.98 78.83,130.13 78.83,129.71 77.14,128.03 68.73,128.03 67.51,126.81 66.13,126.81 65.32,126 59.88,126 59.56,125.68 59.56,123.94 57.49,121.87 56.9,121.87 52.01,116.98 52.01,111.29 51.67,110.95 51.67,106.81 52.36,106.12 52.58,105.9 52.58,97.16 52.92,96.82 55.37,94.36 55.37,93.56 56.26,92.67 56.26,89.76 58.18,87.84 58.18,80.62 54.28,76.73 54.28,51.84 48.88,46.44 48.76,46.44 48.5,46.7 48.21,46.7 47.86,46.35 47.86,46.07 48.13,45.8 48.13,45.69 47.9,45.46 47.79,45.46 47.52,45.73 47.24,45.73 46.89,45.38 46.89,45.09 47.15,44.83 47.15,44.71 46.92,44.48 46.81,44.48 46.54,44.75 46.26,44.75 45.91,44.4 45.91,44.12 46.18,43.85 46.18,43.73 45.97,43.53 43.56,43.53 43.18,43.14 43.18,42.51 43.51,42.18 43.69,42.18 v7(43.87,42)
  BOTTOM w0.112: CV25.1 26.64,42.41 v11(27.5,42.41) 27.95,42.41 28.42,41.94 31.27,41.94 31.28,41.92 31.83,41.92 31.85,41.94 34.1,41.94 35.84,40.2 41.07,40.2 42.96,42.09 43.78,42.09 v7(43.87,42)
PCH_DDI2_N1: length 147.5
  IN2 w0.081: v7(43.92,37.82) 44.11,38.01 44.59,38.01 57.06,50.49 57.06,76.71 60.15,79.8 60.15,88.84 58.29,90.7 58.29,93.43 57.34,94.38 57.34,95.18 54.55,97.98 54.55,106.72 53.64,107.62 53.64,109.82 54.18,110.36 54.18,111.49 55.08,112.39 55.08,114.61 56.02,115.55 56.02,115.9 56.74,116.62 56.74,116.94 56.97,117.18 56.97,118.45 60,121.48 61.09,121.48 62.28,122.67 66.48,122.67 67.89,124.08 79.81,124.08 80.37,124.63 80.37,126.7 81.85,128.19 81.85,128.96 82.27,129.38 82.27,130.2 82.46,130.39 82.46,131.29 82.93,131.76 83.44,131.76 83.94,132.27 83.94,133.06 83.6,133.4 83.53,133.4 v3(83.41,133.52)
  BOTTOM w0.112: v7(43.92,37.82) 43.77,37.97 42.58,37.97 41.14,39.42 35.27,39.42 33.52,41.17 30.58,41.17 30.56,41.15 30.01,41.15 30,41.17 v11(28.54,41.17) 26.66,41.17 CV28.1
PCH_DDI2_N2: length 147.6
  IN2 w0.081: v7(39.75,38.72) 39.88,38.6 40.21,38.6 40.34,38.72 40.34,40.82 40.54,41.02 41.12,41.02 41.2,41.1 41.2,41.43 41.12,41.51 40.54,41.51 40.34,41.71 40.34,42.28 53.7,55.64 53.7,76.97 57.59,80.86 57.59,87.59 55.67,89.52 55.67,92.43 54.78,93.31 54.78,94.12 52.68,96.23 51.99,96.92 51.99,105.66 51.08,106.56 50.98,106.67 50.98,110.92 50.98,111.09 51.08,111.19 51.42,111.53 51.42,117.23 52.13,117.94 52.13,117.94 52.42,118.22 56.65,122.46 57.24,122.46 58.93,124.15 58.93,126.38 59.56,127.01 59.86,127.01 60.73,127.89 67.76,127.89 68.61,128.74 76.99,128.74 78.14,129.89 78.14,130.38 79.67,131.9 79.67,132.16 80.38,132.87 80.7,132.87 81.58,133.75 81.58,134.3 82.04,134.76 82.22,134.76 v3(82.28,134.82)
  BOTTOM w0.112: v7(39.75,38.72) 39.88,38.6 40.13,38.6 40.49,38.24 40.49,37.83 40.06,37.4 38.23,37.4 37.7,37.93 35.14,37.93 33.17,39.9 v11(28,39.9) 26.66,39.9 CV32.1
PCH_DDI2_N3: length 148.1
  IN2 w0.081: v7(39.64,34.31) 39.8,34.47 40.39,34.47 42.8,36.88 42.8,38.2 55.69,51.09 55.69,76.18 59.56,80.05 59.56,88.59 57.64,90.52 57.64,93.25 56.75,94.13 56.75,94.94 53.96,97.73 53.96,106.48 53.06,107.38 53.06,110.18 53.4,110.52 53.4,111.54 54.46,112.61 54.46,115.73 55.83,117.11 55.83,118.51 57.81,120.49 58.13,120.49 59.75,122.11 60.24,122.11 61.5,123.37 62.49,123.37 62.53,123.34 65.74,123.34 67.29,124.89 67.83,124.89 68.29,125.35 78.6,125.35 79.5,126.25 79.5,127.64 79.7,127.83 79.99,127.83 80.53,128.38 80.53,129.77 80.73,129.97 81.21,129.97 81.87,130.63 81.87,131.65 82.5,132.28 82.5,133.38 82.59,133.47 82.67,133.47 82.7,133.47 82.85,133.32 v3(82.85,133.2)
  BOTTOM w0.112: v7(39.64,34.31) 39.45,34.49 37.17,34.49 33.2,38.46 29.78,38.46 29.76,38.44 29.21,38.44 29.2,38.46 v11(28.07,38.46) 27.53,38.46 27.07,37.99 26.66,37.99 CV35.1
