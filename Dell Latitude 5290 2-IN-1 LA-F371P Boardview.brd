# Allegro board Dell Latitude 5290 2-IN-1 LA-F371P Boardview.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
TPS68470YFFR_DSBGA_56P
  round 0.271 smd: A1(0,0) A2(0.4,0) A3(0.8,0) A4(1.2,0) A5(1.6,0) A6(2,0) A7(2.4,0) B1(0,-0.4) B2(0.4,-0.4) B3(0.8,-0.4) B4(1.2,-0.4) B5(1.6,-0.4) B6(2,-0.4) B7(2.4,-0.4) C1(0,-0.8) C2(0.4,-0.8) C3(0.8,-0.8) C4(1.2,-0.8) C5(1.6,-0.8) C6(2,-0.8) C7(2.4,-0.8) D1(0,-1.2) D2(0.4,-1.2) D3(0.8,-1.2) D4(1.2,-1.2) D5(1.6,-1.2) D6(2,-1.2) D7(2.4,-1.2) E1(0,-1.6) E2(0.4,-1.6) E3(0.8,-1.6) E4(1.2,-1.6) E5(1.6,-1.6) E6(2,-1.6) E7(2.4,-1.6) F1(0,-2) F2(0.4,-2) F3(0.8,-2) F4(1.2,-2) F5(1.6,-2) F6(2,-2) F7(2.4,-2) G1(0,-2.4) G2(0.4,-2.4) G3(0.8,-2.4) G4(1.2,-2.4) G5(1.6,-2.4) G6(2,-2.4) G7(2.4,-2.4) H1(0,-2.8) H2(0.4,-2.8) H3(0.8,-2.8) H4(1.2,-2.8) H5(1.6,-2.8) H6(2,-2.8) H7(2.4,-2.8)
TPS79801QDGNRQ1_MSOP8
  oval 0.381x1.575 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,4.35) 6(1.3,4.35) 7(0.65,4.35) 8(0,4.35)
  rect 1.88x1.753 smd: 9(0.975,2.175)
TVNST52302AB0_SOT523-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.5,-1.4) 3(0.5,-1.4)
W25Q80DVZPIG_WSON8
  oval 0.66x1.092 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.9) 6(2.54,5.9) 7(1.27,5.9) 8(0,5.9)
  rect 4.293x3.404 smd: 9(1.905,2.95)
W25Q128JVEIQ_WSON8_8X6
  oval 0.66x0.991 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,8) 6(2.54,8) 7(1.27,8) 8(0,8)
  rect 4.293x3.404 smd: 9(1.905,4)
Y_9H03200031_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_9H03220008_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_X3G024000DC1H_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
Y_XRCGB24M000F2P51R0_4P
  rect 0.762x0.711 smd: 1(0,0) 2(1.35,0) 3(1.35,1) 4(0,1)

## Nets
1.0V_PRIM_CORE_PG: PR735.1 PU801.4
1.0VA_PG: PR705.1 PU700.9
1.2V_DDR_OT: PR600.2 PU600.11
1.2V_DDR_PG: PR606.1 PU600.12
1.8VA_PG: PR725.1 PU720.4 RE252.2 RE253.1
1.8VU_PG: PR732.1 PU721.4
3.3V_CAM_EN: R442.1 U11.3 UCPU1.AY7
3.3V_IRCAM_EN#: R5778.2 UCPU1.AT15
3.3V_TS_EN: R5765.1 UE3.J7
3.3V_TS_EN_R: R5764.2 R5765.2 UZ4.3
3.3V_WWAN_EN: D61.2 UE3.C6
3V_EN: PR504.2 PR516.1 PU500.11
3V_VIN: PC501.1 PC502.1 PC503.1 PC504.1 PL500.2 PU500.1
3VALW_PG: PR151.1 PR271.2 PR503.1 PU500.3 RE121.2
3VALW_PG_EC: RE121.1 UE3.K3
5VALW_EN: PR510.2 PR517.1 PU501.11
5VALW_PG: PR509.1 PU501.3
5VALW_VIN: PC514.1 PC515.1 PC516.1 PC517.1 PL502.2 PR1203.2 PU501.1
5VD_EN: PR515.2 PR518.1 PU502.11
5VD_PG: PR514.1 PU502.3
5VD_VIN: PC527.1 PC528.1 PC529.1 PC530.1 PL504.2 PU502.1
+0.6VS: CD100.1 CD101.1 CD102.1 CD103.1 CD104.1 CD105.1 CD106.1 CD107.1 CD108.1 CD109.1 PJP601.2 RD21.2 RD22.2 RD23.2 RD24.2 RD25.2 RD26.2 RD27.2 RD28.2 RD29.2 RD30.2 RD31.2 RD32.2 RD33.2 RD34.2 RD35.2 RD36.2 RD37.2 RD38.2 RD39.2 RD40.2 RD41.2 RD42.2 RD43.2 RD44.2 RD45.2 RD46.2 RD47.2 RD48.2 RD49.2 RD50.2 RD51.2 RD52.2 RD53.2 RD54.2 RD55.2 RD56.2 RD57.2 RD58.2 RD59.2 RD60.2 RD61.2 RD62.2 RD63.2 RD64.2 RD65.2 RD66.2 RD67.2 RD68.2 RD69.2 RD70.2 RD71.2 RD72.2 RD73.2 RD74.2 RD75.2 RD76.2 RD77.2 RD78.2 RD79.2 RD80.2 RD81.2 RD82.2
+0.6VSP: PC610.1 PC611.1 PJP601.1 PU600.5 PU600.8
+1.0V_AMPHYPLL: CC34.1 RC129.2 UCPU1.K15 UCPU1.L15
+1.0V_APLL: L30.2 R121.1 UCPU1.V15
+1.0V_APLLEBB: CC38.1 RC128.2 UCPU1.N18
+1.0V_CLK: CC27.1 CC28.1 CC30.1 RC15.1 RC16.1 RC31.2 RC103.2 RC104.1 RC105.1 RC117.1 RC118.1
+1.0V_DTS: RC47.2 UCPU1.T1
+1.0V_MPHYAON: CC32.1 RC125.2 UCPU1.K17 UCPU1.L1
+1.0V_MPHYGT: CC39.1 CC43.1 CZ9.1 CZ10.1 R120.2 RC128.1 RC129.1 RC133.1 UCPU1.N15 UCPU1.N16 UCPU1.N17 UCPU1.P15 UCPU1.P16
+1.0V_PRIM_CORE: CC52.1 CC54.1 PJP801.2 UCPU1.AF18 UCPU1.AF19 UCPU1.V20 UCPU1.V21
+1.0V_PRIM_COREP: PC813.1 PC814.1 PC815.1 PJP801.1 PL803.2 PR824.2 PU801.1
+1.0V_SRAM: CC44.1 RC133.2 UCPU1.AF20 UCPU1.AF21 UCPU1.T19 UCPU1.T20
+1.0V_VCCST: CC3.1 CC35.1 CE25.1 CZ5.1 PC903.1 PR900.1 PR901.1 PR920.1 PR925.1 PR934.1 R118.2 RC7.1 RC20.1 RC24.2 RC25.1 RC93.1 RC94.1 RC95.1 RC109.1 RE222.1 RE261.2 UCPU1.A18 UCPU1.K20 UCPU1.K21
+1.0V_VCCST_R: R118.1 UZ3.6
+1.0V_VCCSTG: CC4.1 CZ1.1 R26.2 RC1.2 RC2.1 RC3.2 RC18.1 RC19.1 RC28.1 UCPU1.A22
+1.0V_VCCSTG_R: RC1.1 UCPU1.G20
+1.0V_VCCSTG_R26: R26.1 UZ2.6
+1.0VA: CC29.1 CC51.1 CC92.1 CZ6.1 CZ7.1 CZ8.1 L30.1 PJP700.2 R120.1 R5770.1 RC47.1 RC103.1 RC125.1 RC130.1 UCPU1.AB17 UCPU1.AB19 UCPU1.AB20 UCPU1.AK20 UCPU1.P18 UCPU1.Y18 UZ2.1 UZ2.2 UZ2.7 UZ3.1 UZ3.2 UZ3.7
+1.0VA_XDP: CC33.1 CC37.1 JXDP1.43 JXDP1.44 RC130.2 RC151.1
+1.0VA_XDP1: R5770.2 RC10.2
+1.0VAP: PC707.1 PC708.1 PC709.1 PC710.1 PC711.1 PJP700.1 PL701.2 PR704.1
+1.0VS_VCCIO: CC60.1 CC61.1 CC62.1 CC63.1 CC65.1 CC66.1 CC67.1 CC69.1 CC71.1 CC72.1 PJP800.2 QE15.1 RC108.1 RC119.1 RC147.1 UCPU1.AK28 UCPU1.AK30 UCPU1.AL30 UCPU1.AL42 UCPU1.AM28 UCPU1.AM30 UCPU1.AM42
+1.0VS_VCCIO_PG: PR734.1 PU800.4
+1.0VS_VCCIOP: PC803.1 PC804.1 PC805.1 PJP800.1 PL801.2 PR807.1 PU800.1
+1.2V_DDR: CC15.1 CC18.1 CC19.1 CC20.1 CC74.1 CC75.1 CC77.1 CC80.1 CC82.1 CC84.1 CC85.1 CC86.1 CC87.1 CC88.1 CD1.1 CD2.1 CD3.1 CD4.1 CD5.1 CD6.1 CD8.1 CD9.1 CD10.1 CD11.1 CD12.1 CD13.1 CD14.1 CD15.1 CD16.1 CD17.1 CD18.1 CD23.1 CD24.1 CD25.1 CD26.1 CD27.1 CD28.1 CD29.1 CD30.1 CD31.1 CD32.1 CD33.1 CD37.1 CD38.1 CD39.1 CD51.1 CD52.1 CD53.1 CD56.1 CD57.1 CD58.1 CD59.1 CD60.1 CD61.1 CD62.1 CD63.1 CD64.1 CD65.1 CD66.1 CD68.1 CD73.1 CD74.1 CD75.1 CD76.1 CD77.1 CD78.1 CD79.1 CD80.1 CD81.1 CD82.1 CD85.1 CZ3.1 PJP600.2 RC156.1 RD6.1 RD12.1 RD18.1 RV26.1 UC1.5 UCPU1.AU23 UCPU1.AU28 UCPU1.AU35 UCPU1.AU42 UCPU1.BB23 UCPU1.BB32 UCPU1.BB41 UCPU1.BB47 UCPU1.BB51 UD1.A8 UD1.A9 UD1.A11 UD1.C12 UD1.D4 UD1.D5 UD1.D6 UD1.E8 UD1.E12 UD1.F2 UD1.G2 UD1.G5 UD1.G12 UD1.H3 UD1.H5 UD1.H6 UD1.H8 UD1.H9 UD1.H11 UD1.H12 UD1.J5 UD1.J6 UD1.J9 UD1.J10 UD1.K5 UD1.K6 UD1.K8 UD1.K11 UD1.K12 UD1.L2 UD1.L5 UD1.L12 UD1.M2 UD1.N8 UD1.N12 UD1.P4 UD1.P5 UD1.P6 UD1.R12 UD1.U8 UD1.U9 UD1.U11 UD2.A8 UD2.A9 UD2.A11 UD2.C12 UD2.D4 UD2.D5 UD2.D6 UD2.E8 UD2.E12 UD2.F2 UD2.G2 UD2.G5 UD2.G12 UD2.H3 UD2.H5 UD2.H6 UD2.H8 UD2.H9 UD2.H11 UD2.H12 UD2.J5 UD2.J6 UD2.J9 UD2.J10 UD2.K5 UD2.K6 UD2.K8 UD2.K11 UD2.K12 UD2.L2 UD2.L5 UD2.L12 UD2.M2 UD2.N8 UD2.N12 UD2.P4 UD2.P5 UD2.P6 UD2.R12 UD2.U8 UD2.U9 UD2.U11 UD3.A8 UD3.A9 UD3.A11 UD3.C12 UD3.D4 UD3.D5 UD3.D6 UD3.E8 UD3.E12 UD3.F2 UD3.G2 UD3.G5 UD3.G12 UD3.H3 UD3.H5 UD3.H6 UD3.H8 UD3.H9 UD3.H11 UD3.H12 UD3.J5 UD3.J6 UD3.J9 UD3.J10 UD3.K5 UD3.K6 UD3.K8 UD3.K11 UD3.K12 UD3.L2 UD3.L5 UD3.L12 UD3.M2 UD3.N8 UD3.N12 UD3.P4 UD3.P5 UD3.P6 UD3.R12 UD3.U8 UD3.U9 UD3.U11 UD4.A8 UD4.A9 UD4.A11 UD4.C12 UD4.D4 UD4.D5 UD4.D6 UD4.E8 UD4.E12 UD4.F2 UD4.G2 UD4.G5 UD4.G12 UD4.H3 UD4.H5 UD4.H6 UD4.H8 UD4.H9 UD4.H11 UD4.H12 UD4.J5 UD4.J6 UD4.J9 UD4.J10 UD4.K5 UD4.K6 UD4.K8 UD4.K11 UD4.K12 UD4.L2 UD4.L5 UD4.L12 UD4.M2 UD4.N8 UD4.N12 UD4.P4 UD4.P5 UD4.P6 UD4.R12 UD4.U8 UD4.U9 UD4.U11 UZ1.1 UZ1.2 UZ1.7
+1.2V_DDRP: PC602.1 PC603.1 PC604.1 PC605.1 PC606.1 PJP600.1 PL600.2 PR603.1 PU600.6
+1.2V_MEM_CPUCLK: CC76.1 CC83.1 RC156.2 UCPU1.AM40
+1.2V_MUX: CV39.1 CV60.1 RV14.1 RV26.2 RV42.1 RV61.1 RV62.1 UV1.20 UV1.28 UV2.20 UV2.28
+1.2V_UF_DVDD: C5.1 C6.1 C69.1 C70.1 JUFC1.1 R105.2
+1.2V_WF_DVDD: C7.1 C10.1 JWFC1.21 R116.2
+1.5VS_AUDIO: C207.1 R214.2 R425.2 RA18.1 RC185.1
+1.5VS_AUDIO_R: R425.1 U16.5
+1.8V_ESPI: R513.2 RC83.1
+1.8V_IO_OUT: C77.1 C78.1 RH24.2 RH27.2 U12.E7
+1.8V_PGPP: C1136.1 RC72.1 RC73.1 RC139.2 RC182.2 RC183.2 RC192.2 RC391.2 RC392.2 U4255.1 U4255.2 UCPU1.AF16 UCPU1.AK15
+1.8V_UF_VDD: C2.1 C53.1 C54.1 JUFC1.5 R98.2
+1.8V_WF_DOVDD: C16.1 C72.1 C75.1 JWFC1.20 R106.2
+1.8VA: C94.1 C500.1 C501.1 C502.1 CC47.1 CC48.1 CE54.1 PJP720.2 R472.1 R513.1 RC139.1 RE183.2 RE195.1 RH1.2 RH2.2 RH5.2 RH7.2 RH8.2 RH9.2 RH12.2 RH15.2 RH17.2 RH25.2 RH26.2 U14.6 U14.7 UCPU1.AA1
+1.8VA_EC: CE55.1 RE195.2 RE258.2 RE259.2 UE3.N5
+1.8VA_LDO_PD1: CT10.1 UT1.K1
+1.8VA_LDO_PD2: CT32.1 UT2.K1
+1.8VAP: PC721.1 PC722.1 PJP720.1 PL721.2 PR722.1 PR726.2 PU720.14
+1.8VD_LDO_PD1: CT12.1 RT19.2 UT1.A2
+1.8VD_LDO_PD2: CT20.1 RT54.2 UT2.A2
+1.8VS: Q29.2 R33.1 R35.1 R455.2 R479.1
+1.8VS_AUDIO: C82.1 R112.2 R455.1 RA11.1 RA36.1
+1.8VS_AUDIO_R: R112.1 U14.8 U14.9
+1.8VS_CR: C1138.1 R210.2 R5781.2
+1.8VS_CR_R: R5781.1 U4255.7 U4255.8
+1.8VU: CD7.1 CD34.1 CD35.1 CD36.1 CD40.1 CD41.1 CD48.1 CD49.1 CD50.1 CD54.1 CD55.1 CD83.1 CD84.1 PJP721.2 RS2.1 UD1.A3 UD1.A4 UD1.A5 UD1.A6 UD1.A10 UD1.U3 UD1.U4 UD1.U5 UD1.U6 UD1.U10 UD2.A3 UD2.A4 UD2.A5 UD2.A6 UD2.A10 UD2.U3 UD2.U4 UD2.U5 UD2.U6 UD2.U10 UD3.A3 UD3.A4 UD3.A5 UD3.A6 UD3.A10 UD3.U3 UD3.U4 UD3.U5 UD3.U6 UD3.U10 UD4.A3 UD4.A4 UD4.A5 UD4.A6 UD4.A10 UD4.U3 UD4.U4 UD4.U5 UD4.U6 UD4.U10
+1.8VUP: PC729.1 PC730.1 PC736.1 PJP721.1 PL723.2 PR729.1 PR733.2 PU721.14
+2.8V_UF_AVDD: C3.1 C4.1 C43.1 C44.1 C45.1 C208.1 C209.1 JUFC1.3 R78.1 R79.2
+2.8V_VCM_OUT: C1.1 C14.1 C86.1 C87.1 JWFC1.18 R5.1 R15.1 R113.2
+2.8V_WF_AVDD: C15.1 C66.1 C68.1 C210.1 C211.1 C212.1 JWFC1.19 R102.2
+3.3V_ALW_DSW: CC55.1 CC59.1 CC73.1 RC84.1 RC90.1 RC91.2 RC127.1 RC143.1 RC394.1 RC395.1 UCPU1.AD17 UCPU1.AD18 UCPU1.AJ17
+3.3V_ALW_DSW_Q352: Q352.1 RC395.2
+3.3V_EC_PLL: CE47.1 CE48.1 RE194.1 UE3.F1
+3.3V_LDO_PD1: CT5.1 CT9.1 PC151.1 PR185.1 PU104.5 RT6.1 RT7.1 RT10.1 RT16.2 RT25.1 RT29.1 RT32.1 RT35.1 RT36.1 RT42.1 RT43.1 RT44.1 RT47.1 RT48.1 RT49.1 RT103.1 RT119.1 RT125.1 U22.8 UT1.G1
+3.3V_LDO_PD2: CT31.1 PC150.1 PR183.1 PU103.5 RT55.2 RT62.1 RT64.1 RT67.1 RT72.1 RT79.1 RT81.1 RT83.1 RT86.1 RT87.1 RT90.1 RT94.1 RT105.1 RT123.1 RT126.1 UT2.G1
+3.3V_PGPP: CC45.1 CC50.1 CC58.1 RC134.2 UCPU1.AD15 UCPU1.AG15 UCPU1.T16 UCPU1.Y15 UCPU1.Y16
+3.3V_SPI: CC90.1 JSPI2.8 RC170.1 UCPU1.AJ16 UH1.8
+3.3V_TBAT_LDO: PD105.2 PD280.2 PR157.2 RTCD2.2
+3.3V_VOUT_PD1: CT13.1 UT1.H2
+3.3V_VOUT_PD2: CT28.1 UT2.H2
+3.3VDX_SSD: C131.1 C139.1 C140.1 C141.2 C142.1 C143.1 JNGFF2.2 JNGFF2.4 JNGFF2.12 JNGFF2.14 JNGFF2.16 JNGFF2.18 JNGFF2.70 JNGFF2.72 JNGFF2.74 R64.2 R152.2
+3.3VDX_SSD_R: R152.1 U21.8 U21.9
+3V_5105: CE8.1 CE10.1 CE14.1 CE49.1 CE88.2 Q22.2 R449.2 R474.1 RE1.1 RE3.1 RE4.1 RE5.1 RE6.1 RE7.1 RE8.1 RE9.1 RE11.2 RE15.1 RE20.2 RE30.2 RE32.2 RE33.2 RE35.2 RE38.2 RE40.1 RE42.1 RE45.2 RE46.2 RE52.2 RE53.1 RE55.2 RE56.1 RE61.1 RE62.2 RE63.1 RE64.2 RE65.2 RE67.2 RE68.2 RE70.2 RE110.2 RE111.2 RE115.1 RE116.2 RE118.1 RE123.1 RE194.2 RE246.2 RE250.1 RE251.2 RE262.2 RE266.2 RE269.2 RE270.2 RH6.2 UE3.B7 UE3.G8 UE3.H1 UE3.K2 UE3.M9
+3V_FAN: R27.2 R28.2 R443.2 R444.2
+3V_LDO: PC352.1 PD280.3 PR115.1 PR139.1 PR158.2 PR160.1 PR215.1 PR222.1 PR231.2 PR252.1 PR259.1 PR263.1 PU301.5 RT37.1 RT85.1 RTCD1.2
+3V_LDOP: PQ123.1 PR147.2
+3V_PRIM: C60.1 C126.1 CC46.1 CC56.1 CC57.1 JAPS1.18 JSPI2.9 R145.2 R153.1 R448.1 R5771.1 R5775.1 R5777.1 RA39.1 RC8.1 RC11.2 RC12.2 RC13.2 RC14.2 RC49.2 RC51.2 RC55.2 RC58.2 RC59.1 RC60.2 RC63.1 RC64.2 RC65.1 RC68.1 RC81.1 RC107.1 RC134.1 RC149.1 RC158.1 RC162.1 RC170.2 RC180.1 RC181.1 RC186.1 RC193.2 RC195.2 RC199.1 RC204.1 RC205.2 RC206.2 RC396.1 RE253.2 RH11.1 RH19.1 RH20.1 U11.1 U11.2 U12.B5 U44.5 U4245.5 U4252.5 UCPU1.AJ21 UCPU1.AK17 UCPU1.V19
+3V_PRIM_R: R145.1 U21.13 U21.14
+3V_RF: C48.1 R81.1 R82.2 R83.1 R88.1
+3V_SKYCAM: C46.1 C55.1 C61.1 C65.1 C76.1 C79.1 C80.1 R90.2 R91.1 R93.1 R430.1 R431.1 U9.8 U12.A7 U12.B6 U12.D1 U12.G6 U12.H5
+3VALW: C42.1 C93.1 C96.1 C117.1 C121.1 C124.1 C132.1 C203.1 C205.1 C236.2 C1124.1 CE46.1 JAPS1.12 JAPS1.16 PC286.1 PJP500.2 PQ124.1 PR124.1 PR127.1 PR142.1 PR143.1 PR174.1 PR175.1 PR249.1 PR261.1 PR262.1 PR264.1 PR265.1 PR267.1 PR503.2 PR610.2 PR705.2 PR707.1 PR709.1 PR725.2 PR732.2 PR734.2 PR735.2 PR800.2 PR804.1 PR805.1 PR813.2 PR817.1 PR818.1 PR917.1 PR918.1 PR919.1 PR931.1 PR940.1 PR950.1 PR1101.1 PR1103.1 PR1118.1 PR1126.1 PU105.5 Q352.3 Q354.2 Q354.5 QZ9.3 R82.1 R234.1 R235.2 R444.1 R457.1 R5758.1 R5773.1 RC394.2 RE11.1 RE174.2 RE196.2 RE215.1 RE264.2 RT50.1 RT84.1 U8.5 U13.6 U13.7 U14.1 U14.2 U15.5 U16.1 U17.1 U17.2 U17.6 U17.7 U21.1 U21.2 U21.6 U21.7 U4250.6 UC2.5 UC5.5 UC7.5 UC8.5 UE5.5 UE7.5 UZ4.1 UZ4.2 UZ4.6 UZ4.7
+3VALW_PD1: CT14.1 CT18.1 RT37.2 RT50.2 UT1.B1 UT1.H1
+3VALW_PD2: CT29.1 CT33.1 RT84.2 RT85.2 UT2.B1 UT2.H1
+3VALW_TPM: C229.1 C230.1 R457.2 U4246.1
+3VALW_USH: C1129.1 JIO1.4 JIO1.6 JIO1.8 U4250.1
+3VALWP: PC506.1 PC507.1 PC508.1 PC509.1 PJP500.1 PL501.2 PU500.5
+3VLP: PR519.1 RE152.2
+3VS: C8.1 C95.1 C1123.1 CS1.1 CS2.1 CS10.1 CV17.1 CV18.1 JESPI1.1 JESPI1.2 JUFC1.30 Q1.2 Q1.5 R32.1 R110.2 R119.2 R443.1 R454.2 R456.2 R466.1 R5750.1 R5757.1 RC9.1 RC38.1 RC43.2 RC45.2 RC53.2 RC56.1 RC82.1 RC97.1 RC120.1 RC153.1 RC157.1 RC159.1 RC161.1 RC163.1 RC168.1 RC178.2 RC179.2 RC190.1 RC191.1 RC194.1 RC200.2 RC202.2 RE168.2 RH3.1 RH4.1 RH29.2 RH30.2 RH505.2 RN1.1 RN2.1 RS1.1 RS3.1 RS4.1 RS5.1 RS9.2 RS10.2 RS17.1 RS18.2 RS19.2 RS20.1 RS22.1 RS23.1 RS24.1 RV2.1 U4249.6 UC3.5 UC4.5
+3VS_AUDIO: C17.1 C81.1 R111.2 RA26.1 RA29.1
+3VS_AUDIO_R: R111.1 U14.13 U14.14
+3VS_CAM: C59.1 R90.1 R94.2
+3VS_CR: C198.1 CR7.1 CR8.2 CR20.2 CR21.1 R205.2 RR10.1 RR11.2 UR1.11 UR1.27
+3VS_CR_R: R205.1 UZ4.8 UZ4.9
+3VS_ECOM: CS6.1 CS7.1 CS9.1 RS17.2 U3.3 U3.9 U3.10
+3VS_GYRO: CS3.1 CS4.1 CS5.1 LGA1.1 LGA1.2 LGA1.3 LGA1.5 LGA1.8 LGA1.12 RS20.2
+3VS_IR: C1034.1 C1035.1 C1036.1 C1037.1 JIR1.11 R223.2
+3VS_IR_R: QZ9.1 R223.1
+3VS_MUX: CV19.1 CV42.1 QC2.2 QC2.5 QC3.2 QC3.5 RV2.2 RV6.2 RV13.2 RV14.2 RV16.1 RV19.2 RV27.2 RV28.2 RV32.2 RV34.2 RV37.2 RV41.2 RV42.2 RV43.2 RV45.1 RV53.2 RV57.1 RV58.1 RV59.1 RV60.1 RV71.1 RV73.1 RV75.2 RV77.2 RV79.2 RV81.2 RV83.2 RV85.2 UV1.6 UV2.6
+3VS_MUX_UV1: CV36.1 RV73.2 RV74.1 UV1.17
+3VS_MUX_UV2: CV57.1 RV71.2 RV72.1 UV2.17
+3VS_R: R119.1 U13.8 U13.9
+3VS_TPM: C125.1 C128.1 C130.1 R153.2 R439.1 R453.2 R5750.2 U4246.14 U4246.22
+3VS_TS: C191.1 C193.2 C194.1 C196.1 JEDP1.17 Q351.2 R204.2 RC48.1 RC50.1 RC393.1
+3VS_TS_R: R204.1 UZ4.13 UZ4.14
+3VS_U4: C28.1 C227.1 C228.1 R456.1 U4.1 U4.6 U4.10
+3VS_USH: C1128.1 JIO1.2 U4249.1
+3VS_WLAN: C120.1 C146.1 C147.1 C148.1 C149.1 C150.1 C152.1 C153.1 C154.1 C155.1 C156.1 JNGFF3.2 JNGFF3.4 JNGFF3.72 JNGFF3.74 R140.2 R156.1 R157.1 U23.5
+3VS_WLAN_R: R140.1 U17.13 U17.14
+3VS_WWAN: C97.1 C98.1 C99.1 C100.1 C101.1 C102.1 C103.1 C104.1 C105.1 C106.1 C116.1 JNGFF1.2 JNGFF1.4 JNGFF1.70 JNGFF1.72 JNGFF1.74 L31.2 L32.2 R123.1
+3VS_WWAN_R: L31.1 L32.1 U17.8 U17.9
+5V_DOCK: C37.1 C38.1 JIO2.16 JIO2.17 JIO2.18 JIO2.19 JIO2.20 R72.2
+5V_DOCK_R: R72.1 U7.1
+5V_FAN: C21.2 R29.2 R438.1 R445.2 R446.2
+5V_USB_P1: C113.1 C114.1 C115.1 JUSB1.1 MD1.8 US1.12
+5VALW: C27.1 C29.1 C90.1 CZ4.1 PJP501.2 R50.2 R54.1 R266.1 RC188.2 RT41.1 RT56.1 U2.4 U11.4 U13.1 U13.2 U13.4 U14.4 U17.4 U21.4 U4255.4 US1.1 UZ1.3 UZ2.3 UZ3.3 UZ4.4
+5VALW_IR: JIR1.1 JIR1.2 R266.2
+5VALW_LP: PC518.2 PU501.6
+5VALW_PD1: CT16.1 CT17.1 RT41.2 UT1.A11 UT1.B11 UT1.C11 UT1.D11 UT1.H10
+5VALW_PD2: CT21.1 CT22.1 RT56.2 UT2.A11 UT2.B11 UT2.C11 UT2.D11 UT2.H10
+5VALWP: PC519.1 PC520.1 PC521.1 PC522.1 PC1438.1 PC1439.1 PC1440.1 PJP501.1 PL503.2 PU501.5
+5VD: C22.1 C39.1 C1122.1 PJP502.2 R74.1 R446.1 R5756.1 U2.1 U2.2 U7.5 U4248.6
+5VD_LP: PC531.2 PU502.6
+5VD_USH: C1127.1 JIO1.1 JIO1.3 U4248.1
+5VDP: PC532.1 PC533.1 PC534.1 PC535.1 PJP502.1 PL505.2 PU502.5
+5VS: C18.1 C23.1 C503.1 C504.1 C1121.1 JUFC1.27 R30.2 R435.2 R445.1 R5755.1 U4247.6
+5VS_AUDIO: C89.1 LA1.2 LA2.1 LA3.1 R114.2 RA31.1
+5VS_AUDIO_R: R114.1 U13.13 U13.14
+5VS_R: R30.1 U2.7 U2.8
+5VS_USH: C1126.1 JIO1.5 U4247.1
+AVDD1: CA19.1 CA22.1 CA23.1 LA1.1 UA1.40
+DVDD: CA1.1 CA2.1 CA5.1 CA6.1 CA33.1 CA39.1 RA13.1 RA29.2 RA33.1 RA36.2 RA40.1 RA41.1 RA42.1 RA43.1 RA44.1 UA1.4
+DVDDIO: CA36.1 CA38.1 Q25.6 RA18.2 RA26.2 UA1.12
+VBUS1_20V: PC104.1 PC105.1 PC106.1 PC107.1 PC108.1 PC109.1 PC133.1 PD103.2 PL100.2 PQ100.1 PQ100.2 PQ100.3 PQ133.3 PR100.1 PR213.1 PR218.1
+VBUS1_PD_20V: C159.2 C160.2 C161.2 C163.2 C165.1 CT1.1 CT11.1 CT19.1 D71.1 JUSBC1.A4 JUSBC1.A9 JUSBC1.B4 JUSBC1.B9 PC100.1 PC101.1 PC102.1 PC103.1 PL100.1 PT101.1(TP-1) UT1.A10 UT1.B10 UT1.H11 UT1.J10 UT1.J11 UT1.K11
+VBUS2_20V: PC115.1 PC117.1 PC118.1 PC119.1 PC121.1 PC123.1 PC134.1 PD106.2 PL101.2 PQ113.1 PQ113.2 PQ113.3 PQ135.3 PR128.1 PR219.1 PR220.1
+VBUS2_PD_20V: C192.2 C195.2 C197.2 C199.2 C202.1 CT4.1 CT23.1 CT24.1 D82.1 JUSBC2.A4 JUSBC2.A9 JUSBC2.B4 JUSBC2.B9 PC114.1 PC116.1 PC120.1 PC122.1 PL101.1 PT102.1(TP-1) UT2.A10 UT2.B10 UT2.H11 UT2.J10 UT2.J11 UT2.K11
+VCC_CORE: PC1200.1 PC1201.1 PC1202.1 PC1203.1 PC1220.1 PC1221.1 PC1222.1 PC1223.1 PC1224.1 PC1225.1 PC1227.1 PC1228.1 PC1229.1 PC1230.1 PC1231.1 PC1232.1 PC1233.1 PC1234.1 PC1237.1 PC1246.1 PC1247.1 PC1248.1 PC1250.1 PC1251.1 PC1252.1 PC1256.1 PC1259.1 PC1260.1 PC1261.1 PC1262.1 PC1263.1 PC1265.1 PC1266.1 PC1267.1 PC1268.1 PC1269.1 PC1270.1 PC1272.1 PC1273.1 PC1274.1 PC1275.1 PC1288.1 PC1289.1 PC1290.1 PC1291.1 PC1292.1 PC1293.1 PC1294.1 PC1295.1 PC1296.1 PC1297.1 PC1298.1 PC1299.1 PC1300.1 PC1301.1 PC1302.1 PC1303.1 PC1304.1 PC1305.1 PL1100.2 PL1101.2 PR1200.1 R275.1 R277.1 RC5.1 UCPU1.A30 UCPU1.A34 UCPU1.A39 UCPU1.A44 UCPU1.AK33 UCPU1.AK35 UCPU1.AK37 UCPU1.AK38 UCPU1.AK40 UCPU1.AL33 UCPU1.AL37 UCPU1.AL40 UCPU1.AM32 UCPU1.AM33 UCPU1.AM35 UCPU1.AM37 UCPU1.AM38 UCPU1.G30 UCPU1.G32 UCPU1.G33 UCPU1.G35 UCPU1.G37 UCPU1.G38 UCPU1.G40 UCPU1.G42 UCPU1.J30 UCPU1.J33 UCPU1.J37 UCPU1.J40 UCPU1.K33 UCPU1.K35 UCPU1.K37 UCPU1.K38 UCPU1.K40 UCPU1.K42 UCPU1.K43
+VCC_CORE_G0: T8.1(TP-1) UCPU1.K32
+VCC_CORE_G1: T18.1(TP-1) UCPU1.AK32
+VCC_GT: PC1207.1 PC1208.1 PC1209.1 PC1210.1 PC1211.1 PC1212.1 PC1213.1 PC1214.1 PC1215.1 PC1216.1 PC1218.1 PC1253.1 PC1254.1 PC1255.1 PC1258.1 PC1276.1 PC1278.1 PC1279.1 PC1281.1 PC1282.1 PC1283.1 PC1284.1 PC1285.1 PC1287.1 PC1306.1 PC1309.1 PC1311.1 PC1312.1 PC1313.1 PC1314.1 PC1315.1 PC1316.1 PC1317.1 PC1318.1 PC1319.1 PC1320.1 PC1321.1 PC1323.1 PC1324.1 PC1325.1 PC1331.1 PC1335.1 PC1336.1 PC1337.1 PC1339.1 PC1340.1 PC1341.1 PC1384.1 PC1385.1 PC1386.1 PC1387.1 PC1388.1 PC1389.1 PC1390.1 PC1391.1 PC1392.1 PC1393.1 PC1394.1 PC1395.1 PC1421.1 PC1422.1 PL1102.2 PR1201.1 R276.2 R278.2 R280.2 RC44.1 UCPU1.A58 UCPU1.A62 UCPU1.A66 UCPU1.AA63 UCPU1.AA64 UCPU1.AA66 UCPU1.AA67 UCPU1.AA69 UCPU1.AA70 UCPU1.AA71 UCPU1.AC64 UCPU1.AC65 UCPU1.AC66 UCPU1.AC67 UCPU1.AC68 UCPU1.AC69 UCPU1.AC70 UCPU1.AC71 UCPU1.AK53 UCPU1.AK55 UCPU1.AK56 UCPU1.AK58 UCPU1.AK60 UCPU1.AK70 UCPU1.AL53 UCPU1.AL56 UCPU1.AL60 UCPU1.AM53 UCPU1.AM56 UCPU1.AM58 UCPU1.AU58 UCPU1.AU63 UCPU1.BB57 UCPU1.BB66 UCPU1.J53 UCPU1.J55 UCPU1.J56 UCPU1.J58 UCPU1.J60 UCPU1.K53 UCPU1.K55 UCPU1.K56 UCPU1.K58 UCPU1.K60 UCPU1.L62 UCPU1.L63 UCPU1.L64 UCPU1.L65 UCPU1.L66 UCPU1.L67 UCPU1.L68 UCPU1.L69 UCPU1.L70 UCPU1.L71 UCPU1.M62 UCPU1.N63 UCPU1.N64 UCPU1.N66 UCPU1.N67 UCPU1.N69 UCPU1.N70 UCPU1.N71 UCPU1.R63 UCPU1.R64 UCPU1.R65 UCPU1.R66 UCPU1.R67 UCPU1.R68 UCPU1.R69 UCPU1.R70 UCPU1.R71 UCPU1.T62 UCPU1.U65 UCPU1.U68 UCPU1.U71 UCPU1.W63 UCPU1.W64 UCPU1.W65 UCPU1.W66 UCPU1.W67 UCPU1.W68 UCPU1.W69 UCPU1.W70 UCPU1.W71 UCPU1.Y62
+VCC_SA: PC1217.1 PC1322.1 PC1355.1 PC1356.1 PC1357.1 PC1358.1 PC1359.1 PC1360.1 PC1361.1 PC1362.1 PC1363.1 PC1364.1 PC1365.1 PC1366.1 PC1368.1 PC1369.1 PC1370.1 PL1103.2 PR1202.1 RC116.1 UCPU1.AK23 UCPU1.AK25 UCPU1.G23 UCPU1.G25 UCPU1.G27 UCPU1.G28 UCPU1.J22 UCPU1.J23 UCPU1.J27 UCPU1.K23 UCPU1.K25 UCPU1.K27 UCPU1.K28 UCPU1.K30
+VCCCLK1: CC5.1 RC16.2 UCPU1.A14
+VCCCLK2: CC42.1 RC117.2 UCPU1.K19
+VCCCLK3: RC104.2 UCPU1.L21
+VCCCLK4: CC40.1 RC118.2 UCPU1.N20
+VCCCLK5: CC41.1 RC105.2 UCPU1.L19
+VCCCLK6: RC15.2 UCPU1.A10
+VCCIA_GT: PC1326.1 PC1327.1 PC1328.1 PC1329.1 PC1330.1 PC1374.1 PC1375.1 PC1376.1 PC1377.1 PC1401.1 PC1402.1 PC1403.1 PC1404.1 PC1405.1 PC1406.1 PC1407.1 PC1408.1 PC1409.1 PC1410.1 PC1411.1 PC1412.1 PC1413.1 PC1414.1 PC1415.1 PC1416.1 PC1417.1 PC1418.1 PC1419.1 PC1420.1 R275.2 R276.1 R277.2 R278.1 R279.2 UCPU1.A48 UCPU1.A53 UCPU1.AK42 UCPU1.AK43 UCPU1.AK45 UCPU1.AK46 UCPU1.AK48 UCPU1.AK50 UCPU1.AL43 UCPU1.AL46 UCPU1.AL50 UCPU1.AM48 UCPU1.AM50 UCPU1.AM52 UCPU1.J43 UCPU1.J45 UCPU1.J46 UCPU1.J48 UCPU1.J50 UCPU1.J52 UCPU1.K48 UCPU1.K50
+VCCPLL_OC: CC68.1 CZ2.1 R48.2 UCPU1.AL23
+VCCPLL_OC_R: R48.1 UZ1.6
+VSS_PLL: CE47.2 CE48.2 UE3.G1
AGND: CA7.2 CA8.2 CA9.2 CA11.2 CA15.2 CA16.2 CA17.2 CA18.2 CA19.2 CA20.2 CA22.2 CA23.2 CA24.2 CA27.2 CA28.2 CA29.2 CA49.2 CA50.2 JP1.5 JP1.7 JP1.8 RA10.1 RA22.2 RA23.2 RA25.2 UA1.18 UA1.37
DV12S: CR5.1 CR6.2 CR9.2 UR1.10 UR1.14
DV33_18: CR15.2 UR1.18
GND: C1.2 C2.2 C3.2 C4.2 C5.2 C6.2 C7.2 C8.2 C9.2 C10.2 C11.2 C14.2 C15.2 C16.2 C17.2 C18.2 C19.2 C20.2 C21.1 C22.2 C23.2 C24.2 C27.2 C28.2 C29.2 C32.2 C37.2 C38.2 C39.2 C40.2 C41.2 C42.2 C44.2 C45.2 C46.2 C47.1 C48.2 C49.2 C50.2 C51.2 C52.2 C53.2 C54.2 C55.2 C56.2 C57.2 C58.2 C59.2 C60.2 C61.2 C62.1 C63.1 C64.1 C65.2 C66.2 C67.2 C68.2 C69.2 C70.2 C71.2 C72.2 C73.2 C74.2 C75.2 C76.2 C77.2 C78.2 C79.2 C80.2 C81.2 C82.2 C83.2 C84.2 C85.2 C86.2 C87.2 C88.2 C89.2 C90.2 C91.2 C92.2 C93.2 C94.2 C95.2 C96.2 C97.2 C98.2 C99.2 C100.2 C101.2 C102.2 C103.2 C104.2 C105.2 C106.2 C107.2 C108.2 C112.2 C113.2 C114.2 C115.2 C116.2 C117.2 C118.2 C119.2 C120.2 C121.2 C124.2 C125.2 C126.2 C127.2 C128.2 C129.2 C130.2 C131.2 C132.2 C133.2 C134.2 C135.1 C136.2 C138.2 C139.2 C140.2 C141.1 C142.2 C143.2 C144.2 C145.2 C146.2 C147.2 C148.2 C149.2 C150.2 C151.2 C152.2 C153.2 C154.2 C155.2 C156.2 C159.1 C160.1 C161.1 C163.1 C165.2 C167.1 C169.2 C172.2 C174.2 C182.2 C188.2 C189.2 C190.2 C191.2 C192.1 C193.1 C194.2 C195.1 C196.2 C197.1 C198.2 C199.1 C200.2 C201.2 C202.2 C203.2 C205.2 C206.2 C207.2 C208.2 C209.2 C210.2 C211.2 C212.2 C219.2 C220.2 C221.2 C222.2 C223.2 C224.2 C225.2 C226.2 C227.2 C228.2 C229.2 C230.2 C232.2 C233.2 C236.1 C500.2 C501.2 C502.2 C503.2 C504.2 C1034.2 C1035.2 C1036.2 C1037.2 C1038.2 C1039.2 C1040.2 C1120.2 C1121.2 C1122.2 C1123.2 C1124.2 C1125.2 C1126.2 C1127.2 C1128.2 C1129.2 C1130.2 C1131.2 C1132.2 C1133.2 C1134.2 C1136.2 C1137.2 C1138.2 CA1.2 CA2.2 CA3.2 CA4.2 CA5.2 CA6.2 CA13.2 CA25.2 CA26.2 CA30.2 CA31.1 CA32.2 CA33.2 CA34.2 CA35.2 CA36.2 CA37.2 CA38.2 CA39.2 CA40.2 CA41.2 CA42.2 CA43.2 CA44.2 CA45.2 CA46.2 CA47.2 CA48.2 CC1.2 CC2.2 CC3.2 CC4.2 CC5.2 CC7.2 CC8.2 CC11.2 CC13.2 CC14.2 CC15.2 CC16.2 CC17.2 CC18.2 CC19.2 CC20.2 CC22.2 CC23.2 CC24.2 CC25.1 CC26.2 CC27.2 CC28.2 CC29.2 CC30.2 CC32.2 CC33.2 CC34.2 CC35.2 CC36.2 CC37.2 CC38.2 CC39.2 CC40.2 CC41.2 CC42.2 CC43.2 CC44.2 CC45.2 CC46.2 CC47.2 CC48.2 CC49.2 CC50.2 CC51.2 CC52.2 CC53.2 CC54.2 CC55.2 CC56.2 CC57.2 CC58.2 CC59.2 CC60.2 CC61.2 CC62.2 CC63.2 CC64.2 CC65.2 CC66.2 CC67.2 CC68.2 CC69.2 CC70.2 CC71.2 CC72.2 CC73.2 CC74.2 CC75.2 CC76.2 CC77.2 CC78.1 CC79.2 CC80.2 CC81.2 CC82.2 CC83.2 CC84.2 CC85.2 CC86.2 CC87.2 CC88.2 CC90.2 CC91.1 CC92.2 CC93.2 CC94.2 CC95.2 CC96.1 CC97.1 CC98.2 CC99.2 CD1.2 CD2.2 CD3.2 CD4.2 CD5.2 CD6.2 CD7.2 CD8.2 CD9.2 CD10.2 CD11.2 CD12.2 CD13.2 CD14.2 CD15.2 CD16.2 CD17.2 CD18.2 CD19.2 CD21.2 CD22.2 CD23.2 CD24.2 CD25.2 CD26.2 CD27.2 CD28.2 CD29.2 CD30.2 CD31.2 CD32.2 CD33.2 CD34.2 CD35.2 CD36.2 CD37.2 CD38.2 CD39.2 CD40.2 CD41.2 CD47.2 CD48.2 CD49.2 CD50.2 CD51.2 CD52.2 CD53.2 CD54.2 CD55.2 CD56.2 CD57.2 CD58.2 CD59.2 CD60.2 CD61.2 CD62.2 CD63.2 CD64.2 CD65.2 CD66.2 CD68.2 CD69.2 CD70.2 CD71.2 CD72.2 CD73.2 CD74.2 CD75.2 CD76.2 CD77.2 CD78.2 CD79.2 CD80.2 CD81.2 CD82.2 CD83.2 CD84.2 CD85.2 CD100.2 CD101.2 CD102.2 CD103.2 CD104.2 CD105.2 CD106.2 CD107.2 CD108.2 CD109.2 CE8.2 CE9.2 CE10.2 CE11.2 CE12.2 CE13.2 CE14.2 CE15.2 CE18.2 CE19.2 CE21.2 CE24.2 CE25.2 CE30.2 CE46.2 CE49.2 CE54.2 CE55.2 CE57.2 CE64.2 CE65.2 CE78.2 CE86.2 CE87.2 CE88.1 CLIP1.1(TP-1) CLIP2.1(TP-1) CLIP3.1 CLIP4.1 CLIP5.1 CLIP6.1 CLIP7.1 CLIP8.1 CLIP9.1 CLIP10.1 CLIP11.1 CLIP12.1 CLIP13.1(TP-1) CLIP14.1 CLRP1.1 CMOS1.1 CR1.2 CR2.1 CR3.2 CR4.2 CR5.2 CR6.1 CR7.2 CR8.1 CR9.1 CR10.2 CR11.2 CR13.2 CR15.1 CR16.2 CR17.2 CR18.2 CR19.1 CR20.1 CR21.2 CS1.2 CS2.2 CS3.2 CS4.2 CS5.2 CS6.2 CS7.2 CS8.1 CS9.2 CS10.2 CT1.2 CT2.2 CT3.2 CT4.2 CT5.2 CT6.2 CT7.2 CT8.2 CT9.2 CT10.2 CT11.2 CT12.2 CT13.2 CT14.2 CT15.2 CT16.2 CT17.2 CT18.2 CT19.2 CT20.2 CT21.2 CT22.2 CT23.2 CT24.2 CT25.2 CT26.2 CT27.2 CT28.2 CT29.2 CT30.2 CT31.2 CT32.2 CT33.2 CV17.2 CV18.2 CV19.2 CV36.2 CV39.2 CV42.2 CV57.2 CV60.2 CV61.2 CV62.2 CZ1.2 CZ2.2 CZ3.2 CZ4.2 CZ5.2 CZ6.2 CZ7.2 CZ8.2 CZ9.2 CZ10.2 D1.2 D2.2 D3.2 D4.2 D5.2 D6.2 D7.2 D8.2 D9.2 D10.2 D11.2 D12.2 D13.2 D14.2 D15.2 D16.2 D17.2 D18.2 D19.2 D20.2 D21.2 D48.2 D49.2 D50.2 D51.2 D52.1 D53.1 D54.2 D55.2 D56.2 D57.2 D58.1 D59.1 D62.1 D63.1 D64.1 D65.1 D68.2 D69.1 D70.2 D71.2 D72.1 D73.1 D74.2 D75.2 D76.1 D77.1 D78.1 D79.1 D80.2 D81.2 D82.2 D83.1 D84.1 D85.2 D86.2 D87.1 D88.1 D89.1 DA1.2 DA3.2 DA4.2 DA5.2 DA6.2 DA8.1 DA9.1 DI1.1 H1.1(TP-1) H2.1(TP-1) H3.1(TP-1) H4.1(TP-1) H5.1(TP-1) H6.1(TP-1) H7.1(TP-1) H8.1(TP-1) H9.1(TP-1) H10.1(TP-1) H11.1(TP-1) H12.1(TP-1) H13.1(TP-1) JANT3.2 JANT3.3 JANT3.4 JAPS1.5 JAPS1.7 JAPS1.9 JAPS1.11 JAPS1.19 JAPS1.20 JCR1.6 JCR1.10 JCR1.11 JCR1.12 JCR1.15 JCR1.18 JCR1.21 JCR1.22 JCR1.23 JDEG3.10 JDEG3.11 JDEG3.12 JEDP1.8 JEDP1.11 JEDP1.13 JEDP1.32 JEDP1.34 JEDP1.41 JEDP1.44 JEDP1.47 JEDP1.50 JEDP1.51 JEDP1.52 JEDP1.53 JEDP1.54 JEDP1.55 JESPI1.9 JESPI1.11 JESPI1.12 JFAN1.1 JFAN1.5 JFAN1.6 JIO1.12 JIO1.13 JIO1.14 JIO1.15 JIO1.26 JIO1.32 JIO1.34 JIO1.36 JIO1.38 JIO1.39 JIO1.41 JIO1.42 JIO1.43 JIO1.44 JIO2.1 JIO2.2 JIO2.3 JIO2.4 JIO2.6 JIO2.9 JIO2.12 JIO2.28 JIO2.29 JIO2.30 JIO2.31 JIO2.32 JIR1.5 JIR1.6 JIR1.7 JIR1.8 JIR1.12 JIR1.13 JIR1.14 JNGFF1.3 JNGFF1.5 JNGFF1.11 JNGFF1.27 JNGFF1.33 JNGFF1.39 JNGFF1.45 JNGFF1.51 JNGFF1.57 JNGFF1.71 JNGFF1.73 JNGFF1.76 JNGFF1.77 JNGFF2.1 JNGFF2.3 JNGFF2.9 JNGFF2.15 JNGFF2.21 JNGFF2.27 JNGFF2.33 JNGFF2.39 JNGFF2.45 JNGFF2.51 JNGFF2.57 JNGFF2.71 JNGFF2.73 JNGFF2.75 JNGFF2.76 JNGFF2.77 JNGFF3.1 JNGFF3.7 JNGFF3.18 JNGFF3.23 JNGFF3.24 JNGFF3.29 JNGFF3.30 JNGFF3.33 JNGFF3.36 JNGFF3.39 JNGFF3.45 JNGFF3.51 JNGFF3.57 JNGFF3.63 JNGFF3.69 JNGFF3.75 JNGFF3.76 JNGFF3.77 JRTC1.2 JRTC1.3 JRTC1.4 JSIM1.4 JSIM1.7 JSIM1.9 JSIM1.10 JSIM1.11 JSPI2.10 JSPI2.11 JSPI2.12 JSPK.6 JSPK.7 JSPK.8 JT100.1 JT100.2 JT100.3 JT100.4 JT100.13 JT100.14 JUART.5 JUART.6 JUFC1.2 JUFC1.8 JUFC1.9 JUFC1.13 JUFC1.14 JUFC1.20 JUFC1.21 JUSB1.4 JUSB1.7 JUSB1.11 JUSB1.12 JUSB1.13 JUSB1.14 JUSBC1.A1 JUSBC1.A12 JUSBC1.B1 JUSBC1.B12 JUSBC2.A1 JUSBC2.A12 JUSBC2.B1 JUSBC2.B12 JWFC1.1 JWFC1.4 JWFC1.7 JWFC1.10 JWFC1.13 JWFC1.16 JWFC1.23 JWFC1.26 JWFC1.28 JWFC1.35 JWFC1.36 JWFC1.37 JWFC1.38 JXDP1.2 JXDP1.7 JXDP1.8 JXDP1.13 JXDP1.14 JXDP1.19 JXDP1.20 JXDP1.25 JXDP1.26 JXDP1.31 JXDP1.32 JXDP1.37 JXDP1.38 JXDP1.49 JXDP1.50 JXDP1.59 JXDP1.61 JXDP1.62 JXDP1.63 L13.2 L14.2 L80.1 LGA1.6 LGA1.7 LT1.2 LT2.2 MC1.2 MD1.7 MIC1.5 MIC1.6 MIC1.7 MIC1.8 MIC2.2 MIC2.5 MIC2.6 MIC2.7 MIC2.8 MIC3.5 MIC3.6 MIC3.7 MIC3.8 PC100.2 PC101.2 PC102.2 PC103.2 PC104.2 PC105.2 PC106.2 PC107.2 PC108.2 PC114.2 PC115.2 PC116.2 PC117.2 PC118.2 PC119.2 PC120.2 PC121.2 PC122.2 PC126.2 PC127.2 PC128.2 PC129.2 PC130.2 PC131.2 PC132.1 PC133.2 PC134.2 PC140.2 PC144.2 PC145.2 PC146.2 PC147.2 PC148.2 PC149.2 PC150.2 PC151.2 PC280.2 PC281.2 PC282.2 PC283.2 PC284.2 PC285.2 PC286.2 PC301.2 PC302.2 PC303.2 PC304.2 PC305.2 PC306.2 PC307.2 PC308.2 PC309.2 PC310.2 PC313.2 PC314.2 PC315.2 PC316.2 PC317.2 PC318.2 PC319.2 PC320.2 PC321.2 PC322.2 PC323.2 PC324.2 PC325.2 PC326.2 PC327.2 PC328.2 PC329.2 PC331.2 PC332.2 PC333.1 PC334.2 PC335.1 PC337.2 PC338.2 PC339.2 PC340.2 PC341.2 PC342.2 PC343.2 PC345.1 PC347.2 PC348.2 PC349.2 PC350.2 PC351.2 PC352.2 PC400.2 PC403.2 PC404.2 PC405.2 PC406.2 PC407.2 PC418.2 PC501.2 PC502.2 PC503.2 PC504.2 PC505.1 PC506.2 PC507.2 PC508.2 PC509.2 PC510.2 PC511.2 PC514.2 PC515.2 PC516.2 PC517.2 PC518.1 PC519.2 PC520.2 PC521.2 PC522.2 PC523.2 PC524.2 PC527.2 PC528.2 PC529.2 PC530.2 PC531.1 PC532.2 PC533.2 PC534.2 PC535.2 PC536.2 PC537.2 PC601.2 PC603.2 PC604.2 PC605.2 PC606.2 PC607.2 PC608.2 PC609.2 PC610.2 PC611.2 PC612.2 PC613.2 PC614.2 PC615.2 PC700.2 PC701.2 PC703.2 PC704.2 PC705.2 PC706.2 PC708.2 PC709.2 PC710.2 PC711.2 PC712.2 PC713.2 PC720.1 PC722.2 PC723.2 PC724.2 PC725.2 PC726.2 PC727.2 PC728.1 PC730.2 PC731.2 PC732.2 PC733.2 PC734.2 PC735.2 PC736.2 PC800.2 PC801.2 PC802.2 PC803.2 PC804.2 PC805.2 PC806.2 PC807.2 PC808.2 PC809.2 PC810.2 PC811.2 PC812.2 PC813.2 PC814.2 PC815.2 PC816.2 PC817.2 PC818.2 PC819.2 PC900.1 PC901.2 PC902.2 PC903.2 PC904.1 PC905.1 PC906.1 PC907.2 PC911.2 PC931.2 PC932.2 PC933.2 PC1003.2 PC1007.2 PC1008.2 PC1009.2 PC1010.2 PC1011.2 PC1012.2 PC1013.2 PC1014.2 PC1028.2 PC1030.2 PC1103.2 PC1104.2 PC1105.2 PC1106.2 PC1107.2 PC1108.2 PC1109.2 PC1111.2 PC1112.2 PC1113.2 PC1115.2 PC1116.2 PC1117.2 PC1118.2 PC1119.2 PC1121.2 PC1122.2 PC1123.2 PC1124.2 PC1125.2 PC1200.2 PC1201.2 PC1202.2 PC1203.2 PC1207.2 PC1208.2 PC1209.2 PC1210.2 PC1211.2 PC1212.2 PC1213.2 PC1214.2 PC1215.2 PC1216.2 PC1217.2 PC1218.2 PC1220.2 PC1221.2 PC1222.2 PC1223.2 PC1224.2 PC1225.2 PC1227.2 PC1228.2 PC1229.2 PC1230.2 PC1231.2 PC1232.2 PC1233.2 PC1234.2 PC1237.2 PC1246.2 PC1247.2 PC1248.2 PC1250.2 PC1251.2 PC1252.2 PC1253.2 PC1254.2 PC1255.2 PC1256.2 PC1258.2 PC1259.2 PC1260.2 PC1261.2 PC1262.2 PC1263.2 PC1265.2 PC1266.2 PC1267.2 PC1268.2 PC1269.2 PC1270.2 PC1272.2 PC1273.2 PC1274.2 PC1275.2 PC1276.2 PC1278.2 PC1279.2 PC1281.2 PC1282.2 PC1283.2 PC1284.2 PC1285.2 PC1287.2 PC1288.2 PC1289.2 PC1290.2 PC1291.2 PC1292.2 PC1293.2 PC1294.2 PC1295.2 PC1296.2 PC1297.2 PC1298.2 PC1299.2 PC1300.2 PC1301.2 PC1302.2 PC1303.2 PC1304.2 PC1305.2 PC1306.2 PC1309.2 PC1311.2 PC1312.2 PC1313.2 PC1314.2 PC1315.2 PC1316.2 PC1317.2 PC1318.2 PC1319.2 PC1320.2 PC1321.2 PC1322.2 PC1323.2 PC1324.2 PC1325.2 PC1326.2 PC1327.2 PC1328.2 PC1329.2 PC1330.2 PC1331.2 PC1335.2 PC1336.2 PC1337.2 PC1339.2 PC1340.2 PC1341.2 PC1355.2 PC1356.2 PC1357.2 PC1358.2 PC1359.2 PC1360.2 PC1361.2 PC1362.2 PC1363.2 PC1364.2 PC1365.2 PC1366.2 PC1368.2 PC1369.2 PC1370.2 PC1374.2 PC1375.2 PC1376.2 PC1377.2 PC1384.2 PC1385.2 PC1386.2 PC1387.2 PC1388.2 PC1389.2 PC1390.2 PC1391.2 PC1392.2 PC1393.2 PC1394.2 PC1395.2 PC1401.2 PC1402.2 PC1403.2 PC1404.2 PC1405.2 PC1406.2 PC1407.2 PC1408.2 PC1409.2 PC1410.2 PC1411.2 PC1412.2 PC1413.2 PC1414.2 PC1415.2 PC1416.2 PC1417.2 PC1418.2 PC1419.2 PC1420.2 PC1421.2 PC1422.2 PC1423.1 PC1424.2 PC1425.2 PC1426.2 PC1427.2 PC1428.2 PC1429.2 PC1430.2 PC1431.2 PC1432.2 PC1433.2 PC1434.2 PC1435.2 PC1436.2 PC1437.2 PC1438.2 PC1439.2 PC1440.2 PD104.1 PD105.1 PD906.2 PQ106.3 PQ108.3 PQ109.1 PQ109.4 PQ110.3 PQ111.3 PQ112.3 PQ118.3 PQ119.3 PQ120.1 PQ120.4 PQ121.1 PQ121.4 PQ122.4 PQ125.1 PQ125.4 PQ126.3 PQ127.1 PQ127.4 PQ129.1 PQ129.4 PQ130.3 PQ131.3 PQ132.3 PQ134.1 PQ134.4 PQ136.1 PQ136.4 PQ139.1 PQ139.4 PQ140.3 PQ280.3 PQ305.1 PQ305.2 PQ305.3 PQ306.1 PQ306.2 PQ306.3 PQ308.3 PR102.2 PR126.2 PR153.2 PR162.2 PR166.2 PR172.2 PR176.2 PR177.2 PR178.1 PR179.1 PR218.2 PR219.2 PR228.2 PR229.2 PR248.2 PR255.2 PR256.2 PR257.2 PR258.2 PR269.2 PR270.2 PR272.2 PR284.2 PR285.2 PR307.2 PR312.2 PR322.2 PR325.1 PR333.2 PR334.1 PR336.2 PR346.2 PR347.2 PR420.1 PR500.1 PR505.2 PR506.1 PR511.1 PR516.2 PR517.2 PR518.2 PR604.2 PR607.2 PR609.2 PR612.2 PR701.2 PR706.2 PR708.1 PR724.2 PR731.2 PR803.2 PR808.2 PR809.2 PR812.2 PR816.2 PR820.2 PR821.2 PR825.2 PR936.1 PR938.1 PR939.1 PR941.1 PR942.2 PR944.1 PR945.1 PR946.2 PR956.1 PR1200.2 PR1201.2 PR1202.2 PU101.2 PU103.2 PU104.2 PU105.2 PU280.4 PU280.6 PU300.33 PU301.3 PU400.20 PU400.21 PU400.29 PU500.2 PU500.10 PU501.2 PU501.10 PU502.2 PU502.10 PU600.2 PU600.4 PU700.7 PU700.8 PU700.18 PU700.21 PU720.6 PU720.8 PU720.15 PU720.16 PU720.17 PU721.6 PU721.8 PU721.15 PU721.16 PU721.17 PU800.15 PU800.16 PU800.17 PU801.6 PU801.15 PU801.16 PU801.17 PU900.49 PU1005.5 PU1005.6 PU1005.7 PU1005.13 PU1006.5 PU1006.6 PU1006.7 PU1006.13 PU1107.5 PU1107.6 PU1107.7 PU1107.13 PU1108.4 PU1108.5 PU1108.11 Q9.1 Q9.4 Q10.3 Q12.3 Q16.3 Q25.4 Q26.1 Q26.4 Q31.3 Q32.3 Q348.3 Q353.3 Q356.3 QE13.1 QE13.4 QE14.1 QE14.4 QR1.3 R3.1 R14.1 R31.1 R51.1 R56.2 R61.2 R67.2 R73.1 R76.2 R77.2 R84.2 R85.2 R109.2 R117.1 R139.1 R146.1 R151.1 R155.2 R158.2 R159.2 R160.2 R209.2 R211.2 R215.2 R216.1 R217.2 R219.2 R434.2 R442.2 R451.2 R468.1 R481.2 R488.1 R490.2 R2745.2 R5751.1 R5752.1 R5753.1 R5754.1 R5767.1 R5772.2 R5776.2 R5780.1 RA15.2 RA19.1 RA21.2 RA22.1 RA23.1 RA25.1 RA30.2 RC6.2 RC17.1 RC29.1 RC30.1 RC37.1 RC40.1 RC42.2 RC46.1 RC66.2 RC74.2 RC80.2 RC96.2 RC102.1 RC106.1 RC111.1 RC112.2 RC114.2 RC115.2 RC122.2 RC123.2 RC124.1 RC126.1 RC137.2 RC140.2 RC142.1 RC152.2 RC154.1 RC155.2 RC160.2 RC164.2 RC165.2 RC166.2 RC167.2 RC189.1 RC397.1 RD1.2 RD2.2 RD3.2 RD4.2 RD7.2 RD8.2 RD9.2 RD11.2 RD13.2 RD14.2 RD16.2 RD17.2 RD19.2 RD20.2 RE2.1 RE14.2 RE16.2 RE17.1 RE24.1 RE25.1 RE29.2 RE31.1 RE41.2 RE44.2 RE48.2 RE51.1 RE54.2 RE58.2 RE69.1 RE112.2 RE122.1 RE154.2 RE157.2 RE247.1 RH10.1 RH13.1 RH14.2 RH16.1 RH18.1 RH21.1 RH28.2 RH31.2 RH90.2 RH91.2 RR1.1 RS6.2 RS11.2 RT2.1 RT13.1 RT14.1 RT15.1 RT18.1 RT21.2 RT22.1 RT23.2 RT24.2 RT53.2 RT58.2 RT69.1 RT70.1 RT73.1 RT74.1 RT82.1 RT88.2 RT91.1 RT96.2 RT99.2 RT100.2 RT101.2 RT102.2 RT104.2 RT106.2 RT107.1 RT108.1 RT109.2 RT110.2 RT111.2 RT112.2 RT120.1 RT124.1 RV5.2 RV7.2 RV12.2 RV15.1 RV17.2 RV18.2 RV20.2 RV21.2 RV30.2 RV31.2 RV35.2 RV38.2 RV40.2 RV44.1 RV46.2 RV47.2 RV50.2 RV72.2 RV74.2 RV76.1 RV78.1 RV80.1 RV82.1 RV84.1 RV86.1 RZ2.2 SW1.1 SW1.3 SW1.4 SW1.5 SW2.1 SW2.3 SW2.4 SW2.5 SW3.2 SW3.4 U1.B2 U2.5 U2.9 U3.2 U3.6 U3.8 U3.11 U3.12 U4.2 U4.5 U4.11 U4.20 U4.21 U7.2 U8.2 U9.4 U9.9 U10.3 U10.7 U11.5 U11.9 U12.A2 U12.B4 U12.F4 U12.F7 U12.G1 U12.G2 U12.G3 U12.G4 U12.H7 U13.11 U13.15 U14.11 U14.15 U15.3 U16.2 U17.11 U17.15 U21.11 U21.15 U22.4 U22.9 U23.3 U44.3 U4245.3 U4246.9 U4246.16 U4246.23 U4246.32 U4246.33 U4247.2 U4248.2 U4249.2 U4250.2 U4251.7 U4251.8 U4252.3 U4255.5 U4255.9 UA1.49 UC1.3 UC2.3 UC3.3 UC4.3 UC5.3 UC7.3 UC8.3 UCPU1.A5 UCPU1.A67 UCPU1.A70 UCPU1.AA2 UCPU1.AA4 UCPU1.AA65 UCPU1.AA68 UCPU1.AB8 UCPU1.AB15 UCPU1.AB16 UCPU1.AB18 UCPU1.AB21 UCPU1.AD8 UCPU1.AD13 UCPU1.AD16 UCPU1.AD19 UCPU1.AD20 UCPU1.AD21 UCPU1.AD62 UCPU1.AE64 UCPU1.AE65 UCPU1.AE66 UCPU1.AE67 UCPU1.AE68 UCPU1.AE69 UCPU1.AF1 UCPU1.AF2 UCPU1.AF4 UCPU1.AF10 UCPU1.AF15 UCPU1.AF17 UCPU1.AF63 UCPU1.AG16 UCPU1.AG17 UCPU1.AG18 UCPU1.AG19 UCPU1.AG20 UCPU1.AG21 UCPU1.AG71 UCPU1.AH6 UCPU1.AH13 UCPU1.AH63 UCPU1.AH64 UCPU1.AH67 UCPU1.AJ4 UCPU1.AJ15 UCPU1.AJ18 UCPU1.AJ20 UCPU1.AK8 UCPU1.AK11 UCPU1.AK16 UCPU1.AK18 UCPU1.AK21 UCPU1.AK22 UCPU1.AK27 UCPU1.AK63 UCPU1.AK68 UCPU1.AK69 UCPU1.AL2 UCPU1.AL4 UCPU1.AL28 UCPU1.AL32 UCPU1.AL35 UCPU1.AL38 UCPU1.AL45 UCPU1.AL48 UCPU1.AL52 UCPU1.AL55 UCPU1.AL58 UCPU1.AL64 UCPU1.AL65 UCPU1.AL66 UCPU1.AM8 UCPU1.AM13 UCPU1.AM21 UCPU1.AM25 UCPU1.AM27 UCPU1.AM43 UCPU1.AM45 UCPU1.AM46 UCPU1.AM55 UCPU1.AM60 UCPU1.AM61 UCPU1.AM68 UCPU1.AM71 UCPU1.AN20 UCPU1.AN23 UCPU1.AN28 UCPU1.AN30 UCPU1.AN32 UCPU1.AN33 UCPU1.AN35 UCPU1.AN37 UCPU1.AN38 UCPU1.AN40 UCPU1.AN42 UCPU1.AN58 UCPU1.AN63 UCPU1.AP10 UCPU1.AP18 UCPU1.AP20 UCPU1.AP23 UCPU1.AP28 UCPU1.AP32 UCPU1.AP35 UCPU1.AP38 UCPU1.AP42 UCPU1.AP58 UCPU1.AP63 UCPU1.AP68 UCPU1.AP70 UCPU1.AR5 UCPU1.AR8 UCPU1.AR11 UCPU1.AR15 UCPU1.AR16 UCPU1.AR20 UCPU1.AR23 UCPU1.AR28 UCPU1.AR35 UCPU1.AR42 UCPU1.AR43 UCPU1.AR45 UCPU1.AR46 UCPU1.AR48 UCPU1.AR50 UCPU1.AR52 UCPU1.AR53 UCPU1.AR55 UCPU1.AR58 UCPU1.AR63 UCPU1.AT2 UCPU1.AT4 UCPU1.AT20 UCPU1.AT23 UCPU1.AT28 UCPU1.AT35 UCPU1.AT42 UCPU1.AT56 UCPU1.AT58 UCPU1.AT63 UCPU1.AT68 UCPU1.AT71 UCPU1.AU10 UCPU1.AU15 UCPU1.AU20 UCPU1.AU32 UCPU1.AU38 UCPU1.AV1 UCPU1.AV68 UCPU1.AV69 UCPU1.AV70 UCPU1.AV71 UCPU1.AW6 UCPU1.AW8 UCPU1.AW10 UCPU1.AW12 UCPU1.AW14 UCPU1.AW16 UCPU1.AW18 UCPU1.AW21 UCPU1.AW23 UCPU1.AW26 UCPU1.AW28 UCPU1.AW30 UCPU1.AW32 UCPU1.AW34 UCPU1.AW36 UCPU1.AW38 UCPU1.AW41 UCPU1.AW43 UCPU1.AW45 UCPU1.AW47 UCPU1.AW49 UCPU1.AW51 UCPU1.AW53 UCPU1.AW55 UCPU1.AW57 UCPU1.AW60 UCPU1.AW62 UCPU1.AW64 UCPU1.AW66 UCPU1.AY3 UCPU1.AY66 UCPU1.AY71 UCPU1.B10 UCPU1.B14 UCPU1.B18 UCPU1.B22 UCPU1.B30 UCPU1.B34 UCPU1.B39 UCPU1.B44 UCPU1.B48 UCPU1.B53 UCPU1.B58 UCPU1.B62 UCPU1.B66 UCPU1.B71 UCPU1.BA1 UCPU1.BA2 UCPU1.BA6 UCPU1.BA10 UCPU1.BA14 UCPU1.BA18 UCPU1.BA23 UCPU1.BA28 UCPU1.BA32 UCPU1.BA36 UCPU1.BA41 UCPU1.BA45 UCPU1.BA49 UCPU1.BA53 UCPU1.BA57 UCPU1.BA62 UCPU1.BA66 UCPU1.BA71 UCPU1.BB6 UCPU1.BB18 UCPU1.BB26 UCPU1.BB30 UCPU1.BB34 UCPU1.BB38 UCPU1.BB43 UCPU1.BB55 UCPU1.BB60 UCPU1.BB64 UCPU1.BB67 UCPU1.BB70 UCPU1.C1 UCPU1.C5 UCPU1.C25 UCPU1.D6 UCPU1.D10 UCPU1.D11 UCPU1.D14 UCPU1.D18 UCPU1.D22 UCPU1.D25 UCPU1.D26 UCPU1.D30 UCPU1.D34 UCPU1.D39 UCPU1.D44 UCPU1.D45 UCPU1.D47 UCPU1.D48 UCPU1.D53 UCPU1.D58 UCPU1.D62 UCPU1.D66 UCPU1.D69 UCPU1.E6 UCPU1.E11 UCPU1.E15 UCPU1.E18 UCPU1.E21 UCPU1.E46 UCPU1.E50 UCPU1.E53 UCPU1.E56 UCPU1.E65 UCPU1.E71 UCPU1.F1 UCPU1.F2 UCPU1.F4 UCPU1.F8 UCPU1.F13 UCPU1.F22 UCPU1.F23 UCPU1.F27 UCPU1.F28 UCPU1.F32 UCPU1.F33 UCPU1.F35 UCPU1.F37 UCPU1.F38 UCPU1.F40 UCPU1.F42 UCPU1.F65 UCPU1.F68 UCPU1.G5 UCPU1.G6 UCPU1.G10 UCPU1.G22 UCPU1.G43 UCPU1.G45 UCPU1.G48 UCPU1.G52 UCPU1.G55 UCPU1.G58 UCPU1.G60 UCPU1.G63 UCPU1.G65 UCPU1.G66 UCPU1.H15 UCPU1.H18 UCPU1.H71 UCPU1.J8 UCPU1.J11 UCPU1.J13 UCPU1.J25 UCPU1.J28 UCPU1.J32 UCPU1.J35 UCPU1.J38 UCPU1.J42 UCPU1.K16 UCPU1.K18 UCPU1.K22 UCPU1.K61 UCPU1.K63 UCPU1.K64 UCPU1.K65 UCPU1.K66 UCPU1.K67 UCPU1.K68 UCPU1.K70 UCPU1.K71 UCPU1.L2 UCPU1.L4 UCPU1.L8 UCPU1.L11 UCPU1.L16 UCPU1.L17 UCPU1.L18 UCPU1.L20 UCPU1.N6 UCPU1.N10 UCPU1.N13 UCPU1.N19 UCPU1.N21 UCPU1.N65 UCPU1.N68 UCPU1.P17 UCPU1.P19 UCPU1.P20 UCPU1.P21 UCPU1.R6 UCPU1.R13 UCPU1.T2 UCPU1.T4 UCPU1.T15 UCPU1.T17 UCPU1.T18 UCPU1.T21 UCPU1.U10 UCPU1.U63 UCPU1.U64 UCPU1.U66 UCPU1.U67 UCPU1.U69 UCPU1.U70 UCPU1.V16 UCPU1.V17 UCPU1.V18 UCPU1.W6 UCPU1.W9 UCPU1.W13 UCPU1.Y17 UCPU1.Y19 UCPU1.Y20 UCPU1.Y21 UD1.B2 UD1.B5 UD1.B6 UD1.B12 UD1.C3 UD1.C5 UD1.C6 UD1.D3 UD1.D8 UD1.D12 UD1.E4 UD1.E5 UD1.E6 UD1.F4 UD1.F5 UD1.F6 UD1.F12 UD1.G3 UD1.G4 UD1.G6 UD1.G8 UD1.G9 UD1.H2 UD1.H10 UD1.J4 UD1.J12 UD1.K2 UD1.K10 UD1.L6 UD1.L8 UD1.L9 UD1.M4 UD1.M5 UD1.M6 UD1.M12 UD1.N4 UD1.N5 UD1.N6 UD1.P3 UD1.P8 UD1.P12 UD1.R4 UD1.R5 UD1.R6 UD1.T2 UD1.T3 UD1.T4 UD1.T5 UD1.T6 UD1.T12 UD2.B2 UD2.B5 UD2.B6 UD2.B12 UD2.C3 UD2.C5 UD2.C6 UD2.D3 UD2.D8 UD2.D12 UD2.E4 UD2.E5 UD2.E6 UD2.F4 UD2.F5 UD2.F6 UD2.F12 UD2.G3 UD2.G4 UD2.G6 UD2.G8 UD2.G9 UD2.H2 UD2.H10 UD2.J4 UD2.J12 UD2.K2 UD2.K10 UD2.L6 UD2.L8 UD2.L9 UD2.M4 UD2.M5 UD2.M6 UD2.M12 UD2.N4 UD2.N5 UD2.N6 UD2.P3 UD2.P8 UD2.P12 UD2.R4 UD2.R5 UD2.R6 UD2.T2 UD2.T3 UD2.T4 UD2.T5 UD2.T6 UD2.T12 UD3.B2 UD3.B5 UD3.B6 UD3.B12 UD3.C3 UD3.C5 UD3.C6 UD3.D3 UD3.D8 UD3.D12 UD3.E4 UD3.E5 UD3.E6 UD3.F4 UD3.F5 UD3.F6 UD3.F12 UD3.G3 UD3.G4 UD3.G6 UD3.G8 UD3.G9 UD3.H2 UD3.H10 UD3.J4 UD3.J12 UD3.K2 UD3.K10 UD3.L6 UD3.L8 UD3.L9 UD3.M4 UD3.M5 UD3.M6 UD3.M12 UD3.N4 UD3.N5 UD3.N6 UD3.P3 UD3.P8 UD3.P12 UD3.R4 UD3.R5 UD3.R6 UD3.T2 UD3.T3 UD3.T4 UD3.T5 UD3.T6 UD3.T12 UD4.B2 UD4.B5 UD4.B6 UD4.B12 UD4.C3 UD4.C5 UD4.C6 UD4.D3 UD4.D8 UD4.D12 UD4.E4 UD4.E5 UD4.E6 UD4.F4 UD4.F5 UD4.F6 UD4.F12 UD4.G3 UD4.G4 UD4.G6 UD4.G8 UD4.G9 UD4.H2 UD4.H10 UD4.J4 UD4.J12 UD4.K2 UD4.K10 UD4.L6 UD4.L8 UD4.L9 UD4.M4 UD4.M5 UD4.M6 UD4.M12 UD4.N4 UD4.N5 UD4.N6 UD4.P3 UD4.P8 UD4.P12 UD4.R4 UD4.R5 UD4.R6 UD4.T2 UD4.T3 UD4.T4 UD4.T5 UD4.T6 UD4.T12 UE3.A6 UE3.A13 UE3.C4 UE3.E6 UE3.H4 UE5.3 UE7.3 UH1.4 UH1.9 UR1.33 US1.14 US1.17 UT1.A1 UT1.B8 UT1.D8 UT1.E5 UT1.E6 UT1.E7 UT1.E8 UT1.F5 UT1.F6 UT1.F7 UT1.F8 UT1.G5 UT1.G6 UT1.G7 UT1.G8 UT1.H4 UT1.H5 UT1.H8 UT1.L1 UT2.A1 UT2.B8 UT2.D8 UT2.E5 UT2.E6 UT2.E7 UT2.E8 UT2.F5 UT2.F6 UT2.F7 UT2.F8 UT2.G5 UT2.G6 UT2.G7 UT2.G8 UT2.H4 UT2.H5 UT2.H8 UT2.L1 UV1.41 UV2.41 UZ1.5 UZ2.5 UZ3.5 UZ4.11 UZ4.15 Y1.2 Y1.4 YC1.2 YC1.4 YC3.2 YC3.4
GND_SIGNAL: PC401.2 PC402.2 PC408.2 PC409.2 PC410.2 PC411.2 PC412.2 PC413.2 PC414.2 PC415.2 PC416.2 PC417.2 PR401.1 PR403.1 PR405.1 PR406.1 PR408.2 PR412.2 PR413.2 PR414.2 PR415.2 PR418.2 PR419.2 PR420.2 PU400.11
VBUS1_ECOK: PR114.2 PR138.1 RE24.2 UE3.M6
VBUS2_ECOK: PR135.2 PR145.1 UE3.N3
VBUSSENSE: RC61.1 RH91.1 UCPU1.AG4
VCC_GT_SENSE: PR906.2 RC44.2 UCPU1.J70
VCCDSW_EN_GPIO: Q353.2 R235.1 UE3.M7
VCCIO_SENSE: PR810.2 RC147.2 UCPU1.AM23
VCCSENSE: PR903.2 RC5.2 UCPU1.E32
VCCST_EN: R427.2 RE48.1 UC8.4 UZ3.4
VCCST_PWRGD_CPU: RC26.2 UCPU1.B65
VCCSTG_EN: RZ1.1 RZ2.1 UC2.4 UZ2.4
VDD: PC335.2 PR308.2 PR319.1 PR331.1 PU300.18
VDD18_CORE: PR935.1 PR937.1
VIN_1.0VA: PC703.1 PC704.1 PC705.1 PC706.1 PL700.2 PU700.2 PU700.3 PU700.4 PU700.5
VIN_1.8VA: PC723.1 PC724.1 PC725.1 PL720.2 PU720.10 PU720.11 PU720.12
VIN_1.8VU: PC731.1 PC732.1 PC733.1 PL722.2 PU721.10 PU721.11 PU721.12
VIN_PRIM: PC811.1 PC812.1 PC816.1 PC817.1 PL802.2 PR1204.2 PU801.10 PU801.11 PU801.12
VIN_VCCIO: PC801.1 PC802.1 PC806.1 PC807.1 PL800.2 PU800.10 PU800.11 PU800.12
VSS_GT_SENSE: PR907.2 RC42.1 UCPU1.J69
VSSIO_SENSE: PR811.2 RC155.1 UCPU1.AM22
VSSSENSE: PR904.2 RC6.1 UCPU1.E33
32KHZ_OUT: CE57.1 UE3.F3
+BAT_TABLET: PC127.1 PC340.1 PL102.2 PL103.2 PQ304.5 PR126.1 PR330.2
+BATT: JT100.9 JT100.10 JT100.11 JT100.12 PC126.1 PC132.2 PL102.1 PL103.1
+BMC_LDO_PD1: CT15.1 UT1.E1
+BMC_LDO_PD2: CT30.1 UT2.E1
+CHG_SRC_20V: PC302.1 PC303.1 PC304.1 PC305.1 PC306.1 PC307.1 PC308.1 PC309.1 PC310.1 PQ302.5 PR300.1
+CHG_VIN_20V: PC111.1 PC124.1 PD300.2 PD906.1 PL302.1 PQ101.1 PQ101.2 PQ101.3 PQ104.3 PQ114.1 PQ114.2 PQ114.3 PQ115.3 PR101.1 PR103.1 PR129.1 PR130.1 PR268.1 PR303.1
+INV_PWR_SRC: C232.1 C233.1 PC400.1 PC401.1 PL400.1 PU400.26 Q33.1 Q33.2 Q33.5 Q33.6 R484.2
+LCDVDD: C40.1 C41.1 C167.2 C169.1 C172.1 C174.1 C182.1 JEDP1.38 JEDP1.39 R75.2 R411.1 R5766.1
+LED_AN: C188.1 C189.1 C190.1 C1038.1 JEDP1.19 JEDP1.20 JEDP1.21 PC403.1 PC404.1 PC405.1 PC406.1 PC418.1 PD400.1 PR410.1
+PECI_VREF: RE261.1 UE3.J11
+RTCBATT: JRTC1.1 RA12.1 RTCR1.2
+RTCVCC: C1040.1 CC70.1 CC79.1 Q349.1 R2751.1 R5768.1 RC85.1 RC88.2 RC89.1 UCPU1.AK19 UCPU1.BB14
+RTCVCC_EC: C112.1 Q349.3 R2751.2 RE19.1 RE27.1 RE117.1 RE141.2 RE142.2 RE267.1 RE268.1 RTCD1.1 RTCD2.1 RTCR1.1
+RTCVCC_VBAT: CE18.1 RE19.2 UE3.A2
+SD_VDD1: CR1.1 CR2.2 JCR1.4 UR1.12
+SD_VDD2: CR3.1 CR4.1 JCR1.13 UR1.13
+SIM_PWR: C144.1 C145.1 JNGFF1.36 JSIM1.1 R154.1
+TPM_LPM: C224.1 C225.1 R453.1 R454.1 U4246.8
+V_DDR_REF_CA: CD46.1 RD10.1 UCPU1.AY67
+V_DDR_REFA_R: CD67.1 RD15.1 UCPU1.AY68
+V_DDR_REFB_R: CD20.1 RD5.1 UCPU1.BA67
+VR_CAP: CE64.1 UE3.C10 UE3.J1
+VREFCA: CD22.1 CD47.1 CD69.1 CD72.1 RD10.2 RD11.1 RD12.2 UD1.H4 UD2.H4 UD3.H4 UD4.H4
+VREFDQ_A: CD21.1 CD71.1 RD15.2 RD16.1 RD18.2 UD2.J11 UD4.J11
+VREFDQ_B: CD19.1 CD70.1 RD4.1 RD5.2 RD6.2 UD1.J11 UD3.J11
AC1_DISC#: PR123.1 PR201.1 PR342.1 PT103.1(TP-1) RT20.2
AC1_OVP: PC145.1 PR117.2 PR146.1 PR269.1
AC2_DISC#: PR136.1 PR144.1 PR343.1 RT59.2
AC2_OVP: PC147.1 PR120.2 PR125.1 PR270.1
AC_DIS: PR338.1 UE3.H12
AC_DIS#: PC140.1 PQ122.3 PR174.2 PR192.2 PR200.2 PR202.1 PR230.2
AC_DISC#: PR230.1 UE3.E13
AC_DISC_OUT#: PR208.2 PR332.1
AC_IN: PC285.1 PR108.2 PR248.1 PR266.1 PU105.3
AC_PRESENT: RC91.1 UCPU1.AY15 UE3.K8
ACAV_IN: PR346.1 PR351.2 UE3.C7
ACAV_IN1: PQ308.1 PR312.1 PR319.2 PR341.1 PR345.1
ACCEL_INT1#: D107.2 RC182.1 UCPU1.AY8
ACCEL_INT1#_C: LGA1.4 RS8.2 RS10.1 RS11.1
ACCEL_INT1#_D: D107.1 RS8.1
ACCEL_INT2#: D108.2 RC183.1 UCPU1.BA8
ACCEL_INT2#_C: LGA1.9 RS6.1 RS7.1 RS9.1
ACCEL_INT2#_D: D108.1 RS7.2
AK52: R279.1 UCPU1.AK52
ALS_I2C1_ALERT#: D110.1 RS24.2 RS26.2
ALS_I2C1_ALERT#_PCH: D110.2 RC392.1 UCPU1.AP13
ALS_I2C1_SCL: RS22.2 RS25.2 UCPU1.N2
ALS_I2C1_SDA: RS23.2 RS27.2 UCPU1.N1
ALWON: RE25.2 RE26.2 UE3.A5
ALWON_PWR: PR504.1 PR505.1 PR510.1 PR515.1 RE26.1
ANA2_EN: U9.5 U12.C4
ANT_CS0: JANT1.1(TP-1) LS1.1
ANTCTRL0: JNGFF1.59 R86.2
ANTCTRL0_L: L16.2 R84.1 R86.1 R88.2
ANTCTRL1: JNGFF1.61 R87.2
ANTCTRL1_L: L17.2 R83.2 R85.1 R87.1
AR_DET#: R5771.2 R5772.1 UCPU1.P4
AUD_PWR_EN: R109.1 R110.1 R218.1 RE114.2 RE120.2 U13.3 U14.3 U14.5
AUX_EN_WOWL: D115.3 UE3.D3
AUX_EN_WOWL_R: D115.1 R139.2 U17.3
B+: C1125.1 PC315.1 PC316.1 PC317.1 PC318.1 PC319.1 PC320.1 PC321.1 PC324.1 PC325.1 PC326.1 PC329.1 PD301.2 PL500.1 PL504.1 PL601.1 PL700.1 PL720.1 PL722.1 PL800.1 PL1000.1 PL1002.1 PQ307.5 PR116.1 PR283.1 PR310.1 PR318.2 R473.1 R502.1 R5759.1 U4251.3 U4251.4
B+_USH: C1130.1 JIO1.7 JIO1.9 U4251.5 U4251.6
BASE_SMB_ALERT#: JIO2.13 RE33.1 UE3.D12
BASE_SMBCLK: C223.1 JIO2.7 RE46.1 UE3.F7
BASE_SMBDAT: C222.1 JIO2.8 RE45.1 UE3.B6
BAT1_LED#: Q354.1 UE3.D10
BAT1_LED#_USH: D113.2 JIO1.31 RE267.2
BAT2_LED#: Q354.4 UE3.D11
BAT2_LED#_USH: D114.2 JIO1.33 RE268.2
BATLOW#: RC84.2 UCPU1.AU13
BATT+: PC322.1 PC323.1 PQ304.1 PQ304.2 PQ304.3 PR310.4
BCM5882_ALERT#: JIO1.17 RE116.1 UE3.G10
BEEP: RA8.1 UE3.H11
BIA_PWM_EC: D40.2 UE3.N1
BOARD_ID: CE9.1 RE15.2 UE3.J13
BT_OFF#_R: D91.2 JNGFF3.54 R156.2 R158.1
BT_RADIO_DIS#: D91.1 RE262.1 UE3.C2
CAM_CBL_DET#: JIR1.4 RC53.1 UCPU1.AB11
CD_WAKE#: RR11.1 RR12.2 UR1.32
CFG0: JXDP1.9 RC29.2 RC144.1 UCPU1.E68
CFG1: JXDP1.11 RC37.2 UCPU1.B67
CFG2: JXDP1.15 UCPU1.D65
CFG3: JXDP1.17 RC30.2 RC141.2 RC142.2 UCPU1.D67
CFG4: JXDP1.27 RC40.2 UCPU1.E70
CFG5: JXDP1.29 UCPU1.C68
CFG6: JXDP1.33 UCPU1.D68
CFG7: JXDP1.35 UCPU1.C67
CFG8: JXDP1.10 UCPU1.F71
CFG9: JXDP1.12 UCPU1.G69
CFG10: JXDP1.16 UCPU1.F70
CFG11: JXDP1.18 UCPU1.G68
CFG12: JXDP1.28 UCPU1.H70
CFG13: JXDP1.30 UCPU1.G71
CFG14: JXDP1.34 UCPU1.H69
CFG15: JXDP1.36 UCPU1.G70
CFG16: JXDP1.6 UCPU1.E63
CFG17: JXDP1.4 UCPU1.F63
CFG18: JXDP1.24 UCPU1.E66
CFG19: JXDP1.22 UCPU1.F66
CFG_RCOMP: RC112.1 UCPU1.E60
CHG_ACIN: PC331.1 PR305.2 PR307.1 PR331.2 PU300.19
CHG_ADP: PC332.1 PR303.2 PU300.16
CHG_AMON: PR328.1 PU300.29
CHG_BGATE: PC339.1 PQ304.4 PU300.32
CHG_BST1: PR306.2 PU300.12
CHG_BST2: PC336.1 PU300.4
CHG_CLK: PR314.2 PU300.22
CHG_CMIN: PR334.2 PU300.20
CHG_COMP: PC348.1 PR327.1 PU300.28
CHG_CSIN: PC312.2 PC314.1 PR301.2 PU300.14
CHG_CSIP: PC312.1 PC313.1 PR302.2 PU300.15
CHG_CSON: PC346.2 PC347.1 PR324.2 PU300.1
CHG_CSOP: PC345.2 PC346.1 PR323.2 PU300.2
CHG_DAT: PR313.2 PU300.21
CHG_DCIN: PC333.2 PR309.2 PU300.17
CHG_LG1: PQ305.4 PU300.9
CHG_LG2: PQ306.4 PU300.7
CHG_LX1: PC330.2 PL301.1 PQ302.1 PQ302.2 PQ302.3 PQ305.5 PR316.1 PU300.10
CHG_LX2: PL301.2 PQ306.5 PQ307.1 PQ307.2 PQ307.3 PR311.1 PR317.1 PU300.6
CHG_MCP23008_SMBCLK: PR314.1 RE110.1 UE3.C12
CHG_MCP23008_SMBDAT: PR313.1 RE111.1 UE3.E10
CHG_PROCHOT#: PR209.2 PR315.2 PU300.23
CHG_PSYS: PR329.1 PU300.30
CHG_UG1: PQ302.4 PU300.11
CHG_UG2: PQ307.4 PU300.5
CHG_VBAT1: PC351.1 PR330.1 PU300.31
CHG_VDDP: PC334.1 PR308.1 PU300.8
CHG_VIN_20V: PC301.1 PL302.2 PR300.4 PR305.1 PT100.1(TP-1)
CL_CLK: JNGFF3.42 UCPU1.G3
CL_DATA: JNGFF3.40 UCPU1.G2
CL_RST#: JNGFF3.38 UCPU1.G1
CLK1_PCIE_WLAN: L24.4 UCPU1.A42
CLK1_PCIE_WLAN#: L24.1 UCPU1.B42
CLK1_PCIE_WLAN#_R: JNGFF3.49 L24.2
CLK1_PCIE_WLAN_R: JNGFF3.47 L24.3
CLK2_PCIE_WWAN: L9.4 UCPU1.C41
CLK2_PCIE_WWAN#: L9.1 UCPU1.D41
CLK2_PCIE_WWAN#_R: JNGFF1.53 L9.2
CLK2_PCIE_WWAN_R: JNGFF1.55 L9.3
CLK_ITPXDP_N: JXDP1.42 RC33.2
CLK_ITPXDP_N_R: RC33.1 UCPU1.F43
CLK_ITPXDP_P: JXDP1.40 RC32.2
CLK_ITPXDP_P_R: RC32.1 UCPU1.E43
CLK_PCIE_MMI: RR7.1 UCPU1.E38
CLK_PCIE_MMI#: RR5.1 UCPU1.E40
CLK_PCIE_MMI#_R: RR5.2 UR1.6
CLK_PCIE_MMI_R: RR7.2 UR1.5
CLK_PCIE_SSD: R60.1 UCPU1.C40
CLK_PCIE_SSD#: R59.1 UCPU1.D40
CLK_PCIE_SSD#_R: JNGFF2.53 R59.2
CLK_PCIE_SSD_R: JNGFF2.55 R60.2
CLK_SMB: JT100.8 PR152.1
CLKREQ_PCIE#1: JNGFF3.53 RC157.2 UCPU1.AT7
CLKREQ_PCIE#2: JNGFF1.52 RC153.2 UCPU1.AT8
CLKREQ_PCIE#3: JNGFF2.52 RC159.2 UCPU1.AT10
CLKREQ_PCIE#5: RC161.2 UCPU1.AU7 UR1.2
CLKRUN#: RC82.2 UCPU1.AW11
CODEC_MUTE#: Q22.3 RA21.1 RA33.2 UA1.3
CONTACTLESS_DET#: JIO1.23 RC200.1 UCPU1.W11
CORE_FB: C88.1 L22.2 R116.1 U12.H6
CORE_SW: L22.1 U12.G7
CORE_VID0: PR822.1 UCPU1.AN11
CORE_VID1: PR823.1 UCPU1.AN13
CPU_B+: PC1003.1 PC1007.1 PC1008.1 PC1009.1 PC1010.1 PC1011.1 PC1012.1 PC1013.1 PC1014.1 PC1028.1 PC1030.1 PC1103.1 PC1104.1 PC1105.1 PC1106.1 PC1107.1 PC1109.1 PC1112.1 PC1113.1 PC1115.1 PC1116.1 PC1118.1 PC1119.1 PC1121.1 PC1122.1 PC1123.1 PC1125.1 PC1424.1 PC1425.1 PC1426.1 PC1427.1 PC1428.1 PC1429.1 PC1430.1 PC1431.1 PC1432.1 PC1433.1 PC1434.1 PC1435.1 PC1436.1 PC1437.1 PL502.1 PL802.1 PL1000.2 PL1002.2 PR943.1 PR1203.1 PR1204.1 PU1005.1 PU1005.8 PU1006.1 PU1006.8 PU1107.1 PU1107.8 PU1108.1 PU1108.6
CPU_DET#: R5775.2 R5776.1 UCPU1.P1
CPU_DP1_CTRL_CLK: RC178.1 UCPU1.L13
CPU_DP1_CTRL_DATA: RC179.1 UCPU1.L12
CPU_DP1_HPD: D105.1 RC124.2 RT51.2 RV39.1 UCPU1.L9
CPU_DP2_CTRL_CLK: RC43.1 UCPU1.N7
CPU_DP2_CTRL_DATA: RC45.1 UCPU1.N8
CPU_DP2_HPD: D106.1 RC46.2 RT34.2 RV11.1 UCPU1.L7
CPU_ID: CE78.1 RE196.1 UE3.J10
CPU_POPIRCOMP: RC160.1 UCPU1.AT16
CPU_XDP_PRDY#: JXDP1.5 UCPU1.D56
CPU_XDP_PREQ#: JXDP1.3 RC151.2 UCPU1.D61
CS_CORE1: PR910.1 PU900.5 PU1005.12
CS_CORE2: PR911.1 PU900.4 PU1006.12
CS_GT: PR912.1 PU900.1 PU1107.12
CS_SA: PR913.1 PU900.48 PU1108.10
CSI2_COMP: RC114.1 UCPU1.E13
CSSUMA: PR910.2 PR911.2 PU900.18
CSSUMB: PR912.2 PU900.19
CSSUMC: PR913.2 PU900.20
DAT_SMB: JT100.7 PR154.1
DCIN1_EN: PR122.1 RE31.2 UE3.K4
DCIN2_EN: PR132.1 UE3.L12
DDI1_P2_TXN0: CV47.1 UCPU1.E55
DDI1_P2_TXN0_C: CV47.2 UV2.10
DDI1_P2_TXN1: CV50.1 UCPU1.E58
DDI1_P2_TXN1_C: CV50.2 UV2.13
DDI1_P2_TXN2: CV52.1 UCPU1.F53
DDI1_P2_TXN2_C: CV52.2 UV2.16
DDI1_P2_TXN3: CV55.1 UCPU1.F56
DDI1_P2_TXN3_C: CV55.2 UV2.19
DDI1_P2_TXP0: CV45.1 UCPU1.F55
DDI1_P2_TXP0_C: CV45.2 UV2.9
DDI1_P2_TXP1: CV49.1 UCPU1.F58
DDI1_P2_TXP1_C: CV49.2 UV2.12
DDI1_P2_TXP2: CV51.1 UCPU1.G53
DDI1_P2_TXP2_C: CV51.2 UV2.15
DDI1_P2_TXP3: CV53.1 UCPU1.G56
DDI1_P2_TXP3_C: CV53.2 UV2.18
DDI2_P1_AUXN_C: CV64.2 RV16.2 UV1.25
DDI2_P1_AUXP_C: CV63.2 RV15.2 UV1.24
DDI2_P1_TXN0_C: CV25.2 UV1.10
DDI2_P1_TXN1_C: CV28.2 UV1.13
DDI2_P1_TXN2_C: CV32.2 UV1.16
DDI2_P1_TXN3_C: CV35.2 UV1.19
DDI2_P1_TXP0_C: CV24.2 UV1.9
DDI2_P1_TXP1_C: CV26.2 UV1.12
DDI2_P1_TXP2_C: CV30.2 UV1.15
DDI2_P1_TXP3_C: CV34.2 UV1.18
DDR_A0_ZQ0: RD20.1 UD4.B3
DDR_A0_ZQ1: RD19.1 UD4.B4
DDR_A1_ZQ0: RD1.1 UD2.B3
DDR_A1_ZQ1: RD2.1 UD2.B4
DDR_A_CA1_0: RD21.1 UCPU1.BA51 UD4.R2
DDR_A_CA1_1: RD23.1 UCPU1.BB54 UD4.P2
DDR_A_CA1_2: RD25.1 UCPU1.BA52 UD4.N2
DDR_A_CA1_3: RD27.1 UCPU1.AY52 UD4.N3
DDR_A_CA1_4: RD29.1 UCPU1.AW52 UD4.M3
DDR_A_CA1_5: RD31.1 UCPU1.AY55 UD4.F3
DDR_A_CA1_6: RD33.1 UCPU1.AW54 UD4.E3
DDR_A_CA1_7: RD35.1 UCPU1.BA54 UD4.E2
DDR_A_CA1_8: RD37.1 UCPU1.BA55 UD4.D2
DDR_A_CA1_9: RD39.1 UCPU1.AY54 UD4.C2
DDR_A_CA2_0: RD41.1 UCPU1.AU46 UD2.R2
DDR_A_CA2_1: RD43.1 UCPU1.AU48 UD2.P2
DDR_A_CA2_2: RD45.1 UCPU1.AT46 UD2.N2
DDR_A_CA2_3: RD47.1 UCPU1.AU50 UD2.N3
DDR_A_CA2_4: RD49.1 UCPU1.AU52 UD2.M3
DDR_A_CA2_5: RD51.1 UCPU1.AY51 UD2.F3
DDR_A_CA2_6: RD53.1 UCPU1.AT48 UD2.E3
DDR_A_CA2_7: RD55.1 UCPU1.AT50 UD2.E2
DDR_A_CA2_8: RD57.1 UCPU1.BB50 UD2.D2
DDR_A_CA2_9: RD59.1 UCPU1.AY50 UD2.C2
DDR_A_CKE0: RD65.1 UCPU1.BA56 UD4.K3
DDR_A_CKE1: RD67.1 UCPU1.BB56 UD4.K4
DDR_A_CKE2: RD69.1 UCPU1.AW56 UD2.K3
DDR_A_CKE3: RD71.1 UCPU1.AY56 UD2.K4
DDR_A_CLK0: RD75.1 UCPU1.AT53 UD4.J3
DDR_A_CLK1: RD79.1 UCPU1.AT55 UD2.J3
DDR_A_CLK#0: RD77.1 UCPU1.AU53 UD4.J2
DDR_A_CLK#1: RD81.1 UCPU1.AU55 UD2.J2
DDR_A_CS#0: RD61.1 UCPU1.AU45 UD2.L3 UD4.L3
DDR_A_CS#1: RD63.1 UCPU1.AU43 UD2.L4 UD4.L4
DDR_A_D0: UCPU1.AL71 UD2.F9
DDR_A_D1: UCPU1.AL68 UD2.F10
DDR_A_D2: UCPU1.AN68 UD2.D9
DDR_A_D3: UCPU1.AN69 UD2.E11
DDR_A_D4: UCPU1.AL70 UD2.E9
DDR_A_D5: UCPU1.AL69 UD2.F8
DDR_A_D6: UCPU1.AN70 UD2.E10
DDR_A_D7: UCPU1.AN71 UD2.F11
DDR_A_D8: UCPU1.AR70 UD2.N9
DDR_A_D9: UCPU1.AR68 UD2.M9
