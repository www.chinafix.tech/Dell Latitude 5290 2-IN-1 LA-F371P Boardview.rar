# Allegro board Dell Latitude 5290 2-IN-1 LA-F371P Boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BAT1_LED#_USH: length 12.6
  TOP w0.112: D113.2 123.71,91.85 123.29,91.43 123.29,90.74 123.66,90.37 RE267.2 123.71,90.15 124.18,89.68 127.43,89.68 128.55,88.56 v2(129.83,88.56) 131.78,88.56 132.05,88.83 JIO1.31
BAT2_LED#: length 137.8
  TOP w0.112: v7(122.78,92.17) 122.78,93.33 123.62,94.17 124.83,94.17 125.31,93.69 Q354.4
  IN3 w0.066: v6(68.58,82.47) 68.31,82.47 68.05,82.21 66.91,82.21 65.92,83.2 48.42,83.2 46.51,85.11 45.4,85.11 42.4,88.1 40.31,88.1 39.53,88.88 v6(39.44,88.88)
  IN4 w0.066: v6(39.44,88.88) 39.44,89.02 39.16,89.3 39.16,89.57 39.3,89.71 39.3,90.31 39.94,90.95 39.94,92.87 40.03,92.97 40.03,93.6 39.94,93.7 39.94,96.19 40.11,96.36 40.11,97.71 40.11,97.72 40.11,98.46 38.07,100.5 38.07,103.06 37.56,103.57 37.56,105.09 37.28,105.37 37.28,105.37 37.13,105.52 37.13,105.52 37.12,105.53 37.12,108.42 36.34,109.2 36.34,109.42 36.34,109.42 36.34,111.9 36.34,112.18 35.1,113.42 35.1,113.93 34.56,114.47 34.56,116.37 33.79,117.14 33.79,117.48 32.18,119.09 32.18,119.63 32.03,119.77 32.03,119.81 31.53,120.31 30.65,120.31 30.03,119.69 30.03,119.14 29.57,118.68 29.43,118.68 29.16,118.4 29.16,117.87 28.91,117.62 28.37,117.62 v1(28.32,117.67) ; v7(122.78,92.17) 122.5,92.45 113.84,92.45 110.01,88.62 94.9,88.62 94.44,89.07 78.64,89.07 74.68,85.1 70.84,85.1 70.03,84.3 69.71,84.3 69.52,84.11 69.52,83.21 68.78,82.47 v6(68.58,82.47)
  BOTTOM w0.076: UE3.D11 27.93,117.2 28.32,117.59 v1(28.32,117.67)
BAT2_LED#_USH: length 9.8
  TOP w0.112: JIO1.33 131.65,89.18 v2(131.48,89.02) 131.38,88.91 128.5,88.91 127.52,89.89 124.64,89.89 124.51,90.02 RE268.2 125.03,90.37 D114.2
BATLOW#: length 11.5
  TOP w0.076: UCPU1.AU13 v8(61.53,115)
  IN1 w0.066: v8(61.53,115) 61.26,114.73 60.29,114.73 59.75,114.2 58.9,114.2 58.6,113.9 58.6,112.69 58.11,112.21 58.11,112.02 57.84,111.74 57.84,111.59 57.84,111.13 56.9,110.19 56.9,108.33 56.9,107.89 56.39,107.38 v8(56.39,107.13)
BATT+: length 1.5
  BOTTOM w0.127: v7(142.37,116.71) v2(141.58,116.71)
  BOTTOM w0.508: PC323.1 v7(142.37,116.71)
BCM5882_ALERT#: length 155.3
  TOP w0.112: JIO1.17 134.85,88.78 v7(135.2,88.43)
  IN3 w0.066: v6(37.13,105.14) 36.96,105.32 35.42,105.32 34.43,104.32 33.54,104.32 33.54,104.32 33.02,103.8 33.02,103.8 32.53,103.32 31.29,103.32 30.47,104.14 29.29,104.14 27.6,105.83 26.38,105.83 26.21,106 23.6,106 v5(22.99,106.62) ; v6(68.58,82.11) 68.51,82.04 66.84,82.04 65.85,83.03 48.35,83.03 46.44,84.94 45.25,84.94 42.26,87.93 40.05,87.93 v6(39.46,88.52)
  IN4 w0.066: v6(39.46,88.52) 39.45,88.53 39.27,88.53 39.15,88.66 39.15,89.08 38.78,89.45 38.78,90.03 39.77,91.02 39.77,92.94 39.86,93.04 39.86,93.53 39.77,93.63 39.77,96.12 39.77,96.26 39.94,96.43 39.94,97.78 39.94,97.79 39.94,98.39 37.61,100.72 37.61,102.29 37.39,102.51 37.39,103.16 37.39,104.89 v6(37.13,105.14) ; v7(135.2,88.43) 135.2,89.04 135.07,89.17 128.98,89.17 126.62,91.53 123.42,91.53 123.19,91.76 123.19,92.32 122.89,92.62 113.77,92.62 109.94,88.78 94.97,88.78 94.51,89.24 78.57,89.24 74.61,85.27 70.77,85.27 69.96,84.47 69.64,84.47 69.35,84.18 69.35,83.28 68.83,82.76 68.5,82.76 68.32,82.58 68.32,82.36 68.57,82.11 v6(68.58,82.11)
  BOTTOM w0.076: UE3.G10 25.24,115.72 25.24,115.08 25.4,114.93 25.4,114.68 25.24,114.52 25.24,113.71 24.62,113.09 24.61,113.09 24.44,112.92 24.44,111.88 24.84,111.49 24.85,111.49 25.01,111.32 25.01,111.08 24.85,110.92 24.84,110.92 24.44,110.52 24.44,109.71 23.84,109.11 23.83,109.11 23.64,108.92 23.64,108.7 23.22,108.27
  BOTTOM w0.112: 23.22,108.27 23.22,106.85 v5(22.99,106.62) ; v7(135.2,88.43) 135.2,88.29 v2(135.59,87.9)
BEEP: length 62.4
  IN3 w0.066: v6(14.02,115.61) 18.95,115.61 v6(19.91,114.64) ; v6(17.12,122.77) 17.7,122.77 18.69,123.76 19.99,123.76 v6(20.25,123.5)
  IN4 w0.066: v6(14.02,115.61) 14.03,115.62 14.03,118.23 14.81,119.01 14.81,120.84 16.48,122.52 16.87,122.52 v6(17.12,122.77) ; 22.42,116.5 22.4,116.48 21.95,116.48 21.79,116.32 21.36,116.32 20.97,115.92 20.38,115.92 19.91,115.46 v6(19.91,114.64) ; v1(28.27,154.84) 28.27,154.07 26.86,152.65 26.86,145.16 26.67,144.97 25.29,144.97 25.28,144.97 25.15,144.97 24.03,143.86 24.03,143.56 23.99,143.52 23.99,140.88 23.24,140.13 23.24,139.17 22.07,137.99 22.07,130.27 22.07,130.23 21.66,129.82 21.66,126.69 20.45,125.48 20.45,124.92 20.4,124.87 20.4,123.65 v6(20.25,123.5)
  IN4 w0.076: 22.42,116.5 23.03,117.11 24.42,117.11 v1(24.73,116.8)
  BOTTOM w0.112: RA8.1 29.21,154.37 28.74,154.84 v1(28.27,154.84)
BIA_PWM_EC: length 65.1
  IN3 w0.066: v5(69.37,92.22) 69.37,92.36 65.82,95.9 62.5,95.9 62.15,96.25 61.26,96.25 58.72,98.79 55.92,98.79 51.16,103.55 51.16,104.31 49.31,106.16 48.23,106.16 46.63,106.16 46.45,105.98 43.29,105.98 42.65,106.62 42.65,107.08 37.63,112.1 37.63,112.53 36.98,113.18 35.19,113.18 34.61,112.6 31.74,112.6 28.86,109.72 28.28,109.72 28.18,109.63 27.14,109.63 27.03,109.73 26.21,109.73 25.48,110.46 23.31,110.46 v5(22.94,110.83)
  BOTTOM w0.076: UE3.N1 21.23,109.31 21.64,109.31 21.86,109.53 21.86,109.76 22.14,110.04 22.37,110.04 22.71,110.38 22.71,110.61 v5(22.94,110.83)
  BOTTOM w0.112: v2(68.57,94.46) D40.2 69.66,93.39 69.37,93.1 v5(69.37,92.22)
BOARD_ID: length 9.4
  IN3 w0.066: v5(21.96,123.34) 22.27,123.34 22.33,123.28 22.99,123.28 v5(23.11,123.15)
  IN4 w0.066: v1(24.08,119.5) 23.97,119.38 22.63,119.38 22.28,119.74 22.28,121.85 22.89,122.46 22.89,122.47 22.93,122.51 22.93,122.97 v5(23.11,123.15)
  BOTTOM w0.112: v1(24.08,119.5) 24.03,119.45 24.03,119.29 23.93,119.19 UE3.J13 ; v5(21.96,123.34) RE15.2
BT_OFF#_R: length 45.3
  TOP w0.112: JNGFF3.54 24.72,61.39 21.72,64.39 21.44,64.39 21.15,64.09 v3(21.15,64.07)
  IN2 w0.066: v3(21.15,64.07) v4(20.76,64.07)
  IN3 w0.066: v5(20.19,64.02) 20.71,64.02 v4(20.76,64.07)
  IN4 w0.066: v1(17.32,92.76) 17.17,92.61 17.17,90.59 16.9,90.32 16.9,87.86 17.26,87.5 17.26,82.39 24.09,75.56 24.09,72.33 22.49,70.73 22.49,66.32 v5(20.19,64.02)
  BOTTOM w0.112: R158.1 v5(20.19,64.02) ; v1(17.32,92.76) 17.62,92.47 20.32,92.47 D91.2
BT_RADIO_DIS#: length 24.7
  IN4 w0.066: v1(27.39,109.3) 26.95,108.86 26.95,105.49 27.6,104.84 v1(27.86,104.84) 28.05,104.65 28.23,104.65 29.41,103.48 29.41,102.91 29.59,102.73 29.59,102.15 29.01,101.56 29.01,98.82 28.36,98.17 28.36,94.68 v1(28.16,94.47)
  BOTTOM w0.076: v1(27.39,109.3) 28.42,109.3 UE3.C2
  BOTTOM w0.112: v1(28.16,94.47) 27.04,93.36 25.68,93.36 25.06,92.74 23.28,92.74 D91.1
CAM_CBL_DET#: length 87.3
  TOP w0.112: JIR1.4 15.3,95.75 16.98,97.42 21.4,97.42 23.36,99.38 v8(23.36,103.6) 23.36,103.61 v2(23.67,103.93)
  IN1 w0.066: v8(23.36,103.6) 23.36,104.62 20.9,107.08 19.47,107.08 17.3,109.25 17.3,117.2 19.09,118.99 19.09,122.77 20.51,124.19 20.51,124.41 20.91,124.81 20.91,125.6 21.3,125.99 25.46,125.99 28.37,123.08 32.77,123.08 33.07,123.38 36.63,123.38 39.37,126.13 42.57,126.13 44.13,127.69 45.6,127.69 v8(45.92,128.02) 47.21,126.73 49.78,126.73 49.83,126.68 52.87,126.68 53.28,127.09 55.74,127.09 55.97,127.32 58.29,127.32 58.93,126.68 58.93,126.11 59.96,125.08 v8(59.96,123.64)
CD_WAKE#: length 4.9
  BOTTOM w0.112: UR1.32 67.56,29.73 RR11.1 RR12.2 65.57,30.08 64.8,30.08 v2(64.63,29.91)
CFG0: length 83.5
  TOP w0.076: RC29.2 97.28,137.5 96.72,136.95 96.72,135.45 v3(96.42,135.14) 96.19,135.14 95.38,135.96 92.32,135.96 91.87,135.51 91.87,135.19 91.76,135.09 91.76,135.05 91.76,135.04 91.76,134.69 91.8,134.59 91.8,134.45 91.79,134.36 91.76,134.28 91.76,134.22 91.76,134.11 91.76,134.1 91.76,134.06 91.81,133.91 91.86,133.72 91.9,133.46 91.98,133.2 91.98,133.09 92.19,132.87 UCPU1.E68
  IN2 w0.066: v4(113.89,132.7) 114.15,132.45 114.15,131.71 113.45,131.01 107.76,131.01 107.47,130.73 106.95,130.21 101.38,130.21 98.92,132.67 98.92,134.58 98.68,134.81 96.55,134.81 96.42,134.94 v3(96.42,135.14)
  IN3 w0.066: v4(113.89,132.7) 114.17,132.42 114.17,132.08 114.3,131.95 116.14,131.95 116.75,132.57 120.67,132.57 121.28,131.95 125.01,131.95 125.41,132.36 128.79,132.36 131.31,129.84 138.19,129.84 140.69,127.34 144.88,127.34 145.45,127.91 146.93,127.91 150.58,124.26 150.58,119.96 v5(150.32,119.7)
  BOTTOM w0.112: v5(150.32,119.7) 151.32,120.7 JXDP1.9
CFG1: length 77.3
  TOP w0.076: 95.09,135.58 93.24,135.58 92.72,135.06 92.7,135.06 92.55,134.91 92.55,134.53 UCPU1.B67
  TOP w0.112: 95.09,135.58 96.24,134.43 96.98,134.43 v3(97.05,134.51) 97.23,134.69 97.23,135.32 97.41,135.5 97.41,135.88 97.84,136.31 RC37.2
  IN2 w0.066: v3(97.05,134.51) 97.05,134.46 97.18,134.33 98.6,134.33 98.73,134.2 98.73,132.59 101.31,130.01 107.03,130.01 107.33,130.31 107.84,130.82 113.53,130.82 114.35,131.64 114.35,132.86 v4(113.94,133.26)
  IN3 w0.066: v4(113.94,133.26) 114.38,132.83 114.38,132.32 114.5,132.19 116.1,132.19 116.67,132.76 122.6,132.76 122.89,132.48 123.66,132.48 123.95,132.76 124.72,132.76 124.93,132.55 128.87,132.55 131.39,130.03 138.27,130.03 140.2,128.1 147.01,128.1 151.58,123.53 151.58,121.73 152.01,121.3 v5(153.21,121.3)
CFG2: length 72
  TOP w0.076: v3(91.31,133.29) 90.9,132.87 UCPU1.D65
  IN2 w0.066: v4(152.02,125.48) 150.25,125.48 148.79,126.94 148.33,126.94 145.91,129.35 142.52,129.35 141.73,130.14 141.2,130.14 141.06,130 140.13,130 139.62,130.51 129.1,130.51 128.59,129.99 127.8,129.99 127.49,129.69 124.27,129.69 123.74,130.22 121.06,130.22 120.9,130.38 118.66,130.38 118.34,130.38 116.07,128.11 109.02,128.11 108.19,127.28 98.85,127.28 96.02,130.11 96.02,130.88 93.93,132.97 93.77,132.97 93.77,132.97 91.63,132.97 v3(91.31,133.29)
  IN3 w0.066: v4(152.02,125.48) 152.22,125.27 152.22,123.26 152.98,122.5 v5(153.21,122.5)
CFG3: length 79.8
  TOP w0.076: RC30.2 96.95,136.82 96.95,135.27 96.9,135.22 v3(96.9,135.12) 96.85,135.07 96.85,134.84 96.72,134.71 96.29,134.71 95.23,135.77 92.35,135.77 92.02,135.45 92.02,135.09 91.93,135 91.93,134.71 91.99,134.6 91.99,134.45 91.93,134.26 91.93,134.08 92.01,133.83 92.05,133.77 92.05,133.66 92.19,133.52 UCPU1.D67
  IN2 w0.066: v4(113.79,132.15) 112.85,131.2 107.68,131.2 107.28,130.81 106.87,130.4 101.46,130.4 99.11,132.75 99.11,134.66 98.73,135.04 96.98,135.04 v3(96.9,135.12)
  IN3 w0.066: v4(113.79,132.15) 113.79,131.89 113.92,131.76 116.22,131.76 116.83,132.38 120.59,132.38 121.2,131.76 124.09,131.76 126.83,129.02 128.62,129.02 128.85,129.25 130.84,129.25 131.13,128.97 134.55,128.97 135.14,129.55 138.2,129.55 140.61,127.14 147.42,127.14 150.32,124.25 v5(150.32,122.11)
  BOTTOM w0.112: RC142.2 149.43,121.22 v5(150.32,122.11) 151.31,123.1 JXDP1.17
CFG4: length 69.8
  TOP w0.076: 95.21,133.29 94.69,132.76 94.2,132.76 UCPU1.E70
  TOP w0.112: RC40.2 97.61,133.8 v3(97.33,133.52) 97.05,133.8 95.72,133.8 95.21,133.29
  IN2 w0.066: v3(97.33,133.52) 97.26,133.45 97.26,132.23 97.71,131.79 97.71,130.46 99.73,128.44 107.66,128.44 108.49,129.27 114.96,129.27 117.46,131.78 120.06,131.78 120.28,131.56 123.71,131.56 124.31,132.15 130.6,132.15 130.87,131.88 140.1,131.88 140.67,131.31 143.49,131.31 144.47,130.33 146.03,130.33 148.58,127.78 153.37,127.78 v4(153.53,127.61)
  IN3 w0.066: v4(153.53,127.61) 153.53,126.42 v5(153.21,126.1)
CFG5: length 67.9
  TOP w0.074: v7(93.3,133.49) 92.94,133.13 UCPU1.C68
  IN2 w0.066: v4(152.08,126.19) 149.81,126.19 148.87,127.13 148.41,127.13 145.99,129.55 142.6,129.55 141.41,130.73 140.43,130.73 139.86,131.3 130.75,131.3 130.15,130.7 129.02,130.7 128.51,130.19 127.72,130.19 127.41,129.88 124.35,129.88 123.82,130.42 121.14,130.42 121.1,130.46 120.98,130.57 118.74,130.57 118.26,130.57 115.99,128.31 108.93,128.31 108.1,127.48 98.93,127.48 96.22,130.19 96.22,130.96 93.68,133.49 v7(93.3,133.49)
  IN3 w0.066: v4(152.08,126.19) 152.6,126.7 v5(153.21,126.7)
CFG6: length 68.9
  TOP w0.076: UCPU1.D68 93.93,133.04 94.25,133.37 94.76,133.37 95.25,133.86
  TOP w0.112: 95.25,133.86 95.3,133.91 v3(95.3,134.08)
  IN2 w0.066: v4(114.99,132.81) 114.99,131.36 114.06,130.43 108.01,130.43 107.18,129.61 101.16,129.61 98.34,132.43 98.34,133.27 97.79,133.82 95.55,133.82 v3(95.3,134.08)
  IN3 w0.066: v5(153.21,127.9) 153.53,128.22 153.53,128.61 153.29,128.86 152.01,128.86 151.64,128.49 140.36,128.49 138.43,130.42 132.31,130.42 131.23,131.49 130.48,131.49 129.03,132.94 125.09,132.94 124.88,133.15 123.94,133.15 123.31,133.78 116.92,133.78 115.74,132.59 115.2,132.59 v4(114.99,132.81)
CFG7: length 71.9
  TOP w0.076: 94.88,135.2 93.43,135.2 93.19,134.96 93.19,134.51 92.78,134.11 UCPU1.C67
  TOP w0.112: 94.88,135.2 95.28,134.81 v3(95.28,134.46)
  IN2 w0.066: v4(114,133.85) 114.55,133.29 114.55,131.41 113.77,130.63 107.92,130.63 107.1,129.8 101.24,129.8 98.53,132.51 98.53,133.43 97.89,134.08 95.86,134.08 95.48,134.46 v3(95.28,134.46)
  IN3 w0.066: v4(114,133.85) 114.63,133.21 114.63,132.51 114.76,132.38 115.98,132.38 116.56,132.96 122.62,132.96 122.98,133.31 123.4,133.31 123.75,132.96 124.8,132.96 125.01,132.75 128.95,132.75 130.4,131.3 131.15,131.3 132.23,130.23 138.35,130.23 140.28,128.29 151.84,128.29 152.04,128.5 153.21,128.5 v5(153.21,128.5)
CFG8: length 75.4
  TOP w0.076: 95.89,132.52 95.3,131.94 94.21,131.94 UCPU1.F71
  TOP w0.112: v3(96.9,133.29) 96.77,133.16 96.52,133.16 95.89,132.52
  IN2 w0.066: v3(96.9,133.29) 96.9,132.32 97.05,132.18 97.05,130.53 99.33,128.25 107.74,128.25 108.57,129.08 115.04,129.08 115.26,129.31 117.54,131.59 119.98,131.59 120.6,130.96 121.14,130.96 121.3,130.8 123.98,130.8 124.51,130.27 127.25,130.27 127.56,130.57 128.35,130.57 128.86,131.09 129.99,131.09 130.59,131.69 140.02,131.69 140.59,131.12 143.41,131.12 144.39,130.14 145.95,130.14 148.5,127.58 153,127.58 153.68,126.9 v4(154.23,126.9)
  IN3 w0.066: v4(154.23,126.9) 154.75,126.38 154.75,122.34 v5(156.09,121)
CFG9: length 79.2
  TOP w0.076: 95.89,131.1 94.86,131.1 94.76,131 94.5,131 94.38,131.06 94.24,131.06 94.01,130.99 93.88,130.99 93.67,131.07 93.41,131.07 UCPU1.G69
  TOP w0.112: 95.89,131.1 95.89,131.1 96.99,132.19 97.67,132.19 98.27,131.59 v3(98.4,131.59)
  IN2 w0.066: v4(115.01,133.85) 115.9,132.96 115.9,131.53 114.41,130.05 108.17,130.05 107.34,129.21 100.78,129.21 v3(98.4,131.59)
  IN3 w0.066: v5(156.09,121.6) 155.8,121.88 155.8,123.68 156.65,124.53 156.65,127.09 156.24,127.5 155.68,127.5 153.73,129.45 148.26,129.45 147.7,128.9 140.5,128.9 138.59,130.81 132.47,130.81 131.39,131.88 130.64,131.88 129.19,133.33 125.25,133.33 125.04,133.53 124.19,133.53 123.56,134.16 115.32,134.16 v4(115.01,133.85)
CFG10: length 78.5
  TOP w0.076: 95.89,132.99 95.07,132.18 94.83,132.18 94.78,132.13 94.41,132.13 94.38,132.16 93.84,132.16 UCPU1.F70
  TOP w0.112: 95.89,132.99 96.14,133.24 v3(96.14,133.29)
  IN2 w0.066: v3(96.14,133.29) 96.14,132.81 96.83,132.12 96.83,130.43 99.2,128.06 107.82,128.06 108.65,128.89 115.11,128.89 115.46,129.23 117.62,131.39 119.9,131.39 120.52,130.77 121.06,130.77 121.22,130.61 123.9,130.61 124.43,130.07 127.33,130.07 127.64,130.38 128.43,130.38 128.94,130.89 130.07,130.89 130.67,131.49 139.94,131.49 140.51,130.92 141.49,130.92 142.68,129.74 146.07,129.74 148.42,127.39 152.92,127.39 153.75,126.56 154.83,126.56 155.45,127.18 156.96,127.18 v4(157.42,127.64)
  IN3 w0.066: v5(156.09,122.8) 157.59,124.31 157.59,127.47 v4(157.42,127.64)
CFG11: length 76.4
  TOP w0.076: 95.89,132.19 95.42,131.72 94.49,131.72 94.06,131.53 93.8,131.53 93.73,131.46 92.95,131.46 UCPU1.G68
  TOP w0.112: v3(97.55,133.14) 97.55,133.05 97.41,132.91 96.61,132.91 95.89,132.19
  IN2 w0.066: v3(97.55,133.14) 97.55,132.99 97.78,132.77 97.78,132.1 97.93,131.94 97.93,130.57 99.87,128.63 107.58,128.63 108.41,129.47 114.88,129.47 117.38,131.97 120.14,131.97 120.36,131.75 123.63,131.75 124.23,132.34 130.68,132.34 130.95,132.07 140.18,132.07 140.75,131.5 145.13,131.5 148.66,127.97 153.72,127.97 154.05,127.64 v4(156.84,127.64)
  IN3 w0.066: v5(156.09,123.4) 156.09,123.69 156.84,124.45 v4(156.84,127.64)
CFG12: length 72
  TOP w0.076: v3(95.25,130.49) 95.1,130.34 94.17,130.34 94.1,130.37 93.87,130.37 93.8,130.44 UCPU1.H70
  IN2 w0.066: v4(155.8,126.14) 155.94,126 155.94,125.05 155.49,124.59 150.31,124.59 148.55,126.36 148.09,126.36 145.72,128.73 140.52,128.73 139.32,129.93 129.34,129.93 128.24,128.83 128.24,127.68 127.26,126.7 124.5,126.7 123.22,125.42 116.05,125.42 114.38,127.08 114.27,127.2 113.93,127.53 109.29,127.53 108.46,126.7 98.61,126.7 95.25,130.06 v3(95.25,130.49)
  IN3 w0.066: v4(155.8,126.14) 156.07,126.4 v5(156.09,126.4)
CFG13: length 70.3
  TOP w0.076: 95.89,131.43 95.74,131.29 94.88,131.29 94.86,131.27 UCPU1.G71
  TOP w0.112: v3(98.42,131.96) 98.42,131.99 97.98,132.43 96.89,132.43 96.27,131.81 96.26,131.81 95.89,131.43
  IN2 w0.066: v4(115.01,133.31) 115.52,132.81 115.52,131.56 114.2,130.24 108.09,130.24 107.26,129.41 101,129.41 98.45,131.96 v3(98.42,131.96)
  IN3 w0.066: v5(156.09,127) 155.8,127 153.55,129.26 148.34,129.26 147.76,128.68 140.44,128.68 138.51,130.61 132.39,130.61 131.31,131.69 130.56,131.69 129.11,133.13 125.17,133.13 124.96,133.34 124.11,133.34 123.48,133.97 115.62,133.97 115.01,133.37 v4(115.01,133.31)
CFG14: length 68.8
  TOP w0.076: UCPU1.H69 93.25,130.87 93.72,130.87 93.88,130.82 94.02,130.82 94.24,130.88 94.35,130.88 94.47,130.84 94.88,130.84 94.95,130.91 95.6,130.91 95.65,130.86 95.89,130.86
  TOP w0.112: 95.89,130.86 96.12,130.86 97.22,131.95 97.5,131.95 97.99,131.46 97.99,131.14 v3(98.24,130.9)
  IN2 w0.066: v3(98.24,130.9) 100.3,128.83 107.5,128.83 108.33,129.66 114.8,129.66 117.32,132.18 120.2,132.18 120.44,131.94 123.55,131.94 124.15,132.54 130.76,132.54 131.03,132.27 140.26,132.27 140.83,131.7 145.21,131.7 148.74,128.16 155.62,128.16 v4(155.66,128.2)
  IN3 w0.066: v5(156.09,128.2) v4(155.66,128.2)
CFG15: length 69.5
  TOP w0.076: 95.89,131.77 95.62,131.5 94.8,131.5 94.76,131.54 94.52,131.54 94.25,131.41 94.11,131.27 UCPU1.G70
  TOP w0.112: v3(97.93,133.15) 97.93,132.91 97.69,132.67 96.78,132.67 95.89,131.77
  IN2 w0.066: v3(97.93,133.15) 98.14,132.93 98.14,131.46 100.58,129.02 107.42,129.02 108.25,129.85 114.72,129.85 117.24,132.38 120.25,132.38 120.63,132.76 122.39,132.76 122.84,132.31 123.65,132.31 124.07,132.73 130.84,132.73 131.11,132.46 140.34,132.46 140.91,131.89 145.29,131.89 147.9,129.28 148.8,129.28 149.73,128.36 155.29,128.36 v4(155.66,128.73)
  IN3 w0.066: v4(155.66,128.73) 155.74,128.8 v5(156.09,128.8)
CFG16: length 78.5
  TOP w0.076: UCPU1.E63 90.23,132.78 v3(90.42,132.78)
  IN2 w0.066: v3(90.42,132.78) 93.85,132.78 95.83,130.8 95.83,130.03 98.77,127.09 108.28,127.09 109.11,127.92 116.15,127.92 118.42,130.19 120.16,130.19 121.18,129.16 127.24,129.16 127.88,129.8 128.67,129.8 129.18,130.31 139.49,130.31 140.69,129.11 145.88,129.11 148.25,126.74 148.71,126.74 150.31,125.14 153.65,125.14 v4(153.99,125.48)
  IN3 w0.066: v5(156.09,119.8) 154.56,121.33 154.56,124.91 v4(153.99,125.48)
CFG17: length 80.1
  TOP w0.074: UCPU1.F63 89.86,131.51
  TOP w0.076: v3(91.19,132.4) 91.19,132.02 91.06,131.89 90.23,131.89 89.86,131.51
  IN2 w0.066: v4(153.99,124.02) 153.8,124.21 150.15,124.21 148.39,125.97 147.93,125.97 145.56,128.34 140.36,128.34 139.85,128.85 137.58,128.85 137.47,128.97 131.72,128.97 131.35,129.33 129.29,129.33 128.71,128.75 128.71,126.63 128.39,126.32 124.66,126.32 123.38,125.03 115.89,125.03 113.77,127.15 109.45,127.15 108.62,126.32 98.45,126.32 94.63,130.14 94.63,130.3 94.63,131.06 94.18,131.5 92.08,131.5 v3(91.19,132.4)
  IN3 w0.066: v5(156.09,119.2) 153.99,121.3 v4(153.99,124.02)
CFG18: length 71.8
  TOP w0.076: UCPU1.E66 91.84,132.16 v3(92.08,132.4)
  IN2 w0.066: v4(155.6,125.2) 155.18,124.79 150.39,124.79 148.63,126.55 148.17,126.55 145.8,128.92 140.61,128.92 139.41,130.12 129.26,130.12 128.11,128.97 121.06,128.97 120.03,129.99 118.5,129.99 116.23,127.73 109.2,127.73 108.37,126.9 98.69,126.9 95.64,129.95 95.64,130.19 95.64,130.72 94.47,131.89 93.34,131.89 92.84,132.4 v3(92.08,132.4)
  IN3 w0.066: v5(156.09,125.2) v4(155.6,125.2)
CFG19: length 73.4
  TOP w0.074: UCPU1.F66 91.98,131.51
  TOP w0.076: 91.98,131.51 v3(92.34,131.88)
  IN2 w0.066: v4(155.78,124.4) 150.23,124.4 148.47,126.16 148.01,126.16 145.64,128.54 140.44,128.54 139.93,129.05 137.66,129.05 136.97,129.74 129.42,129.74 128.44,128.75 128.44,127.6 127.34,126.51 124.58,126.51 123.3,125.23 115.97,125.23 114.19,127 113.85,127.34 109.37,127.34 108.54,126.51 98.53,126.51 94.82,130.22 94.82,131.14 94.71,131.25 94.71,131.25 94.26,131.7 93.26,131.7 93.08,131.88 v3(92.34,131.88)
  IN3 w0.066: v5(156.09,124.6) 156.07,124.6 155.87,124.4 v4(155.78,124.4)
CFG_RCOMP: length 2.4
  IN2 w0.254: v3(87.73,132.1) 88.04,131.79 v4(88.06,131.79)
  IN3 w0.254: v4(88.06,131.79) 88.93,131.79 v5(89.03,131.69)
  BOTTOM w0.127: v5(89.03,131.69) 88.23,131.69 v2(88.1,131.81)
CHG_ACIN: length 5.4
  BOTTOM w0.203: PU300.19 134.78,129.57 v2(134.53,129.82) 133.81,130.54 PR331.2 PR307.1 PR305.2
  BOTTOM w0.254: PR331.2 134.66,130.86 PC331.1
CHG_ADP: length 1.7
  BOTTOM w0.127: PR303.2 v2(129.54,132.78)
CHG_AMON: length 185.7
  TOP w0.112: v7(138.56,126.3) 138.2,126.3 v2(137.97,126.53)
  IN4 w0.066: v1(31.02,123.3) 31.2,123.3 32.41,124.51 32.41,125.95 32.72,126.26 32.72,126.86 30.96,128.62 30.96,129.72 30.88,129.8 30.88,139.38 32.35,140.85 32.35,142.81 35.93,146.39 36.02,146.39 36.97,147.35 36.97,154.27 32.12,159.12 32.12,159.7 35.98,163.55 36.29,163.55 38.79,166.06 106.5,166.06 106.6,166.16 118.39,166.16 123.81,160.74 123.81,157.43 123.66,157.28 123.66,155.29 129.08,149.87 135.94,149.87 136.31,149.5 136.31,129.59 138.56,127.35 v7(138.56,126.3)
  BOTTOM w0.203: v7(138.56,126.3) 138.5,126.36 PU300.29
CHG_BGATE: length 9.5
  TOP w0.112: v7(138.18,124.4) 138.18,124.56 v2(137.83,124.91)
  IN1 w0.508: v7(138.18,124.4) 138.18,124.02 137.54,123.38 137.54,118.63 v8(138.63,117.54)
  BOTTOM w0.203: v7(138.18,124.4) 138.18,124.81 137.83,125.16 PU300.32
CHG_CLK: length 3.2
  BOTTOM w0.203: PR314.2 137.48,129.88 v2(137.46,129.87) 137.33,129.73 136.7,129.73 135.98,129.01 PU300.22
CHG_CMIN: length 2.4
  BOTTOM w0.203: PR334.2 135.18,130.43 PU300.20
CHG_COMP: length 2.8
  BOTTOM w0.203: PU300.28 138.74,126.76 138.75,126.76 PR327.1 139.24,126.77 PC348.1
CHG_CSIN: length 5.3
  TOP w0.112: v2(131.17,126.44) 131.79,127.07 v7(132.09,127.07)
  TOP w0.254: v7(132.09,127.07) 132.22,126.94 PC314.1
  BOTTOM w0.203: PU300.14 132.18,127.16 v7(132.09,127.07) 132.03,127 PC312.2 130.75,127 130.56,127.19 PR301.2
CHG_CSIP: length 5
  TOP w0.112: v7(132.09,127.76) v2(131.52,127.76)
  TOP w0.254: PC313.1 132.16,127.83 v7(132.09,127.76)
  BOTTOM w0.203: PU300.15 132.3,127.56 v7(132.09,127.76) 131.46,128.4 PC312.1 130.62,128.4 130.3,128.08 PR302.2
CHG_CSON: length 4.8
  BOTTOM w0.203: PU300.1 136.78,124.14 137.22,123.7 138.04,123.7 138.24,123.5 PC346.2 138.24,122.68 137.99,122.43 PR324.2 PC347.1
CHG_CSOP: length 6
  BOTTOM w0.112: v2(135.67,119.91) 135.67,121.27 PC345.2
  BOTTOM w0.203: PU300.2 136.38,124.1 136.84,123.64 PC346.1 136.84,122.68 137.1,122.43 PR323.2 PC345.2
CHG_DAT: length 2.6
  BOTTOM w0.203: PR313.2 136.59,130.18 v2(136.18,129.77) 135.58,129.17 PU300.21
CHG_DCIN: length 2.4
  TOP w0.762: v7(131,130.94) 131.19,131.13 PR309.2
  vias: v2(132.47,129.83)
CHG_LG1: length 27.2
  TOP w0.112: v7(132.84,124.72) v2(132.84,123.78)
  IN2 w1.016: 133.6,123.89 133.6,121.54 136.33,118.81 136.33,102.36 137.2,101.5 137.2,99.18 137.19,99.16
  vias: v7(133.41,124.72) v7(137.27,98.32) v7(137.27,97.75)
CHG_LG2: length 7.9
  TOP w0.112: v2(126.25,124.28) 126.25,124.16 v7(125.86,123.76)
  IN4 w1.016: 133.16,123.13 131.64,123.13 130.62,122.11 126.36,122.11
  vias: v1(133.92,123.57) v1(134.18,123.83) v7(125.86,123.13)
CHG_LX1: length 19.1
  IN2 w1.016: 131.95,124.27 132.33,123.89 132.33,121.23 134.18,119.39 134.18,106.81
  BOTTOM w0.112: v7(134.68,105.92) v2(134.68,106.64)
  vias: v7(131.83,125.22) v7(132.4,125.22) v7(134.11,105.92)
CHG_LX2: length 7.4
  TOP w0.112: PQ307.1 v2(131.06,122.26)
  IN4 w1.016: 130.62,118.49 130.75,118.49 134.37,122.11 134.37,122.75
  vias: v1(134.43,123.51) v1(134.68,123.76) v7(127.13,115.7) v7(127.83,115.7) v7(129.79,118.75) v7(129.79,118.18)
CHG_MCP23008_SMBCLK: length 193.3
  IN3 w0.066: v5(28.83,116.41) 28.85,116.39 28.98,116.39 29,116.37 35.28,116.37 36.3,115.36 39.07,115.36 40.46,113.96 40.46,112.93 44.77,108.62 45.91,108.62 46.45,108.08 50.95,108.08 53.63,105.4 53.81,105.4 54.25,104.97 58.36,104.97 59.1,104.22 62.27,104.22 63.67,102.83 63.67,100.22 63.68,100.21 63.68,99.75 63.68,99.74 63.68,99.65 74.13,89.2 79.59,89.2 81.08,90.69 94.05,90.69 94.71,90.41 106.99,90.41 107.68,89.73 109.05,89.73 113.41,94.09 113.41,98.33 v6(113.32,98.43)
  IN4 w0.066: v6(113.32,98.43) 113.41,98.33 113.41,98.15 113.77,97.79 114.3,97.79 115.14,96.95 129.69,96.95 130.14,96.49 146.18,96.49 149.09,99.4 149.09,111.96 146.59,114.46 146.59,126.62 146.39,126.82 146.39,129.46 144.69,131.15 140.11,131.15 139.68,131.58 138.82,131.58 138.4,131.15 137.33,131.15 137.09,131.39 137.09,131.64 137.16,131.71 v1(137.48,131.71)
  BOTTOM w0.076: 28.57,119.32 28.57,118.96 29.01,118.52 29.01,117.98 28.73,117.69 UE3.C12 28.73,117.3 28.44,117.01 28.44,116.69 28.71,116.41 v5(28.83,116.41)
  BOTTOM w0.112: v1(137.48,131.71) v2(137.48,132.72) ; 28.57,119.32 28.57,119.39 28.81,119.62 28.81,121.87 28.54,122.14 28.53,122.14 RE110.1
CHG_MCP23008_SMBDAT: length 193.2
  IN3 w0.066: v5(27.13,116) 27.4,115.73 27.41,115.72 28.85,115.72 29.33,116.2 34.97,116.2 35.99,115.18 38.86,115.18 40.23,113.81 40.23,112.92 44.72,108.43 45.78,108.43 46.3,107.91 50.88,107.91 53.56,105.23 53.75,105.23 54.18,104.8 58.29,104.8 59.03,104.06 62.2,104.06 63.5,102.76 63.5,100.04 63.51,100.03 63.51,99.68 63.51,99.67 63.51,99.58 74.09,89.01 79.64,89.01 81.12,90.5 94.01,90.5 94.67,90.22 106.91,90.22 107.6,89.54 109.13,89.54 113.6,94.01 113.6,98.33 v6(113.7,98.43)
  IN4 w0.066: v6(113.7,98.43) 113.6,98.33 113.6,98.23 113.85,97.98 114.38,97.98 115.22,97.14 129.77,97.14 130.22,96.68 146.1,96.68 148.9,99.48 148.9,111.88 146.4,114.38 146.4,126.57 146.22,126.75 146.22,129.35 144.61,130.96 140.05,130.96 139.61,131.4 138.88,131.4 138.44,130.96 137.25,130.96 136.89,131.31 136.89,131.65 136.83,131.71 v1(136.59,131.71)
  BOTTOM w0.076: 27.71,119.32 27.64,119.24 27.64,117.95 27.44,117.76 27.44,116.68 27.29,116.53 27.29,116.17 v5(27.13,116)
  BOTTOM w0.112: v1(136.59,131.71) 136.59,132.28 v2(136.16,132.72) ; 27.71,119.32 27.71,119.82 27.91,120.02 27.93,120.02 27.95,120.05 28.03,120.05 RE111.1
CHG_PROCHOT#: length 7.7
  TOP w0.112: v12(139.69,128.08) 139.26,128.08 v2(138.77,127.6)
  GND1 w0.254: v12(139.69,128.08) 139.45,128.08 v4(139.32,127.95)
  GND3 w0.254: v15(138.98,128.17) 139.19,127.95 v4(139.32,127.95)
  IN4 w0.254: v15(138.98,128.17) 138.37,128.78 v1(138.37,130.23)
  BOTTOM w0.203: PU300.23 136.38,128.98 136.68,129.27 137.41,129.27 v1(138.37,130.23) PR315.2
CHG_PSYS: length 4.2
  BOTTOM w0.112: PR329.1 141.16,124.98 v2(141.2,124.94)
  BOTTOM w0.203: PR329.1 138.28,125.96 PU300.30
CHG_UG1: length 21.2
  IN2 w1.016: 131.51,106.11 132.91,107.51 132.91,119.08 131.22,120.77 131.22,123.38 130.84,123.76 130.84,125.26
  BOTTOM w0.112: v7(131.19,105.16) v2(131.19,105.79)
  vias: v7(131.83,125.86) v7(131.76,105.16) v7(132.4,125.86)
CHG_UG2: length 8
  IN4 w1.016: 131.22,117.06 135.57,121.41 135.57,122.75
  BOTTOM w0.112: v7(130.81,116.21) v2(130.81,116.77)
  vias: v1(135.13,123.76) v1(135.13,123.45) v7(131.38,116.21)
CHG_VBAT1: length 3.7
  TOP w0.112: v2(139.31,126.37) 139.24,126.3 PC351.1
  TOP w0.254: PR330.1 PC351.1 v7(138.18,125.41)
  BOTTOM w0.203: v7(138.18,125.41) 138.04,125.56 PU300.31
CHG_VDDP: length 9.5
  TOP w0.112: v2(131.75,129.07) 132,129.33 v3(132.31,129.33)
  TOP w0.254: PC334.1 PR308.1 132.59,129.61 v3(132.31,129.33)
  IN2 w0.254: v3(132.31,129.33) 132.32,129.34 v4(132.73,129.34)
  IN3 w0.254: v6(133.15,129.34) v4(132.73,129.34)
  IN4 w0.254: v1(133.6,124.02) 133.99,124.4 133.99,125.07 133.81,125.25 133.81,128.68 v6(133.15,129.34)
  BOTTOM w0.203: v1(133.6,124.02) 133.78,124.02 133.98,124.22 PU300.8
CHG_VIN_20V: length 51.8
  TOP w0.112: v9(133.45,134.57) 132.66,134.57 132.08,133.98 v7(132.08,133.07) 132.08,132.92 v9(131.52,132.36)
  IN4 w0.508: v7(132.08,133.07) 132.08,130.96 130.67,129.55 130.67,128.18 130.16,127.67 128.14,127.67 127.18,126.71 125.09,126.71 123.16,124.78 119.32,124.78 115.75,121.21 115.75,117.34 116.29,116.79 116.29,114.17 115.75,113.63 115.75,103.6 118.5,100.84 v7(120.6,100.84)
  BOTTOM w0.508: PR305.1 132.47,133.07 v7(132.08,133.07)
CL_CLK: length 96
  TOP w0.112: JNGFF3.42 27.73,60.54 v3(27.73,63.38)
  IN1 w0.066: v7(42.03,130.4) 42.49,129.94 42.79,129.94 43.67,129.05 46.05,129.05 47.54,127.56 52.78,127.56 54.53,129.31 ; v8(55.28,131.31) 55.28,130.16 54.53,129.42
  IN1 w0.076: 54.53,129.31 54.53,129.42
  IN2 w0.066: v3(27.73,63.38) 27.72,63.39 27.72,65.4 36.78,74.46 36.78,77.5 36.22,78.06 36.22,80.28 37.41,81.47 37.41,87.95 40.03,90.57 40.03,101.57 37.96,103.64 37.96,104.41 36.52,105.85 36.52,122.39 36.69,122.56 36.69,123.5 37.6,124.42 37.6,126.16 41.84,130.4 v7(42.03,130.4)
CL_DATA: length 94.7
  TOP w0.112: v3(28.23,63.38) 28.23,60.54 JNGFF3.40
  IN1 w0.066: v7(42.61,130.4) 42.78,130.4 43.74,129.43 46.12,129.43 47.61,127.94 52.7,127.94 54.29,129.53 ; 54.29,130.18 54.63,130.52 v8(54.63,131.31)
  IN1 w0.076: 54.29,130.18 54.29,129.53
  IN2 w0.066: v7(42.61,130.4) 41.84,129.62 41.52,129.62 37.92,126.03 37.92,124.28 37.01,123.37 37.01,122.43 36.85,122.26 36.85,105.97 38.28,104.54 38.28,103.78 40.35,101.7 40.35,90.44 37.73,87.82 37.73,81.33 36.54,80.14 36.54,78.2 37.1,77.63 37.1,74.33 28.22,65.45 28.22,63.39 v3(28.23,63.38)
CL_RST#: length 95.4
  TOP w0.112: v3(28.73,63.38) 28.73,60.54 JNGFF3.38
  IN1 w0.066: v7(42.33,130.88) 43.05,130.88 44.17,129.76 46.47,129.76 47.97,128.26 52.23,128.26 52.65,128.68 52.65,129.24 53.18,129.76 53.53,129.76 53.98,130.21 v8(53.98,131.31)
  IN2 w0.066: v3(28.73,63.38) 28.72,63.39 28.72,65.49 37.42,74.2 37.42,77.76 36.86,78.33 36.86,80.01 38.05,81.2 38.05,87.68 40.67,90.31 40.67,102.6 37.21,106.07 37.21,106.32 37.2,106.32 37.2,122.17 37.33,122.3 37.33,123.24 38.24,124.15 38.24,125.9 41.52,129.18 41.99,129.18 42.99,130.18 42.99,130.7 42.81,130.88 v7(42.33,130.88)
CLK1_PCIE_WLAN: length 136.3
  IN2 w0.081: v7(26.37,55.5) 26.16,55.7 26.16,55.95 24,58.11 24,60.54 26.44,62.98 26.44,65.85 34.67,74.08 34.67,76.83 34.11,77.39 34.11,82.95 34.53,83.37 34.53,89.97 37,92.44 37,98.07 33.43,101.64 33.43,106.85 31.92,108.35 31.92,115.58 31.81,115.69 31.81,121.01 34.43,123.63 34.43,125.88 41.51,132.96 41.51,134.11 44.32,136.92 47.29,136.92 47.8,136.42 49.34,136.42 49.83,136.9 51.65,136.9 v4(51.92,136.64) ; v4(78.11,134.49) 78.13,134.49 v3(78.45,134.82)
  IN3 w0.081: v6(78.4,134.1) 78.4,134.2 v4(78.11,134.49) ; v6(52.31,136.64) v4(51.92,136.64)
  IN4 w0.066: v6(52.31,136.64) 52.62,136.95 53.08,136.95 54.96,135.07 56.4,135.07 57.16,135.84 62.09,135.84 63.48,134.44 66.05,134.44 66.36,134.75 67.16,134.75 69.24,132.67 72.99,132.67 73.48,133.16 77,133.16 78.26,134.42 78.36,134.42 78.42,134.36 78.42,134.11 v6(78.4,134.1)
  BOTTOM w0.112: v7(26.37,55.5) 26.16,55.29 26.16,55.19 26.29,55.07 L24.4
CLK1_PCIE_WLAN#: length 136.2
  IN2 w0.081: v4(51.92,137.22) 51.83,137.14 49.77,137.14 49.26,136.62 47.88,136.62 47.38,137.13 44.24,137.13 41.31,134.2 41.31,133.04 34.23,125.96 34.23,123.72 31.61,121.1 31.61,115.61 31.72,115.5 31.72,108.27 33.22,106.76 33.22,101.56 36.8,97.98 36.8,92.52 34.33,90.06 34.33,83.45 33.91,83.03 33.91,77.3 34.47,76.75 34.47,74.17 26.24,65.94 26.24,63.07 23.79,60.62 23.79,58.02 25.96,55.86 25.96,55.67 v7(25.78,55.5) ; v3(78.45,134.17) 78.45,134.21 v4(78.74,134.49)
  IN3 w0.081: v6(52.31,137.22) v4(51.92,137.22) ; v4(78.74,134.49) 78.47,134.76 v6(78.45,134.76)
  IN4 w0.066: v6(78.45,134.76) 78.45,134.67 78.35,134.57 78.2,134.57 76.94,133.31 73.42,133.31 72.93,132.82 69.3,132.82 67.22,134.9 66.3,134.9 65.99,134.59 63.55,134.59 62.15,135.99 57.1,135.99 56.33,135.22 55.02,135.22 53.15,137.1 52.43,137.1 v6(52.31,137.22)
  BOTTOM w0.112: v7(25.78,55.5) 25.95,55.33 25.95,55.17 25.79,55.01 L24.1
CLK1_PCIE_WLAN#_R: length 2.8
  TOP w0.112: JNGFF3.49 25.97,52.26 26.1,52.14 26.1,52.03 v7(25.88,51.82)
  BOTTOM w0.112: L24.2 25.79,52.74 26.07,52.45 26.07,52.01 v7(25.88,51.82)
CLK1_PCIE_WLAN_R: length 2.6
  TOP w0.112: v7(26.47,51.82) 26.31,51.97 26.31,52.1 26.47,52.25 JNGFF3.47
  BOTTOM w0.112: v7(26.47,51.82) 26.29,51.99 26.29,53.09 L24.3
CLK2_PCIE_WWAN: length 93.1
  TOP w0.076: v3(77.72,132.65) 77.72,132.99 77.6,133.11 77.6,133.44 77.89,133.73 UCPU1.C41
  TOP w0.112: L9.4 19.45,110.28 19.69,110.04 19.69,109.68 19.96,109.41 v11(20.23,109.41) 20.51,109.41 21.02,109.92 21.09,109.92 21.3,109.72 21.3,109.4 v3(21.24,109.34)
  IN2 w0.081: v3(21.24,109.34) 21.24,109.71 20.86,110.09 20.86,114.67 20.5,115.03 20.5,117.22 20.22,117.5 20.22,119.29 19.26,120.25 19.26,122.22 20.13,123.08 21.03,123.08 23.88,125.93 24.19,125.93 33.63,135.37 35.19,135.37 41.37,141.55 47.18,141.55 47.45,141.82 51.43,141.82 51.98,142.37 63.49,142.37 70.1,135.76 70.1,133.56 72.33,131.34 73.69,131.34 74.21,130.82 77.51,130.82 77.59,130.91 77.59,131.37 77.79,131.56 77.79,132.59 v3(77.72,132.65)
CLK2_PCIE_WWAN#: length 93.2
  TOP w0.076: UCPU1.D41 77.89,133.33 77.97,133.41 78.11,133.41 78.19,133.33 78.19,133.02 78.11,132.93 v3(78.11,132.65)
  TOP w0.112: L9.1 20.3,110.34 19.91,109.95 19.91,109.77 20.03,109.65 20.44,109.65 20.93,110.14 21.18,110.14 21.51,109.81 21.51,109.46 21.64,109.34 v3(21.65,109.34)
  IN2 w0.081: v3(78.11,132.65) 77.99,132.54 77.99,131.48 77.8,131.28 77.8,130.82 77.6,130.62 74.12,130.62 73.61,131.14 72.24,131.14 69.9,133.48 69.9,135.67 63.41,142.17 52.07,142.17 51.51,141.62 47.53,141.62 47.26,141.34 41.45,141.34 35.28,135.17 33.71,135.17 24.27,125.72 23.97,125.72 21.12,122.88 20.21,122.88 19.47,122.13 19.47,120.33 20.42,119.38 20.42,117.58 20.7,117.3 20.7,115.11 21.06,114.75 21.06,110.17 21.44,109.79 21.44,109.55 v3(21.65,109.34)
CLK2_PCIE_WWAN#_R: length 2.6
  TOP w0.112: JNGFF1.53 19.88,113.79 19.77,113.67 19.77,113.46 19.94,113.29 19.94,112.88 20.3,112.52 L9.2
CLK2_PCIE_WWAN_R: length 2.6
  TOP w0.112: JNGFF1.55 19.38,113.86 19.55,113.68 19.55,113.37 19.71,113.21 19.71,112.85 19.45,112.59 L9.3
CLK_ITPXDP_N: length 96.2
  IN2 w0.081: v4(155.83,135.81) 155.66,135.65 142.87,135.65 140.29,138.23 130.3,138.23 129.35,137.28 124.82,137.28 123.94,138.16 123.94,144.21 121.71,146.45 118,146.45 117.62,146.83 116.35,146.83 115.81,146.29 115.81,145.65 114,143.84 114,142.27 110.44,138.72 97.66,138.72 96.43,137.49 82,137.49 81.76,137.72 81.76,137.96 81.86,138.06 v3(82.3,138.06)
  IN3 w0.081: v4(155.83,135.81) 155.67,135.66 155.46,135.66 155.26,135.46 155.26,134.51 156.67,133.1 156.67,130.46 156.6,130.39 156.3,130.39 v5(156.09,130.6)
CLK_ITPXDP_N_R: length 9.4
  IN1 w0.066: v8(78.59,131.45) 78.59,131.63 78.65,131.7 78.71,131.7 79.28,131.13 79.82,131.13 80.04,131.35 80.04,132.16 80.35,132.46 81.1,132.46 81.34,132.7 81.34,134.39 81.11,134.63 81.11,135.44 82.04,136.38 82.04,136.89 82.3,137.15 v8(82.3,137.15)
CLK_ITPXDP_P: length 96.1
  IN2 w0.081: v4(155.83,135.28) 155.66,135.45 142.78,135.45 140.2,138.03 130.39,138.03 129.44,137.08 124.74,137.08 123.74,138.08 123.74,144.12 121.62,146.24 117.92,146.24 117.54,146.62 116.43,146.62 116.01,146.2 116.01,145.57 114.2,143.75 114.2,142.18 110.53,138.51 97.74,138.51 96.51,137.28 81.91,137.28 81.56,137.64 81.56,137.91 v3(81.41,138.06)
  IN3 w0.081: v5(156.09,130) 156.27,130.19 156.69,130.19 156.87,130.37 156.87,133.18 155.46,134.59 155.46,135.37 155.54,135.45 155.66,135.45 v4(155.83,135.28)
CLK_ITPXDP_P_R: length 9.3
  IN1 w0.066: v8(78.59,132.1) 78.59,131.92 78.65,131.85 78.77,131.85 79.34,131.28 79.76,131.28 79.89,131.42 79.89,132.22 80.29,132.61 81.04,132.61 81.19,132.76 81.19,134.33 80.96,134.56 80.96,135.5 81.89,136.44 81.89,136.87 81.61,137.15 v8(81.41,137.15)
CLK_PCIE_MMI: length 206
  IN2 w0.081: v4(30.9,37.57) 30.78,37.69 30.78,38.01 30.92,38.15 30.92,46.23 29.46,47.69 29.46,52.11 27.58,53.99 25.57,53.99 24.46,55.1 24.46,56.29 23.15,57.6 23.15,61.15 25.6,63.59 25.6,77.96 22.61,80.95 22.61,91.87 24.7,93.96 24.7,94.64 22.68,96.66 22.68,101.79 23.34,102.45 23.34,105.92 19.88,109.38 19.88,112.76 19.52,113.12 19.52,116.81 19.2,117.13 19.2,118.82 18.29,119.73 18.29,122.62 18.86,123.19 19.72,124.06 20.63,124.06 23.48,126.9 23.78,126.9 33.25,136.37 34.81,136.37 40.96,142.52 46.77,142.52 47.6,143.35 63.9,143.35 70.89,136.36 70.89,133.67 72.13,132.43 76.12,132.43 76.2,132.34 76.2,132.18 76.12,132.1 v3(75.84,132.1)
  IN3 w0.081: v5(62.89,33.24) 62.56,33.57 62.03,33.57 61.92,33.68 41.44,33.68 40.84,33.09 38.86,33.09 37.85,34.1 36.69,34.1 35.92,34.88 35.92,36.28 33.47,38.72 31.55,38.72 30.75,37.91 30.75,37.72 v4(30.9,37.57)
  BOTTOM w0.112: v5(62.89,33.24) 62.9,33.23 63.28,33.23 RR7.1
CLK_PCIE_MMI#: length 207.1
  IN2 w0.081: v4(30.37,37.57) 30.57,37.78 30.57,38.09 30.72,38.23 30.72,46.15 29.26,47.61 29.26,52.03 27.5,53.79 25.49,53.79 24.26,55.02 24.26,56.2 22.95,57.51 22.95,61.23 25.4,63.68 25.4,77.88 22.41,80.86 22.41,91.95 24.5,94.04 24.5,94.56 22.48,96.57 22.48,101.88 23.14,102.54 23.14,105.84 19.68,109.3 19.68,112.68 19.32,113.03 19.32,116.73 19,117.05 19,118.73 18.08,119.65 18.08,122.7 18.77,123.39 19.64,124.26 19.81,124.26 20.55,124.26 23.39,127.11 23.7,127.11 33.17,136.58 34.73,136.58 40.88,142.73 46.69,142.73 47.51,143.55 63.98,143.55 71.09,136.44 71.09,133.75 72.22,132.63 76.2,132.63 76.4,132.43 76.4,132.18 76.48,132.1 v3(76.76,132.1)
  IN3 w0.081: v4(30.37,37.57) 30.54,37.74 30.54,38 31.47,38.93 33.55,38.93 36.12,36.36 36.12,34.96 36.78,34.3 37.93,34.3 38.95,33.29 40.76,33.29 41.35,33.88 62.01,33.88 62.12,33.77 62.57,33.77 v5(62.88,34.08)
  BOTTOM w0.112: RR5.1 63.28,34.08 62.88,34.08 v5(62.88,34.08)
CLK_PCIE_MMI#_R: length 2.8
  BOTTOM w0.112: UR1.6 66.42,33.81 66.35,33.74 65.58,33.74 65.24,34.08 64.36,34.08 RR5.2
CLK_PCIE_MMI_R: length 2.8
  BOTTOM w0.112: RR7.2 64.36,33.23 65.24,33.23 65.51,33.5 v11(65.79,33.5) 66.34,33.5 66.44,33.41 UR1.5
CLK_PCIE_SSD: length 171.7
  TOP w0.112: v8(60.14,86.89) 60.14,86.46 R60.1
  IN1 w0.066: v8(60.14,86.89) 59.88,86.89 59.82,86.96 59.82,87.39 59.21,88 54.38,88 53.92,87.53 52.86,87.53 50.88,85.55 50.88,84.91 50.31,84.34 50.31,79.81 44.61,74.1 30.46,74.1 30.14,73.78 30.14,73.59 v10(30.01,73.46)
  IN2 w0.081: v3(77.33,133.52) 77.1,133.3 76.91,133.3 76.63,133.03 76.63,132.7 77.01,132.31 77.01,131.94 76.89,131.82 72.43,131.82 70.61,133.64 70.61,136.08 63.74,142.96 51.74,142.96 51.42,142.65 47.44,142.65 46.93,142.14 41.12,142.14 34.97,135.98 33.41,135.98 23.94,126.52 23.64,126.52 20.79,123.67 19.88,123.67 19.02,122.8 19.02,122.8 18.67,122.46 18.67,119.94 19.61,119.01 19.61,117.27 19.91,116.97 19.91,113.42 20.27,113.06 20.27,109.54 23.74,106.07 23.74,102.25 23.09,101.6 23.09,96.8 25.09,94.8 25.09,93.8 23,91.71 23,81.11 30.12,73.98 30.12,73.58 v10(30.01,73.46)
CLK_PCIE_SSD#: length 170.9
  TOP w0.112: v8(59.29,86.89) 59.29,86.46 R59.1
  IN1 w0.066: v8(59.29,86.89) 59.6,86.89 59.67,86.96 59.67,87.32 59.14,87.85 54.44,87.85 53.98,87.38 52.92,87.38 51.03,85.49 51.03,84.85 50.46,84.28 50.46,79.74 44.67,73.95 30.52,73.95 30.29,73.72 30.29,73.57 v10(30.39,73.46)
  IN2 w0.081: v3(77.33,132.87) 77.1,133.1 76.99,133.1 76.83,132.94 76.83,132.78 77.22,132.4 77.22,131.86 76.98,131.62 72.34,131.62 70.41,133.55 70.41,136 63.65,142.76 51.82,142.76 51.51,142.44 47.53,142.44 47.02,141.93 41.21,141.93 35.05,135.78 33.49,135.78 24.03,126.31 23.72,126.31 20.87,123.47 19.97,123.47 19.1,122.6 18.88,122.38 18.88,120.02 19.81,119.09 19.81,117.36 20.11,117.06 20.11,113.5 20.47,113.14 20.47,109.63 23.95,106.15 23.95,102.17 23.29,101.51 23.29,96.88 25.29,94.88 25.29,93.71 23.2,91.62 23.2,81.19 30.33,74.07 30.33,73.53 v10(30.39,73.46)
CLK_PCIE_SSD#_R: length 3.1
  TOP w0.112: JNGFF2.53 59,83.47 59.14,83.62 59.14,83.87 59.58,84.3 59.58,84.53 59.29,84.82 59.29,85.38 R59.2
CLK_PCIE_SSD_R: length 3.1
  TOP w0.112: R60.2 60.14,85.38 60.14,84.82 59.79,84.47 59.79,84.22 59.36,83.78 59.36,83.62 59.5,83.48 JNGFF2.55
CLK_SMB: length 8.1
  IN2 w0.066: v3(140.84,101.36) 140.43,101.36 140.37,101.29 140.37,101.16 140.44,101.09 141.3,101.09 143.83,98.56 143.83,97.73 144,97.56 145.26,97.56 145.33,97.63 v3(145.33,98.09)
CLKREQ_PCIE#1: length 109.8
  TOP w0.076: UCPU1.AT7 57.45,115.96 57.11,116.3 v7(57.11,116.79)
  TOP w0.112: JNGFF3.53 24.97,52.16 24.64,51.83 v3(24.64,51.6)
  IN2 w0.066: v4(24.95,51.25) 24.64,51.56 v3(24.64,51.6)
  IN3 w0.066: v4(24.95,51.25) 26.31,51.25 27.05,50.51 28.6,50.51 29.28,51.19 59.96,51.19 v6(60.06,51.28)
  IN4 w0.066: v7(57.11,116.79) 57.27,116.79 58.38,115.67 58.38,115.25 58.59,115.04 58.59,109.32 58.53,109.25 58.53,106.29 57.13,104.88 57.13,103.8 57.13,101.29 57.05,101.21 57.05,99.57 58.96,97.66 58.96,92.52 59.92,91.56 59.92,91.23 59.92,91.23 59.92,90.31 59.61,90 59.61,88.52 60.56,87.57 60.56,79.68 60.77,79.48 60.77,78.9 60.6,78.73 60.6,74.73 60.2,74.32 60.2,51.42 v6(60.06,51.28)
  BOTTOM w0.112: v7(57.11,116.79) v2(56.24,116.79) 55.28,116.79 RC157.2
CLKREQ_PCIE#2: length 63.1
  TOP w0.076: v7(58.93,116.27) 58.62,115.96 UCPU1.AT8
  TOP w0.112: v8(19.68,123.82) 20.13,123.38 JNGFF1.52
  IN1 w0.066: v10(20.7,127.5) 20.7,124.84 v8(19.68,123.82)
  IN2 w0.066: v4(20.32,127.5) v10(20.7,127.5)
  IN3 w0.066: v4(20.32,127.5) 19.94,127.88 19.94,128.15 19.23,128.86 19.23,129.57 19.62,129.95 19.79,129.95 20.13,129.95 20.67,130.49 29.07,130.49 30.12,129.44 35.94,129.44 36.49,128.89 42.44,128.89 44.06,127.27 44.06,122.44 45.75,120.75 47.04,120.75 47.18,120.89 49.22,120.89 50.43,119.67 55.35,119.67 55.46,119.56 56.07,119.56 57.32,118.32 57.32,117.66 58.22,116.76 58.44,116.76 v7(58.93,116.27)
  BOTTOM w0.112: RC153.2 55.75,117.54 56.12,117.18 57.39,117.18 57.49,117.08 v2(58.3,117.08) 58.93,116.45 v7(58.93,116.27)
CLKREQ_PCIE#3: length 52.4
  TOP w0.076: v7(58.93,115.64) 59.25,115.96 UCPU1.AT10
  TOP w0.112: v7(60.96,73.98) 59.31,73.98 58.75,74.54 JNGFF2.52
  IN4 w0.066: v7(60.96,73.98) 61.01,74.03 61.01,78.37 61.27,78.64 61.27,82.61 60.9,82.99 60.9,87.76 60.38,88.27 60.38,91.61 59.29,92.7 59.29,97.79 57.38,99.71 57.38,101.07 57.46,101.15 57.46,104.08 58.87,105.48 58.87,109.11 58.93,109.18 58.93,109.32 58.93,109.45 58.93,115.64 v7(58.93,115.64)
  BOTTOM w0.112: v7(58.93,115.64) 58.15,116.42 57.24,116.42 v2(56.26,115.44) 56.2,115.38 RC159.2
CLKREQ_PCIE#5: length 97.7
  TOP w0.076: v7(57.09,115.03) 57.38,115.31 UCPU1.AU7
  IN4 w0.066: v7(57.09,115.03) 57.22,115.03 57.7,114.56 58.07,114.56 58.43,114.2 58.43,109.39 58.35,109.31 58.35,106.35 56.96,104.96 56.96,103.73 56.96,103.73 56.96,101.36 56.88,101.28 56.88,99.47 58.79,97.55 58.79,92.44 59.75,91.48 59.75,90.38 59.44,90.07 59.44,88.45 60.39,87.5 60.39,79.61 60.6,79.41 60.6,78.97 60.43,78.8 60.43,74.8 60.02,74.38 60.02,52.41 59.77,52.16 59.77,45.35 60.6,44.52 60.6,38.53 59.74,37.66 59.74,34.36 63.06,31.04 65.52,31.04 v1(65.85,31.37)
  BOTTOM w0.112: UR1.2 66.36,32.21 65.85,31.7 v1(65.85,31.37) 65.85,31.22 v2(65.51,30.88) ; v7(57.09,115.03) 56.04,115.03 55.5,114.49 RC161.2
CLKRUN#: length 9.3
  TOP w0.076: UCPU1.AW11 60.15,113.89 59.86,113.6 59.86,110.6
  TOP w0.112: 59.86,110.6 59.86,109.59 60.2,109.26 60.2,107.24 59.88,106.92 59.88,106.17 60.15,105.91 RC82.2
CODEC_MUTE#: length 20.6
  IN3 w0.066: v5(33.96,144.06) 33.81,144.21 28.79,144.21 28.46,143.88 28.46,143.02 27.92,142.47 26.82,142.47 26.43,142.87 v5(26.43,143.08)
  IN4 w0.066: v1(25.13,136.25) 25.13,136.79 25.27,136.93 25.27,138.01 26.43,139.17 v5(26.43,143.08)
  BOTTOM w0.112: v1(25.13,136.25) 24.91,136.03 Q22.3 ; RA33.2 33.01,143.55 RA21.1 33.59,143.69 v5(33.96,144.06) 33.96,144.15 v2(34.21,144.4) ; v5(26.43,143.08) 25.91,143.6 UA1.3
CONTACTLESS_DET#: length 177.7
  TOP w0.066: v3(54.61,125.6) 54.67,125.67 55.79,125.67 56.12,125.34 57.35,125.34 57.66,125.03 57.66,124.59 57.85,124.4 59.65,124.4 UCPU1.W11
  TOP w0.112: v7(133.42,88.43) 133.65,88.66 JIO1.23
  IN2 w0.066: v3(54.61,125.6) 54.29,125.29 v4(54.29,125.16)
  IN3 w0.066: v6(70.13,83.7) 54.78,83.7 53.23,85.25 51.45,85.25 50.87,85.83 45.86,85.83 v6(42.73,88.97) ; v4(54.29,125.16) 54.29,123.88 53.85,123.43 51.2,123.43 51,123.63 49.62,123.63 49.39,123.86 47.81,123.86 46.89,124.78 46.89,127.44 v5(43.97,130.37) 42.76,131.57 41.69,131.57 41.13,131.02 37.4,131.02 37.36,131.05 36.86,131.05 v6(36.8,131.1)
  IN4 w0.066: v6(70.13,83.7) 70.15,83.7 71.03,84.58 74.87,84.58 78.85,88.57 94.23,88.57 94.69,88.11 110.22,88.11 114.05,91.94 121.91,91.94 123.29,90.57 126.77,90.57 127.66,89.68 127.66,89.47 128.31,88.81 133.3,88.81 133.42,88.69 v7(133.42,88.43) ; v6(42.73,88.97) 42.73,90.05 42.5,90.27 42.5,94.13 42.58,94.21 42.58,100.45 42.38,100.64 42.38,101.09 41.15,102.33 41.15,103.65 40.85,103.95 40.85,107.17 40.24,107.78 40.24,115.87 39.67,116.45 39.67,120.8 39.59,120.87 39.59,122.93 38.13,124.4 38.13,124.59 36.86,125.87 36.86,129.5 36.75,129.61 36.75,131.05 v6(36.8,131.1)
  BOTTOM w0.112: v2(45.33,130.24) 44.09,130.24 v5(43.97,130.37) 43.89,130.44 RC200.1
CORE_FB: length 6.2
  BOTTOM w0.127: U12.H6 149.95,140.67 v2(149.1,139.82) C88.1 147.25,138.83 L22.2 147.19,138.43 147.89,137.73 R116.1
CORE_VID0: length 52.9
  TOP w0.076: v7(60.73,117.48) 60.3,117.91 UCPU1.AN11
  TOP w0.112: PR822.1 53.54,143.65 54.1,144.21 v3(54.1,144.46)
  IN2 w0.066: v4(54.23,144.85) 54.1,144.72 v3(54.1,144.46)
  IN3 w0.066: v4(54.23,144.85) 54.18,144.79 v6(54.18,144.34) ; v6(42.88,129.18) 44.49,127.57 44.49,124.39 46.4,122.48 46.4,122.35 47.1,121.65 47.63,121.65 49.71,121.65 50.85,120.51 51.13,120.51 55.7,120.51 55.81,120.4 56.5,120.4 56.8,120.4 58.35,118.85 59.22,118.85 59.63,118.44 59.63,118.42 59.97,118.07 60.07,118.07 60.38,117.76 60.38,117.66 60.57,117.48 v7(60.73,117.48)
  IN4 w0.066: v6(54.18,144.34) 53.34,144.34 51.59,142.58 46.12,142.58 42.46,138.92 41.68,138.92 41.27,138.51 41.27,137.7 41.84,137.14 41.84,136.79 41.84,136.79 41.84,136.47 41.84,136.47 41.84,131.89 42.98,130.75 42.98,130.15 42.85,130.03 42.85,129.25 42.91,129.19 42.91,129.18 v6(42.88,129.18)
CORE_VID1: length 52.7
  TOP w0.074: UCPU1.AN13 61.36,117.91 v7(61.71,117.57)
  TOP w0.112: v3(53.34,140.65) 53.34,140.13 v2(53.12,139.92) 52.55,139.92 51.94,140.53 PR823.1
  IN2 w0.066: v3(53.34,140.65) 53.34,140.7 v4(53.11,140.93)
  IN3 w0.066: v6(51.56,142.1) 51.94,142.1 v4(53.11,140.93) ; v6(43.23,129.22) 43.23,129.17 45.79,126.62 45.79,124.46 46.59,123.66 46.59,123.17 47.77,121.99 48.19,121.99 48.19,121.99 49.85,121.99 50.99,120.85 55.84,120.85 55.95,120.74 56.36,120.74 56.94,120.74 58.47,119.21 60.6,119.21 60.63,119.17 60.86,119.17 61.28,118.76 61.28,118 v7(61.71,117.57)
  IN4 w0.066: v6(51.56,142.1) 51.31,142.36 46.13,142.36 42.53,138.75 41.75,138.75 41.44,138.45 41.44,137.78 42,137.22 42,136.86 42,131.96 43.15,130.82 43.15,129.31 v6(43.23,129.22)
CPU_B+:
  vias: v2(61.75,159.7) v3(56.1,157.95) v3(56.09,157.28) v3(56.11,156.73) v3(56.46,157.62) v3(56.46,156.74) v3(65.02,156.68) v3(65.71,156.68) v4(55.74,158.08) v4(55.74,157.1) v4(56.3,158.74) v4(56.55,158.1) v4(56.55,157.19) v4(65.38,156.81) v5(56.83,158.47) v5(83.13,162.4) v5(83.13,161.69) v5(83.46,162.4) v5(83.46,161.69) v7(48.13,150.43) v7(48.13,149.86) v7(48.13,149.29) v7(48.7,150.43) v7(48.7,149.86) v7(48.7,149.29) v7(49.28,150.43) v7(49.28,149.86) v7(49.28,149.29) v7(49.85,150.43) v7(51.69,159.22) v7(51.88,150.94) v7(51.88,150.37) v7(52.25,159.22) v7(52.44,150.94) v7(52.44,150.37) v7(52.81,159.22) v7(55.99,162.76) v7(55.99,162.19) v7(55.99,161.62) v7(55.99,161.05) v7(56.57,162.76) v7(56.57,162.19) v7(56.57,161.62) v7(56.57,161.05) v7(59.44,162.31) v7(59.42,161.71) v7(59.41,161.13) v7(60.01,162.31) v7(59.99,161.71) v7(59.98,161.13) v7(60.57,161.71) v7(60.63,161.13) v7(60.66,162.31) v7(61.14,161.71) v7(61.23,162.31) v7(61.2,161.13) v7(62.94,162.52) v7(62.94,161.93) v7(63.63,162.55) v7(63.63,161.95) v7(65.86,163.23) v7(74.93,162.49) v7(74.87,161.84) v7(75.54,159.32) v7(75.54,158.75) v7(75.56,162.5) v7(76.14,162.5) v7(76.11,159.32) v7(76.11,158.75) v7(76.71,162.5) v7(76.68,159.32) v7(76.68,158.75) v7(77.28,162.5) v7(77.25,159.32) v7(77.25,158.75) v7(77.83,159.32) v7(77.83,158.75) v7(77.85,162.5) v7(78.45,162.46) v7(78.54,161.69) v7(79.04,162.45) v7(79.22,161.69) v7(79.64,162.43) v7(79.91,161.71) v7(80.26,162.42) v7(82.07,157.62) v7(82.63,163.26) v7(82.65,157.62) v7(92.13,161.28) v7(92.15,161.85) v7(92.71,162.43) v7(92.71,161.86) v7(92.71,161.29) v7(92.71,160.72) v7(93.28,162.43) v7(93.28,161.86) v7(93.28,161.29) v7(93.28,160.72) v7(94.69,154.88) v7(95.3,159.65) v7(95.28,154.88) v7(95.91,159.65) v7(95.94,158.87) v7(96.01,162.43) v7(96.01,161.86) v7(96.01,161.29) v7(96.01,160.72) v7(96.58,162.43) v7(96.58,161.86) v7(96.58,161.29) v7(96.58,160.72) v7(96.6,159.78) v7(97.24,160.66) v7(97.31,162.43) v7(97.31,161.84) v7(97.28,161.27)
CPU_DET#: length 14.9
  TOP w0.112: R5776.1 v8(43.01,128.54)
  IN1 w0.066: v8(53.98,127.33) 53.96,127.31 53.22,127.31 52.81,126.9 47.51,126.9 46.13,128.28 44.48,128.28 43.12,126.92 42.85,126.92 42.63,127.14 42.63,127.7 43.01,128.08 v8(43.01,128.54)
CPU_DP1_CTRL_CLK: length 15.4
  TOP w0.076: 53.34,127.57 53.34,127.58 55.8,127.58 55.82,127.6 56.04,127.6 56.32,127.32 60.4,127.32 60.88,127.8 60.88,128.47 UCPU1.L13
  TOP w0.112: 53.34,127.57 53.09,127.57 52.53,127.02 48.33,127.02 48.02,126.7 47.92,126.7 47.7,126.48 RC178.1
CPU_DP1_CTRL_DATA: length 14.5
  TOP w0.076: UCPU1.L12 60.27,128.51 60.27,127.85 59.9,127.47 56.39,127.47 56.11,127.75 55.76,127.75 55.73,127.73 53.62,127.73 53.34,128.01
  TOP w0.112: 53.34,128.01 53.04,128.01 52.28,127.24 47.8,127.24 RC179.1
CPU_DP1_HPD: length 214.3
  TOP w0.076: v7(58.01,129.94) 58.01,129.5 UCPU1.L9
  IN3 w0.066: v6(52.88,95.42) 52.39,95.42 50.64,97.16 47.64,97.16 45.52,99.28 45.09,99.28 42.44,101.92 39.5,101.92 38.38,100.8 29.25,100.8 26.82,103.24 22.63,103.24 v5(21.94,103.93) ; v5(16.61,21.31) 17.16,21.31 19.43,23.59 24.38,23.59 24.89,23.08 24.89,21.78 25.45,21.22 28.35,21.22 28.8,21.68 35.49,21.68 38.77,24.96 41.19,24.96 41.47,25.24 47.24,25.24 47.48,25.01 47.99,25.01 48.39,25.41 51.36,25.41 51.61,25.67 54.89,25.67 54.93,25.71 58,25.71 v5(58.42,25.29)
  IN4 w0.066: v1(58.39,32.65) 56.87,34.18 56.87,50.13 55.85,51.14 55.85,82.69 54.65,83.9 54.65,89.39 54.18,89.85 54.18,93.13 52.88,94.43 v6(52.88,95.42) 52.88,95.65 52.43,96.1 52.43,100.28 52.71,100.57 52.71,100.79 51.43,102.07 51.43,105.28 50.57,106.14 50.57,115.05 49.9,115.72 49.9,115.96 49.9,116.32 48.61,117.62 48.61,120.15 47.23,121.52 46.98,121.52 46.09,122.41 46.09,123.38 46.9,124.19 46.9,127.25 46.9,127.39 47.5,127.99 48.32,128.81 52.07,128.81 52.35,129.09 52.35,129.92 53.96,131.53 56.42,131.53 v7(58.01,129.94)
  BOTTOM w0.112: RC124.2 57.89,130.06 v7(58.01,129.94) ; v5(21.94,103.93) 21.36,104.51 D105.1 ; v1(58.39,32.65) v2(56.85,32.65) 54.76,32.65 54,31.89 54,27.7 54.58,27.12 57.38,27.12 58.42,26.07 v5(58.42,25.29)
