# Allegro board Dell Latitude 5290 2-IN-1 LA-F371P Boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D13: length 18.1
  IN2 w0.076: 72.65,109.21 72.65,109.43 73.51,110.29 73.51,112.58 v3(73.77,112.85)
  IN2 w0.094: 72.65,109.21 72.65,102.14 73.2,101.58 74.11,101.58 75.71,99.99 76.36,99.99 76.5,99.85 77.04,99.85 77.26,99.63 77.7,99.63 77.79,99.73 77.79,100.09 77.7,100.18 v3(77.44,100.18)
DDR_B_D14: length 23
  IN2 w0.076: 70.83,108.45 70.83,109.19 72.45,110.81 72.45,111.85 72.21,112.09 72.21,112.6 v3(72.45,112.85) ; v3(79.04,99.53) 78.4,99.53 78.14,99.27 78.14,98.81 77.67,98.34 75,98.34
  IN2 w0.094: 75,98.34 74.55,98.34 74.22,98.67 72.89,98.67 70.83,100.74 70.83,108.45
DDR_B_D15: length 21.5
  IN2 w0.076: 75,98.65 75.01,98.65 75.17,98.49 77.6,98.49 77.99,98.87 77.99,99.34 78.24,99.59 v3(78.24,100.18) ; 71.11,108.45 71.11,109.14 72.62,110.65 72.62,112.02 v3(72.45,112.19)
  IN2 w0.094: 75,98.65 74.69,98.65 74.39,98.95 73.01,98.95 71.11,100.85 71.11,108.45
DDR_B_D16: length 16
  TOP w0.076: v7(76.28,115.64) 76.61,115.31 UCPU1.AU40
  IN3 w0.094: v7(76.28,115.64) 76.28,114.38 76.22,114.32 76.22,113.67 75.79,113.24 75.79,104.44 77.9,102.34 77.9,101.83 v5(78.24,101.48)
DDR_B_D17: length 17.2
  TOP w0.076: UCPU1.AT40 76.86,115.96 v7(77.2,116.3)
  IN3 w0.094: v7(77.2,116.3) 77.57,115.93 77.57,114.72 77.26,114.41 77.26,113.52 76.36,112.62 76.36,106.15 78.23,104.27 78.23,102.8 78.61,102.43 78.61,101.92 v5(79.04,101.48)
DDR_B_D18: length 18.3
  TOP w0.076: UCPU1.AT37 74.87,115.96 v7(74.5,116.33)
  IN3 w0.076: v7(74.5,116.33) 74.5,116.09 74.81,115.79 74.81,115.34
  IN3 w0.094: v5(77.01,101.77) 76.94,101.85 76.23,101.85 73.41,104.67 73.41,109.54 74.02,110.15 74.02,113.88 74.81,114.68 74.81,115.34
  BOTTOM w0.076: UD3.C10 77.3,101.48 v5(77.01,101.77)
DDR_B_D19: length 17
  TOP w0.076: v7(74.45,115.64) 74.78,115.31 UCPU1.AU37
  IN3 w0.076: v7(74.45,115.64) 74.42,115.61
  IN3 w0.094: v5(76.64,101.48) 76.19,101.48 73.13,104.55 73.13,109.66 73.73,110.27 73.73,114.81 74.42,115.5 74.42,115.61
DDR_B_D20: length 17
  TOP w0.076: v7(77.2,116.94) 76.87,116.61 UCPU1.AR40
  IN3 w0.094: v7(77.2,116.94) 77.74,116.39 77.74,114.47 77.56,114.29 77.56,113.41 77.22,113.07 77.22,111.99 76.64,111.41 76.64,106.41 79.04,104.01 v5(79.04,102.13)
DDR_B_D21: length 17.4
  TOP w0.076: UCPU1.AP40 76.89,117.26 v7(77.2,117.57)
  IN3 w0.094: v7(77.2,117.57) 76.69,117.06 76.69,114.24 76.5,114.06 76.5,113.55 76.07,113.12 76.07,104.56 77.43,103.2 77.43,103.04 78.24,102.23 v5(78.24,102.13)
DDR_B_D22: length 17.9
  TOP w0.076: v7(74.5,117.6) 74.84,117.26 UCPU1.AP37
  IN3 w0.076: v7(74.5,117.6) 75.02,117.08 75.02,116.03 75.18,115.88
  IN3 w0.094: 75.18,115.88 75.18,113.98 74.84,113.64 74.84,104.05 76.46,102.43 76.94,102.43 v5(77.01,102.36)
  BOTTOM w0.076: v5(77.01,102.36) 77.23,102.13 UD3.B10
DDR_B_D23: length 16.8
  TOP w0.076: UCPU1.AR37 74.83,116.61 v7(74.5,116.94)
  IN3 w0.076: v7(74.5,116.94) 74.86,116.58 74.86,115.97 74.99,115.84 74.99,115.11
  IN3 w0.094: v5(76.64,102.13) 76.35,102.13 74.55,103.93 74.55,113.94 74.99,114.37 74.99,115.11
DDR_B_D24: length 24.3
  TOP w0.076: UCPU1.AT33 73.15,115.96 v7(73.51,116.33)
  IN3 w0.094: v7(73.51,116.33) 73.03,115.84 73.03,115.51 72.67,115.15 72.67,110.57 72.16,110.06 72.16,104.15 75.24,101.07 75.24,100.81 76.93,99.11 76.93,98.04 78,96.97 78,95.88 v5(78.24,95.63)
DDR_B_D25: length 23.5
  TOP w0.076: UCPU1.AU33 72.98,115.31 v7(72.62,115.67)
  IN3 w0.094: v7(72.62,115.67) 72.39,115.43 72.39,110.69 71.87,110.18 71.87,104.03 74.95,100.95 74.95,100.69 76.63,99.01 76.63,97.92 77.71,96.83 77.71,95.9 v5(77.44,95.63)
DDR_B_D26: length 24.9
  TOP w0.076: v7(70.77,115.64) 71.1,115.31 UCPU1.AU30
  IN3 w0.094: v5(77.44,94.98) 77.04,94.98 76.78,95.25 76.09,95.25 75.08,96.26 75.08,98.29 70.5,102.87 70.5,114.26 70.77,114.52 v7(70.77,115.64)
DDR_B_D27: length 25.3
  TOP w0.076: UCPU1.AT30 71.16,115.96 v7(70.87,116.25)
  IN3 w0.094: v5(76.64,94.98) 75.95,94.98 74.79,96.14 74.79,96.95 74.25,97.5 74.25,97.81 74.48,98.05 74.48,98.45 70.22,102.71 70.22,114.42 70.42,114.62 70.42,115.8 v7(70.87,116.25)
DDR_B_D28: length 26
  TOP w0.076: v7(73.51,116.96) 73.16,116.61 UCPU1.AR33
  IN3 w0.076: 72.95,114.37 72.95,114.67 73.88,115.59 73.88,116.59 v7(73.51,116.96)
  IN3 w0.094: v5(78.24,94.98) 78.62,95.36 78.62,95.89 78.28,96.22 78.28,97.09 77.24,98.13 77.24,99.2 75.52,100.92 75.52,101.19 72.44,104.27 72.44,109.94 72.95,110.46 72.95,114.37
DDR_B_D29: length 25.9
  TOP w0.076: UCPU1.AP33 73.2,117.26 v7(73.51,117.57)
  IN3 w0.076: 74.06,115.52 74.06,117.03 v7(73.51,117.57)
  IN3 w0.094: 74.06,115.52 73.33,114.8 73.33,110.43 72.73,109.83 72.73,104.39 75.81,101.31 75.81,101.04 79.04,97.81 v5(79.04,95.63)
DDR_B_D30: length 28.4
  TOP w0.076: v7(70.82,116.86) 71.07,116.61 UCPU1.AR30
  IN3 w0.094: v5(78.24,94.33) 77.89,94.68 75.85,94.68 74.51,96.02 74.51,96.68 69.53,101.66 69.53,114.11 70.23,114.81 70.23,116.27 v7(70.82,116.86)
DDR_B_D31: length 26.8
  TOP w0.076: UCPU1.AP30 71.35,117.26 v7(71.71,117.62)
  IN3 w0.094: v7(71.71,117.62) 71.25,117.16 71.25,114.49 70.92,114.17 70.92,102.91 75.41,98.42 75.41,96.33 76.23,95.5 76.9,95.5 v5(77.11,95.3)
  BOTTOM w0.173: UD3.M11 76.77,95.63 v5(77.11,95.3)
DDR_B_D32: length 26
  IN2 w0.076: 69.21,108.89 69.21,108.98 70.54,110.31 70.54,112.69 71.15,113.3 v3(71.15,113.5)
  IN2 w0.094: 69.21,108.89 69.21,100.15 73.04,96.33 75.88,96.33 76.09,96.53 77.54,96.53 77.99,96.09 77.99,95.23 v3(78.24,94.98)
DDR_B_D33: length 25.4
  IN2 w0.076: v3(71.15,114.15) 71.39,113.9 71.39,112.08 71.1,111.8 71.1,111.67
  IN2 w0.094: v3(79.04,95.63) 79.04,95.91 77.77,97.18 73.39,97.18 70.06,100.51 70.06,109.05 71.1,110.1 71.1,111.67
DDR_B_D34: length 26.1
  TOP w0.076: v3(69.42,112.87) 69.92,113.37 UCPU1.AY29
  IN2 w0.076: v3(69.42,112.87) 69.33,112.78 69.33,112.41 69.38,112.36 69.38,110.59 69.22,110.43
  IN2 w0.094: 69.22,110.43 67.69,108.9 67.69,99.52 72.58,94.63 75.9,94.63 76.25,94.98 v3(76.64,94.98)
DDR_B_D35: length 28.2
  IN2 w0.076: 67.4,108.45 67.4,109 69.23,110.82 69.23,112.3 69.18,112.34 69.18,113.02 69.34,113.18 69.34,113.57 v3(69.92,114.15)
  IN2 w0.094: v3(77.44,94.98) 77.14,94.68 76.39,94.68 76.06,94.35 72.46,94.35 67.4,99.4 67.4,108.45
DDR_B_D36: length 24.7
  IN2 w0.094: v3(71.15,112.19) 70.87,111.92 70.87,110.12 69.78,109.03 69.78,100.39 73.27,96.89 77.67,96.89 78.49,96.07 78.49,94.58 v3(78.24,94.33)
DDR_B_D37: length 24.3
  IN2 w0.076: v3(71.15,112.85) 70.7,112.4 70.7,110.24 69.49,109.03 69.49,108.9
  IN2 w0.094: 69.49,108.9 69.49,100.27 73.16,96.61 75.85,96.61 75.94,96.7 77.62,96.7 78.24,96.08 v3(78.24,95.63)
DDR_B_D38: length 25.6
  TOP w0.076: UCPU1.BA29 69.82,112.79 v3(69.58,112.54)
  IN2 w0.076: v3(69.58,112.54) 69.58,110.47 68.68,109.58
  IN2 w0.094: 68.68,109.58 67.97,108.87 67.97,99.64 72.61,95 75.67,95 75.86,95.19 76.34,95.19 76.46,95.32 77.12,95.32 v3(77.44,95.63)
DDR_B_D39: length 23.4
  TOP w0.076: UD1.F11 76.38,95.63 v3(76.25,95.5) ; v3(69.82,111.58) UCPU1.BB29
  IN2 w0.076: 69.82,111.54 69.82,110.48 68.66,109.32
  IN2 w0.094: v3(76.25,95.5) 75.81,95.5 75.69,95.37 72.64,95.37 68.26,99.76 68.26,108.92 68.66,109.32 ; 69.82,111.54 v3(69.82,111.58)
DDR_B_D40: length 32.2
  IN2 w0.094: v3(77.44,93.03) 77.19,92.78 71.38,92.78 66.15,98.01 66.15,104.9 66.04,105.02 66.04,105.41 66.15,105.52 66.15,105.82 66.04,105.93 65.77,105.93 65.68,106.02 65.68,106.21 65.77,106.3 66.04,106.3 66.14,106.4 66.14,106.59 66.04,106.68 65.77,106.68 65.68,106.77 65.68,107.52 66.15,108 66.15,108.59 65.89,108.85 65.89,109.04 66.4,109.55 66.62,109.55 66.97,109.9 67.2,109.9 68.39,111.09 68.39,111.67 68.87,112.15 68.87,113.19 68.95,113.27 68.95,113.41 68.87,113.5 v3(68.69,113.5)
DDR_B_D41: length 32.5
  IN2 w0.076: 68.89,110.71 69.08,110.9 69.08,112.12 69.03,112.16 69.03,113.11 69.15,113.23 69.15,113.83 68.84,114.15 v3(68.69,114.15)
  IN2 w0.094: v3(76.64,93.68) 76.38,93.95 75.97,93.95 75.88,93.85 75.88,93.76 75.78,93.66 75.59,93.66 75.5,93.76 75.5,93.85 75.41,93.95 75.21,93.95 75.12,93.85 75.12,93.73 75.02,93.64 74.83,93.64 74.74,93.73 74.74,93.85 74.65,93.95 74.39,93.95 74.3,93.85 74.3,93.73 74.2,93.64 74.01,93.64 73.92,93.73 73.92,93.85 73.83,93.95 73.64,93.95 73.54,93.85 73.54,93.73 73.45,93.64 73.26,93.64 73.17,93.73 73.17,93.85 73.07,93.95 72.89,93.95 72.79,93.85 72.79,93.73 72.7,93.64 72.51,93.64 72.42,93.73 72.42,93.83 72.29,93.96 72.13,93.96 71.89,93.72 71.76,93.72 71.62,93.85 71.62,93.98 71.87,94.22 71.87,94.36 71.73,94.49 71.6,94.49 71.36,94.25 71.23,94.25 71.09,94.38 71.09,94.51 71.33,94.76 71.33,94.89 71.2,95.02 71.07,95.02 70.83,94.78 70.69,94.78 70.56,94.91 70.56,95.05 70.8,95.29 70.8,95.42 67.01,99.22 67.01,108.85 68.87,110.71 68.89,110.71
DDR_B_D42: length 35.5
  IN2 w0.094: v3(78.24,93.68) 78.49,93.43 78.49,92.93 77.11,91.55 70.87,91.55 64.92,97.5 64.92,104.37 64.44,104.84 64.44,109.36 66.08,111 66.99,111 67.47,111.47 v3(67.47,113.5)
DDR_B_D43: length 34.6
  IN2 w0.094: v3(67.47,114.15) 67.47,113.95 67.75,113.67 67.75,111.37 67.06,110.68 66.17,110.68 64.73,109.24 64.73,104.96 65.2,104.49 65.2,97.62 70.98,91.83 77.05,91.83 78.24,93.02 v3(78.24,93.03)
DDR_B_D44: length 30.6
  TOP w0.076: UCPU1.BB27 68.79,111.8 v3(68.83,111.76)
  IN2 w0.094: v3(68.83,111.76) 68.58,111.51 68.58,111.04 66.83,109.29 66.67,109.29 66.44,109.05 66.44,107.88 65.97,107.41 65.97,107.06 66.07,106.96 66.3,106.96 66.44,106.83 66.44,98.2 66.65,97.99 66.78,97.99 67.04,98.24 67.17,98.24 67.3,98.11 67.3,97.98 67.05,97.72 67.05,97.59 67.18,97.45 67.31,97.45 67.57,97.71 67.7,97.71 67.84,97.58 67.84,97.44 67.58,97.19 67.58,97.06 67.71,96.92 67.85,96.92 68.1,97.18 68.24,97.18 68.37,97.05 68.37,96.91 68.11,96.66 68.11,96.52 71.57,93.07 76.61,93.07 v3(76.64,93.03)
DDR_B_D45: length 31
  TOP w0.076: v3(77.08,93.42) 77.35,93.68 UD1.C10 ; v3(68.83,111.38) 68.47,111.74 68.47,112.29 68.79,112.62 UCPU1.BA27
  IN2 w0.094: v3(77.08,93.42) 77.02,93.35 71.71,93.35 69.73,95.33 69.73,95.46 69.98,95.71 69.98,95.84 69.84,95.97 69.71,95.97 69.46,95.73 69.33,95.73 69.2,95.86 69.2,96 69.44,96.24 69.44,96.37 69.31,96.51 69.18,96.51 68.93,96.26 68.8,96.26 68.67,96.4 68.67,96.53 68.91,96.77 68.91,96.91 67.28,98.54 66.85,98.54 66.72,98.66 66.72,106.99 66.46,107.25 66.46,107.5 66.72,107.76 66.72,108.94 68.83,111.05 v3(68.83,111.38)
DDR_B_D46: length 36.1
  TOP w0.076: v3(67.14,112.85) 67.16,112.85 UCPU1.BA25
  IN2 w0.094: v3(79.04,93.03) 79.04,92.67 77.34,90.98 70.6,90.98 64.35,97.23 64.35,104.14 63.87,104.61 63.87,109.36 63.87,109.36 63.87,109.6 65.79,111.51 66.17,111.51 66.83,112.17 66.83,112.54 v3(67.14,112.85)
DDR_B_D47: length 35.5
  TOP w0.076: v3(67.12,112.19) UCPU1.BB25
  IN2 w0.094: v3(79.04,93.68) 78.74,93.38 78.74,92.77 77.23,91.26 70.75,91.26 64.63,97.38 64.63,104.25 64.16,104.73 64.16,109.48 65.87,111.19 66.94,111.19 67.16,111.41 67.16,112.16 v3(67.12,112.19)
DDR_B_D48: length 26.4
  TOP w0.076: v7(69.88,115.67) 69.53,115.31 UCPU1.AU27
  IN4 w0.069: v7(69.88,115.67) 69.88,115.57 70.6,114.85 70.6,114.75 70.37,114.53 70.37,114.43 70.47,114.33 70.57,114.33 70.79,114.56 70.89,114.56 70.99,114.46 70.99,114.36 70.76,114.13 70.76,114.04 70.85,113.94 70.95,113.94 71.18,114.17 71.28,114.17 71.38,114.07 71.38,113.98 71.11,113.72 71.11,113.62 71.21,113.52 71.31,113.52 71.57,113.78 71.67,113.78 71.76,113.68 71.76,113.59 71.5,113.33 71.5,113.23 71.6,113.13 71.7,113.13 71.96,113.39 72.05,113.39 72.15,113.3 72.15,113.2 71.89,112.94 71.89,112.84 71.99,112.74 72.08,112.74 72.35,113.01 72.44,113.01 72.54,112.91 72.54,112.81 72.28,112.55 72.28,112.45 72.38,112.36 72.47,112.36 72.72,112.6 72.82,112.6 72.93,112.49 72.93,112.4 72.65,112.12 72.65,109.95 72.58,109.88 72.08,109.88 72.01,109.81 72.01,109.67 72.08,109.6 72.58,109.6 72.65,109.54 72.65,108.66 74.82,106.49 74.82,104.78 76.37,103.24 76.37,101.28 76.5,101.15 76.84,101.15 77.03,100.96 v1(77.03,99.84)
  BOTTOM w0.076: UD3.F11 76.72,99.53 v1(77.03,99.84)
DDR_B_D49: length 27.8
  TOP w0.076: v7(69.88,116.28) 69.88,116.22 69.62,115.96 UCPU1.AT27
  IN4 w0.069: v7(69.88,116.28) 70.36,115.8 70.36,115.46 71.11,114.71 71.29,114.71 71.61,115.03 71.71,115.03 71.81,114.93 71.81,114.84 71.44,114.47 71.44,114.38 71.54,114.28 71.64,114.28 72.02,114.66 72.11,114.66 72.21,114.56 72.21,114.46 71.83,114.08 71.83,113.99 71.93,113.89 72.02,113.89 72.4,114.27 72.5,114.27 72.6,114.17 72.6,114.07 72.22,113.69 72.22,113.6 72.31,113.5 72.41,113.5 72.79,113.88 72.89,113.88 72.99,113.78 72.99,113.69 72.61,113.31 72.61,113.21 72.7,113.11 72.8,113.11 72.99,113.3 73.09,113.3 73.18,113.21 73.18,113.11 72.99,112.92 72.99,112.82 73.19,112.62 73.19,112.08 73.13,112.01 72.98,112.01 72.91,111.94 72.91,111.8 72.98,111.73 73.13,111.73 73.19,111.66 73.19,111.53 73.13,111.46 72.98,111.46 72.91,111.39 72.91,111.25 72.98,111.18 73.13,111.18 73.19,111.12 73.19,110.98 73.13,110.91 72.98,110.91 72.91,110.84 72.91,110.7 72.98,110.64 73.13,110.64 73.19,110.57 73.19,110.43 73.13,110.36 72.98,110.36 72.91,110.29 72.91,110.15 72.98,110.09 73.13,110.09 73.19,110.02 73.19,109.88 73.13,109.81 72.98,109.81 72.91,109.74 72.91,109.61 72.98,109.54 73.13,109.54 73.19,109.47 73.19,109.33 73.13,109.26 72.98,109.26 72.91,109.19 72.91,109.06 72.98,108.99 73.13,108.99 73.19,108.92 73.19,108.48 75.08,106.59 75.08,104.89 77.72,102.25 77.72,100.46 77.72,100.46 ; v5(77.44,100.18) 77.65,100.39
  IN4 w0.076: 77.65,100.39 77.72,100.46
DDR_B_D50: length 28.3
  TOP w0.076: UCPU1.AT25 68.35,115.96 v7(68.08,115.69)
  IN4 w0.069: v1(78.24,99.53) 78,99.53 77.93,99.46 77.93,98.76 77.64,98.47 76.43,98.47 75.52,99.37 75.52,99.7 74.82,100.41 74.82,102.68 71.87,105.62 71.87,105.72 72.54,106.39 72.54,106.49 72.45,106.59 72.35,106.59 71.68,105.91 71.58,105.91 71.48,106.01 71.48,106.11 72.15,106.78 72.15,106.88 72.06,106.97 71.96,106.97 71.3,106.31 71.18,106.31 69.6,107.9 69.6,112.46 67.63,114.42 67.63,115.25 v7(68.08,115.69)
DDR_B_D51: length 27.2
  TOP w0.076: v7(68.1,115.03) 68.38,115.31 UCPU1.AU25
  IN4 w0.069: v7(68.1,115.03) 68.1,114.32 69.86,112.57 69.86,108 71.13,106.73 71.25,106.73 71.82,107.3 72.1,107.3 72.85,106.54 72.85,106.3 72.32,105.76 72.32,105.67 72.41,105.57 72.51,105.57 73.09,106.15 73.19,106.15 73.29,106.05 73.29,105.96 72.7,105.37 72.7,105.28 72.8,105.18 72.9,105.18 73.2,105.48 73.29,105.48 73.39,105.38 73.39,105.29 73.09,104.99 73.09,104.89 75.07,102.91 75.07,100.51 75.63,99.95 75.86,99.95 76.2,99.62 76.2,98.9 76.46,98.65 77.54,98.65 77.74,98.85 77.74,99.23 v1(77.44,99.53)
DDR_B_D52: length 27.9
  TOP w0.076: v7(68.99,117.57) 69.3,117.26 UCPU1.AP27
  IN4 w0.069: v1(76.64,100.18) 76.27,100.56 76.27,100.88 76.11,101.03 76.11,103.13 74.29,104.95 74.29,106.35 72.19,108.44 71.87,108.44 71.75,108.57 71.75,108.94 71.84,109.02 72.32,109.02 72.39,109.09 72.39,109.23 72.32,109.3 71.84,109.3 71.75,109.39 71.75,110.14 71.82,110.21 72.32,110.21 72.39,110.28 72.39,110.41 72.32,110.48 71.82,110.48 71.75,110.55 71.75,110.69 71.82,110.76 72.32,110.76 72.39,110.82 72.39,111.98 71.97,112.4 71.87,112.4 71.62,112.15 71.52,112.15 71.42,112.24 71.42,112.34 71.68,112.59 71.68,112.69 71.58,112.79 71.48,112.79 71.23,112.53 71.13,112.53 71.03,112.63 71.03,112.73 71.29,112.98 71.29,113.08 71.19,113.18 71.09,113.18 70.84,112.92 70.74,112.92 70.65,113.02 70.65,113.12 70.9,113.37 70.9,113.47 70.8,113.56 70.7,113.56 70.45,113.31 70.35,113.31 70.26,113.41 70.26,113.5 70.51,113.76 70.51,113.92 69.96,114.47 69.68,114.47 69.48,114.67 69.48,116.96 68.99,117.45 v7(68.99,117.57)
DDR_B_D53: length 28.3
  TOP w0.076: UCPU1.AN27 69.36,117.91 v7(69.02,118.26)
  IN4 w0.069: v1(78.24,100.83) 77.98,101.1 77.98,102.62 78.21,102.85 78.21,103.35 78,103.56 77.27,103.56 76.08,104.75 76.08,106.3 75.96,106.43 75.61,106.43 75.49,106.56 75.49,106.66 75.79,106.96 75.79,107.06 75.7,107.16 75.6,107.16 75.29,106.85 75.19,106.85 75.1,106.95 75.1,107.04 75.4,107.35 75.4,107.45 75.31,107.54 75.21,107.54 74.9,107.24 74.81,107.24 74.71,107.34 74.71,107.43 75.02,107.74 75.02,107.84 74.92,107.93 74.82,107.93 74.52,107.63 74.42,107.63 74.32,107.72 74.32,107.82 74.63,108.13 74.63,108.22 74.53,108.32 74.43,108.32 74.13,108.01 74.03,108.01 73.93,108.11 73.93,108.21 74.24,108.52 74.24,108.61 74.14,108.71 74.05,108.71 73.74,108.4 73.64,108.4 73.45,108.59 73.45,113.68 71.52,115.62 71.52,116.68 70.95,117.24 69.56,117.24 69.36,117.45 69.36,117.92 v7(69.02,118.26)
DDR_B_D54: length 31.2
  TOP w0.076: UCPU1.AN25 68.41,117.91 v7(68.07,118.26)
  IN4 w0.069: v1(79.04,99.53) 78.76,99.25 78.76,98.54 78.02,97.8 77.07,97.8 76.8,98.07 76.1,98.07 74.95,99.21 74.95,99.53 74.3,100.19 74.3,102.43 69.08,107.64 69.08,112.19 65.79,115.49 65.79,117.67 66.38,118.26 v7(68.07,118.26)
DDR_B_D55: length 30
  TOP w0.076: UCPU1.AP25 68.39,117.26 v7(68.1,117.55)
  IN4 w0.069: v1(78.24,100.18) 78.53,99.9 78.53,98.76 77.76,98 77.19,98 76.89,98.3 76.23,98.3 75.21,99.32 75.21,99.64 74.56,100.3 74.56,102.53 69.34,107.75 69.34,112.3 66.8,114.84 66.8,116.27 66.62,116.45 66.62,117.8 66.8,117.98 67.66,117.98 v7(68.1,117.55)
DDR_B_D56: length 35.9
  TOP w0.076: UCPU1.AT22 66.86,115.96 v7(67.16,116.26)
  IN3 w0.094: v5(76.64,93.03) 76.13,93.03 73.54,95.62 73.54,96.27 69.44,100.37 68.79,100.37 67.8,101.36 67.8,101.87 67.89,101.96 68.37,101.96 68.47,102.05 68.47,102.24 68.37,102.34 67.89,102.34 67.8,102.43 67.8,102.62 67.89,102.71 68.37,102.71 68.47,102.81 68.47,102.99 68.37,103.09 67.89,103.09 67.8,103.18 67.8,103.37 67.89,103.46 68.37,103.46 68.47,103.56 68.47,103.75 68.37,103.84 67.89,103.84 67.8,103.93 67.8,104.12 67.89,104.22 68.37,104.22 68.47,104.31 68.47,104.5 68.37,104.59 67.89,104.59 67.8,104.69 67.8,105.54 67.34,105.99 67.34,108.61 67.74,109.01 67.74,109.81 68.2,110.27 68.2,113.39 67.88,113.71 67.75,113.71 67.38,113.34 67.25,113.34 67.11,113.47 67.11,113.6 67.49,113.98 67.49,114.11 67.23,114.37 66.67,114.37 66.57,114.46 66.57,115.8 66.8,116.03 66.8,116.26 66.9,116.35 67.07,116.35 v7(67.16,116.26)
DDR_B_D57: length 34.5
  TOP w0.076: UCPU1.AU22 66.83,115.31 v7(67.16,115.64)
  IN3 w0.094: v5(77.06,93.42) 76.15,93.42 73.83,95.74 73.83,96.39 68.85,101.37 68.85,105.31 68.7,105.46 68.2,105.46 68.11,105.55 68.11,105.74 68.2,105.83 68.74,105.83 68.83,105.93 68.83,106.12 68.74,106.21 67.81,106.21 67.72,106.3 67.72,106.49 67.81,106.59 68.74,106.59 68.84,106.68 68.84,106.87 68.74,106.96 67.81,106.96 67.72,107.06 67.72,107.24 67.81,107.34 68.75,107.34 68.84,107.43 68.84,107.62 68.75,107.71 67.72,107.71 67.63,107.81 67.63,108.49 68.02,108.89 68.02,109.69 68.49,110.15 68.49,113.51 67.51,114.48 67.51,115.29 v7(67.16,115.64)
  BOTTOM w0.173: v5(77.06,93.42) 77.33,93.68 UD3.R10
DDR_B_D58: length 36.6
  TOP w0.076: v7(65.38,114.92) 65.4,114.92 UCPU1.AU21
  IN3 w0.094: v7(65.38,114.92) 65.33,114.88 65.33,113.47 65.24,113.38 64.88,113.38 64.79,113.29 64.79,113.1 64.88,113 65.24,113 65.33,112.91 65.33,112.72 65.24,112.63 64.88,112.63 64.79,112.53 64.79,112.35 64.88,112.25 65.24,112.25 65.33,112.16 65.33,111.97 65.24,111.88 64.88,111.88 64.79,111.78 64.79,111.59 64.88,111.5 65.24,111.5 65.33,111.41 65.33,111.22 65.24,111.12 64.88,111.12 64.79,111.03 64.79,110.84 64.88,110.75 65.24,110.75 65.33,110.65 65.33,110.47 65.24,110.37 64.88,110.37 64.79,110.28 64.79,110.09 64.88,110 65.24,110 65.33,109.9 65.33,109.71 65.24,109.62 64.88,109.62 64.79,109.53 64.79,109.34 64.88,109.24 65.24,109.24 65.33,109.15 65.33,106.21 66.56,104.98 66.56,100.85 68.28,99.14 68.93,99.14 72.3,95.76 72.3,95.11 75.4,92.01 77.29,92.01 78.24,92.96 v5(78.24,93.03)
DDR_B_D59: length 36.7
  TOP w0.076: UCPU1.AT21 65.71,115.96 v7(65.38,115.64)
  IN3 w0.094: v7(65.38,115.64) 64.9,115.15 64.9,114.35 64.47,113.93 64.47,108.89 64.57,108.8 64.88,108.8 64.97,108.7 64.97,108.52 64.88,108.42 64.57,108.42 64.47,108.33 64.47,108.14 64.57,108.05 64.88,108.05 64.97,107.95 64.97,107.76 64.88,107.67 64.57,107.67 64.47,107.58 64.47,107.39 64.57,107.29 64.88,107.29 64.97,107.2 64.97,107.01 64.88,106.92 64.57,106.92 64.47,106.82 64.47,106 66.28,104.2 66.28,100.73 68.16,98.85 68.81,98.85 72.02,95.64 72.02,94.99 75.38,91.63 77.19,91.63 78.49,92.93 78.49,93.43 v5(78.24,93.68)
DDR_B_D60: length 36.2
  TOP w0.076: v7(66.22,117.57) 66.56,117.91 UCPU1.AN22
  IN3 w0.094: v7(66.22,117.57) 66.63,117.16 67.72,117.16 67.82,117.07 67.82,116.59 67.69,116.46 67.69,114.71 69.13,113.27 69.13,113.07 69.04,112.98 68.86,112.98 68.77,112.88 68.77,112.7 68.86,112.6 69.04,112.6 69.13,112.51 69.13,112.32 69.04,112.23 68.86,112.23 68.77,112.13 68.77,111.94 68.86,111.85 69.04,111.85 69.13,111.76 69.13,111.57 69.04,111.47 68.86,111.47 68.77,111.38 68.77,111.19 68.86,111.1 69.04,111.1 69.13,111 69.13,110.82 69.04,110.72 68.86,110.72 68.77,110.63 68.77,110.44 68.86,110.35 69.04,110.35 69.13,110.25 69.13,110.07 69.04,109.97 68.71,109.97 68.61,109.88 68.61,109.69 68.71,109.6 69.04,109.6 69.13,109.5 69.13,109.31 69.04,109.22 68.4,109.22 68.31,109.13 68.31,108.94 68.4,108.84 69.04,108.84 69.13,108.75 69.13,108.56 69.04,108.47 68.01,108.47 67.91,108.37 67.91,108.19 68.01,108.09 69.04,108.09 69.13,108 69.13,101.49 74.11,96.51 74.11,95.86 76.28,93.68 v5(76.64,93.68)
DDR_B_D61: length 37.4
  TOP w0.076: UCPU1.AP22 66.55,117.26 v7(66.22,116.94)
  IN3 w0.094: v5(77.44,93.03) 77.19,92.78 75.98,92.78 73.26,95.5 73.26,96.16 69.33,100.09 68.67,100.09 67.51,101.25 67.51,105.4 66.29,106.62 66.29,107.1 66.38,107.19 66.96,107.19 67.06,107.29 67.06,107.48 66.96,107.57 66.38,107.57 66.29,107.66 66.29,107.85 66.38,107.95 66.96,107.95 67.06,108.04 67.06,108.23 66.96,108.32 66.38,108.32 66.29,108.42 66.29,108.61 66.38,108.71 67.04,108.71 67.45,109.12 67.45,109.93 67.92,110.39 67.92,111.48 67.82,111.57 67.27,111.57 67.18,111.66 67.18,111.85 67.27,111.95 67.82,111.95 67.92,112.04 67.92,112.26 67.69,112.49 67.69,112.62 67.92,112.85 67.92,112.99 67.78,113.12 67.65,113.12 67.42,112.89 67.29,112.89 66.4,113.78 66.4,115.87 66.63,116.09 66.63,116.53 v7(66.22,116.94)
DDR_B_D62: length 38.7
  TOP w0.076: v7(65.31,116.96) 65.61,117.26 UCPU1.AP21
  IN3 w0.094: v7(65.31,116.96) 64.9,117.37 64.9,117.53 64.56,117.87 64.27,117.87 64.06,117.66 64.06,114.74 64.19,114.61 64.19,105.88 65.99,104.08 65.99,100.61 68.04,98.57 68.69,98.57 71.74,95.53 71.74,94.87 75.26,91.35 77.15,91.35 78.76,92.96 v5(78.76,93.33)
  BOTTOM w0.173: v5(78.76,93.33) UD3.T8
DDR_B_D63: length 39.4
  TOP w0.076: UCPU1.AN21 65.6,117.91 v7(65.31,117.62)
  IN3 w0.094: v5(79.04,93.68) 79.04,93 77.1,91.06 75.14,91.06 71.45,94.75 71.45,95.41 68.58,98.28 67.92,98.28 65.71,100.5 65.71,103.96 63.89,105.78 63.89,117.73 64.2,118.04 64.89,118.04 v7(65.31,117.62)
DDR_B_DQS0: length 14.9
  IN2 w0.094: v3(77.44,100.83) 77.44,100.91 77.85,101.32 77.85,101.71 76.99,102.57 76.57,102.57 75.39,103.75 75.39,111.67 76.07,112.36 76.07,113 75.56,113.51 v3(75.56,113.82)
DDR_B_DQS1: length 21.4
  IN2 w0.076: 75.11,99.5 75.13,99.47 76.87,99.47 77.11,99.23 77.11,98.96 77.19,98.88 v3(77.44,98.88) ; v3(73.11,113.17) 73.11,113.31 73.19,113.39 73.31,113.39 73.41,113.29 73.41,113.03 73.11,112.74 73.11,110.51 71.95,109.35 71.95,108.48 71.96,108.47 71.96,108.45
  IN2 w0.094: 71.96,108.45 71.96,101.19 72.32,100.83 72.45,100.83 72.59,100.97 72.85,100.97 73.14,100.68 73.14,100.42 73,100.28 73,100.15 73.35,99.81 73.55,99.81 73.64,99.9 73.64,100.29 73.83,100.48 74.24,100.48 74.42,100.29 74.42,99.9 74.51,99.81 74.8,99.81 75.11,99.5
DDR_B_DQS2: length 17.7
  TOP w0.076: v7(76.26,116.33) 75.97,116.61 UCPU1.AR38
  IN3 w0.094: v5(77.44,100.83) 77.25,100.83 77.15,100.93 77.15,101.2 77.42,101.46 77.42,102.52 76.99,102.94 76.72,102.94 75.39,104.28 75.39,113.41 75.75,113.76 75.75,114.83 75.87,114.94 75.87,115.94 v7(76.26,116.33)
DDR_B_DQS3: length 26.4
  TOP w0.076: UCPU1.AR32 72.27,116.61 v7(72.6,116.94)
  IN3 w0.094: v7(72.6,116.94) 71.79,116.94 71.61,116.75 71.61,114.37 71.32,114.08 71.32,103.17 73.18,101.3 73.76,101.3 74.37,100.69 74.37,100.1 75.82,98.66 75.82,96.49 76.51,95.8 76.96,95.8 77.15,95.99 77.15,96.19 77.25,96.28 v5(77.44,96.28)
DDR_B_DQS4: length 26
  IN2 w0.094: v3(77.44,96.28) 77.44,96.24 77.34,96.14 77.34,95.96 77.15,95.77 72.81,95.77 68.66,99.92 68.66,109.01 70.07,110.42 70.07,112.75 69.85,112.97 69.85,113.48 70.07,113.7 70.46,113.7 v3(70.58,113.82)
DDR_B_DQS5: length 35.1
  IN2 w0.094: v3(68.13,113.17) 68.25,113.17 68.43,113 68.43,112.4 68.04,112.02 68.04,111.3 67.04,110.3 66.44,110.3 65.13,108.98 65.13,108.68 65.31,108.49 65.49,108.49 65.58,108.4 65.58,108.21 65.49,108.11 65.31,108.11 65.13,107.93 65.13,105.13 65.6,104.66 65.6,97.78 71.15,92.23 77.21,92.23 77.85,92.87 77.85,93.23 77.03,94.05 77.03,94.24 77.12,94.33 v3(77.44,94.33)
DDR_B_DQS6: length 29.7
  TOP w0.076: UCPU1.AR27 69.29,116.61 v7(68.99,116.91)
  IN4 w0.069: v7(68.99,116.91) 68.7,116.62 68.7,116.52 68.99,116.23 68.99,114.14 71.37,111.76 71.37,111.22 71.23,111.08 70.43,111.08 70.36,111.01 70.36,110.81 70.43,110.74 71.23,110.74 71.37,110.59 71.37,110.28 71.23,110.13 70.43,110.13 70.36,110.07 70.36,109.86 70.43,109.79 71.23,109.79 71.37,109.65 71.37,109.33 71.23,109.19 70.43,109.19 70.36,109.12 70.36,108.92 70.43,108.85 71.23,108.85 71.37,108.7 71.37,108.41 70.82,107.85 70.82,107.76 71.14,107.43 71.24,107.43 71.86,108.05 72.06,108.05 73.92,106.19 73.92,104.8 75.58,103.13 75.58,100.72 77.15,99.15 77.15,98.98 77.25,98.88 v1(77.44,98.88)
DDR_B_DQS7: length 39.9
  TOP w0.076: v7(65.28,116.3) 65.59,116.61 UCPU1.AR21
  IN3 w0.094: v5(77.44,94.33) 77.34,94.24 77.34,94.1 77.44,94.01 77.54,94.01 77.92,93.63 77.92,92.94 77.42,92.44 75.53,92.44 72.7,95.27 72.7,95.93 69.1,99.53 68.44,99.53 66.96,101.02 66.96,105.16 65.73,106.39 65.73,109.07 65.92,109.26 66.81,109.26 66.9,109.35 66.9,109.64 66.81,109.73 65.92,109.73 65.73,109.91 65.73,110.34 65.92,110.53 67.27,110.53 67.36,110.62 67.36,110.9 67.27,110.99 65.92,110.99 65.73,111.18 65.73,112.17 65.92,112.35 66.58,112.35 66.67,112.44 66.67,112.73 66.58,112.82 66.04,112.82 65.85,113.02 65.85,114.21 65.86,114.23 65.86,115.72 v7(65.28,116.3)
DDR_B_DQS#0: length 14.9
  IN2 w0.094: v3(76.64,100.83) 76.87,101.06 77.26,101.06 77.41,101.2 77.52,101.2 77.69,101.38 77.69,101.65 76.93,102.41 76.51,102.41 75.23,103.69 75.23,111.73 75.92,112.42 75.92,112.94 75.69,113.17 v3(75.47,113.17)
DDR_B_DQS#1: length 21.5
  IN2 w0.076: v3(76.64,98.88) 76.9,98.88 76.97,98.96 76.97,99.18 76.81,99.34 75.06,99.34 75.02,99.38 75,99.38 75,99.39 ; 71.8,108.45 71.8,108.47 71.81,108.48 71.81,109.41 72.97,110.57 72.97,112.89 72.87,113 72.87,113.27 73.01,113.41 v3(73.01,113.82)
  IN2 w0.094: 75,99.39 74.73,99.65 74.45,99.65 74.27,99.84 74.27,100.23 74.17,100.32 73.89,100.32 73.8,100.23 73.8,99.84 73.61,99.65 73.28,99.65 72.85,100.08 72.85,100.35 72.98,100.48 72.98,100.61 72.78,100.81 72.65,100.81 72.52,100.68 72.25,100.68 71.8,101.13 71.8,108.45
DDR_B_DQS#2: length 17.7
  TOP w0.076: UCPU1.AT38 75.78,115.96 v7(75.44,116.3)
  IN3 w0.094: v5(76.64,100.83) 76.89,100.83 77,100.94 77,101.27 77.26,101.53 77.26,102.46 76.93,102.79 76.66,102.79 75.23,104.21 75.23,113.47 75.59,113.83 75.59,114.89 75.71,115.01 75.71,116.03 v7(75.44,116.3)
DDR_B_DQS#3: length 26.5
  TOP w0.076: v7(72.62,116.3) 72.28,115.96 UCPU1.AT32
  IN3 w0.094: v5(76.64,96.28) 76.64,96.43 76.73,96.52 76.91,96.52 77,96.43 77,96.06 76.89,95.95 76.57,95.95 75.97,96.55 75.97,98.72 74.53,100.17 74.53,100.76 73.83,101.46 73.25,101.46 71.47,103.23 71.47,114.02 71.76,114.31 71.76,116.68 71.86,116.78 72.26,116.78 72.62,116.41 v7(72.62,116.3)
DDR_B_DQS#4: length 25.9
  IN2 w0.094: v3(76.64,96.28) 76.72,96.36 77.09,96.36 77.18,96.27 77.18,96.02 77.09,95.93 72.87,95.93 68.81,99.99 68.81,108.95 70.23,110.36 70.23,112.81 70,113.03 70,113.38 70.16,113.54 70.39,113.54 70.48,113.45 v3(70.48,113.17)
DDR_B_DQS#5: length 35
  IN2 w0.094: v3(76.64,94.33) 76.78,94.33 76.87,94.24 76.87,93.98 77.69,93.16 77.69,92.93 77.15,92.38 71.21,92.38 65.75,97.85 65.75,104.72 65.28,105.19 65.28,107.86 65.38,107.96 65.55,107.96 65.74,108.14 65.74,108.46 65.55,108.64 65.38,108.64 65.28,108.74 65.28,108.92 66.51,110.15 67.11,110.15 68.2,111.24 68.2,111.95 68.58,112.33 68.58,113.07 68.03,113.62 v3(68.03,113.82)
DDR_B_DQS#6: length 29.7
  TOP w0.076: v7(68.1,116.26) 68.45,116.61 UCPU1.AR25
  IN4 w0.069: v1(76.64,98.88) 76.93,98.88 77.03,98.98 77.03,99.09 75.45,100.67 75.45,103.08 73.79,104.74 73.79,106.14 72.01,107.92 71.91,107.92 71.29,107.3 71.09,107.3 70.69,107.7 70.69,107.91 71.24,108.47 71.24,108.65 71.18,108.72 70.38,108.72 70.23,108.86 70.23,109.18 70.38,109.32 71.18,109.32 71.24,109.39 71.24,109.59 71.18,109.66 70.38,109.66 70.23,109.81 70.23,110.12 70.38,110.26 71.18,110.26 71.24,110.33 71.24,110.54 71.18,110.61 70.38,110.61 70.23,110.75 70.23,111.07 70.38,111.21 71.18,111.21 71.24,111.28 71.24,111.71 68.86,114.09 68.86,116.18 68.59,116.46 68.3,116.46 v7(68.1,116.26)
DDR_B_DQS#7: length 39.8
  TOP w0.076: UCPU1.AR22 66.61,116.61 v7(66.27,116.28)
  IN3 w0.094: v7(66.27,116.28) 66.11,116.28 65.82,115.99 66.02,115.79 66.02,114.16 66,114.15 66,113.08 66.11,112.98 66.64,112.98 66.83,112.79 66.83,112.38 66.64,112.2 65.98,112.2 65.89,112.1 65.89,111.24 65.98,111.15 67.33,111.15 67.52,110.97 67.52,110.55 67.33,110.37 65.98,110.37 65.89,110.28 65.89,109.98 65.98,109.88 66.87,109.88 67.06,109.7 67.06,109.29 66.87,109.1 65.98,109.1 65.89,109.01 65.89,106.45 67.12,105.23 67.12,101.08 68.51,99.69 69.16,99.69 72.86,95.99 72.86,95.34 75.6,92.6 77.36,92.6 77.76,93 77.76,93.56 77.47,93.85 77.37,93.85 77.19,94.04 77.19,94.24 77.1,94.33 v5(76.64,94.33)
DDR_B_ODT0: length 42.6
  TOP w0.076: v7(77.22,111.44) 77.15,111.52 77.15,112.15 77.15,112.16 77.15,112.59 UCPU1.BA42 ; UD1.J8 79.5,98.04 79.5,98.75 v7(79.95,99.21)
  IN1 w0.107: v8(86.96,99.89) 86.82,99.75 83.38,99.75 83.25,99.87 82.92,99.87 82.65,99.6 82.65,99.46 82.39,99.21 v7(79.95,99.21)
  IN4 w0.069: v7(79.95,99.21) 79.95,99.72 79.34,100.34 79.34,101.67 79.17,101.84 78.92,101.84 78.74,102.01 78.74,102.38 79,102.63 79,103.56 77.99,104.56 77.99,106.4 76.72,107.67 76.72,109.41 76.65,109.48 76.52,109.48 76.45,109.41 76.45,107.7 76.38,107.63 76.24,107.63 76.17,107.7 76.17,109.41 76.11,109.48 75.97,109.48 75.9,109.41 75.9,108.23 75.83,108.16 75.69,108.16 75.63,108.23 75.63,110.9 75.56,110.96 75.42,110.96 75.35,110.9 75.35,108.79 75.28,108.73 75.15,108.73 75.08,108.79 75.08,111.12 75.41,111.44 76.23,111.44 76.3,111.38 76.3,110.55 76.37,110.48 76.51,110.48 76.57,110.55 76.57,111.38 76.64,111.44 v7(77.22,111.44)
  BOTTOM w0.076: UD1.J8 79.04,97.75 79.4,98.11 79.4,98.66 v7(79.95,99.21)
DDR_CHA_EN: length 7.7
  IN2 w0.066: v3(55.28,127.33) 55.28,127.2 v4(55.07,126.99)
  IN3 w0.066: v5(50.43,127.64) 50.36,127.56 50.36,127.05 51.2,126.21 54.46,126.21 55.07,126.82 v4(55.07,126.99)
  BOTTOM w0.112: v5(50.43,127.64) 50.19,127.4 RH31.1
DDR_CHB_EN: length 4.2
  IN2 w0.066: v3(54.63,127.33) 54.63,127.06 54.3,126.73 v4(54.3,126.55)
  IN3 w0.066: v4(54.3,126.55) 52.87,126.55 52.76,126.65 52.58,126.65 v5(52.53,126.6)
  BOTTOM w0.112: RH29.1 52.3,126.84 RH28.1
DDR_VTT_CNTL: length 12
  TOP w0.076: UCPU1.AW67 92.35,114.18 93.04,114.18 93.27,113.95 93.27,113.85 93.44,113.68 93.68,113.68 93.77,113.77 94.38,113.77 94.54,113.6 94.73,113.6 95.01,113.32 95.89,113.32
  TOP w0.112: UC1.2 97.14,118.56 97.03,118.44 v2(97.03,118.2) 97.03,117.71 98.17,116.56 98.17,115.51 95.98,113.32 95.89,113.32
DDR_XDP_SMBCLK: length 192.2
  IN1 w0.066: v10(41.71,124.58) 41.78,124.65 41.78,124.96 42.1,125.27 43.12,125.27 v8(43.51,125.67) 43.51,125.57 43.64,125.44 43.82,125.44 44.41,126.04 48.22,126.04 48.28,126.1 49.17,126.1 49.29,125.98 53.5,125.98 54.17,126.66 55.85,126.66 55.93,126.58 57.1,126.58 v8(57.36,126.84)
  GND1 w0.066: v4(41.61,124.17) 41.71,124.27 v10(41.71,124.58)
  IN3 w0.066: v6(112.74,98.43) 112.65,98.33 112.65,95.58 108.57,91.5 95.01,91.5 94.12,92.39 92.2,92.39 91.6,91.8 80.65,91.8 79.14,90.29 74.58,90.29 64.77,100.1 64.77,103.26 62.18,105.85 59.77,105.85 57.97,107.65 55.57,107.65 52.45,110.78 52.45,113.48 49.07,116.85 46.41,116.85 44.18,119.08 44.18,119.16 41.79,121.55 41.79,123.98 v4(41.61,124.17)
  IN4 w0.066: v1(153.21,133.9) 153.21,133.75 153.14,133.68 152.52,133.68 148.08,129.24 148.08,123.78 147.2,122.91 147.2,114.48 149.77,111.92 149.77,99.44 146.37,96.04 129.78,96.04 129.33,96.5 114.96,96.5 114.37,97.09 113.71,97.09 113.46,96.84 113.15,96.84 112.65,97.35 112.65,98.33 v6(112.74,98.43)
DDR_XDP_SMBDAT: length 192.3
  IN1 w0.066: v10(42.06,124.58) 41.98,124.66 41.98,124.88 42.18,125.08 43.21,125.08 v8(43.51,124.78) 43.51,125.06 43.7,125.25 43.9,125.25 44.49,125.85 48.3,125.85 48.36,125.91 49.09,125.91 49.21,125.79 53.58,125.79 54.25,126.47 55.77,126.47 55.85,126.39 57.36,126.39 57.66,126.68 57.85,126.68 v8(58.01,126.84)
  GND1 w0.066: v10(42.06,124.58) 42.06,124.25 v4(42.14,124.17)
  IN3 w0.066: v6(112.36,98.43) 112.46,98.33 112.46,95.66 108.49,91.69 95.09,91.69 94.2,92.58 92.12,92.58 91.52,91.99 80.57,91.99 79.06,90.48 74.66,90.48 64.96,100.18 64.96,103.34 62.26,106.04 59.85,106.04 58.05,107.84 55.65,107.84 52.64,110.86 52.64,113.56 49.15,117.05 46.49,117.05 44.38,119.16 44.38,119.24 41.99,121.63 41.99,124.02 v4(42.14,124.17)
  IN4 w0.066: v1(153.21,133.3) 153.02,133.49 152.6,133.49 148.27,129.16 148.27,123.7 147.4,122.83 147.4,114.56 149.96,112 149.96,99.36 146.45,95.85 129.7,95.85 129.25,96.31 114.88,96.31 114.29,96.9 113.79,96.9 113.54,96.65 113.07,96.65 112.46,97.27 112.46,98.33 v6(112.36,98.43)
DEBUG_UART0_TX: length 56.4
  TOP w0.112: JDEG3.9 35.21,91.4 v3(34.92,91.68)
  IN1 w0.066: v10(31.88,107.15) 31.32,107.15 29.78,108.69 29.78,115.86 32.24,118.31 34.67,118.31 35.91,119.55 38.31,119.55 39.05,120.3 41.32,120.3 41.75,120.72 44.28,120.72 44.5,120.94 45.62,120.94 47.2,122.52 47.75,122.52 47.9,122.67 49.29,122.67 49.33,122.63 49.33,122.63 49.47,122.49 50.45,122.49 50.73,122.49 50.79,122.55 50.8,122.55 50.81,122.56 52.84,122.56 53.05,122.77 54.04,122.77
  IN1 w0.076: 54.04,122.77 v8(54.63,123.36)
  IN2 w0.066: v3(34.92,91.68) 33.57,91.68 33.36,91.89 33.36,99.36 32.59,100.13 32.59,101.37 32.58,101.38 32.58,106.45 v10(31.88,107.15)
DET_L#: length 182
  IN2 w0.066: v4(30.56,21.1) 30.56,19.36 v3(29.84,18.65) ; v7(74.8,42.66) 74.29,43.18 74.29,59.55 v3(74.38,59.64)
  IN3 w0.066: v4(30.56,21.1) v6(30.91,21.1) ; v7(74.8,42.66) v6(46.43,42.66)
  IN4 w0.066: v6(30.91,21.1) 30.91,20.18 31.09,20 44.7,20 46.71,22.01 46.71,40.77 46.37,41.12 46.37,42.54 46.43,42.61 v6(46.43,42.66) 46.48,42.71 46.48,45.85 41.21,51.11 36.46,51.11 35.96,51.61 35.96,55.61 36.55,56.2 36.55,57.37 36.1,57.82 36.1,58.8 35.49,59.42 35.38,59.42 32.47,62.33 32.47,66.77 31,68.24 31,71.1 26.67,75.43 26.67,76.17 26.34,76.49 26.34,76.82 25.74,77.42 25.74,77.73 21.42,82.05 21.42,89.22 20.51,90.13 20.51,94.05 19.91,94.64 19.91,96.97 18.53,98.35 17.82,98.35 17.54,98.63 17.54,103.23 17.04,103.73 17.04,104.88 17.22,105.06 17.22,106.54 18.68,108 18.68,108.65 19.75,109.72 19.75,112.34 21.55,114.14 21.69,114.14 21.76,114.21 21.76,114.22 21.91,114.37 21.93,114.37 21.93,114.38 21.93,114.58 22.29,114.94 22.44,114.94 22.72,115.23 23.57,115.23 23.81,115.46 25.58,115.46 25.92,115.13 v1(26.31,115.13)
DET_R: length 81.9
  TOP w0.112: v7(75.63,55.15) 74.55,55.15 JIO2.5 73.87,55.15 73.53,54.81 73.53,53.47 v2(73.22,53.15) ; v3(26.42,29.66) 26.42,25.08 27.3,24.2 27.3,23.18 28.07,22.42 28.07,20.97 PR121.2 PR162.1
  IN2 w0.066: v4(36.11,50.21) 36.11,49.66 35.99,49.54 35.99,46.32 34.39,44.72 34.39,41.52 32.84,39.97 32.84,37.56 32.16,36.87 32.16,35.02 29.64,32.5 27.23,32.5 26.42,31.69 v3(26.42,29.66)
  IN3 w0.066: v7(75.63,55.15) 70.07,55.15 65.12,50.21 v4(36.11,50.21)
DET_R#: length 126.4
  IN2 w0.066: v3(29.84,20.33) 29.84,20.92 v4(30.02,21.1)
  IN3 w0.066: v4(30.02,21.1) 30,21.12 v6(29.64,21.12)
  IN4 w0.066: v6(29.64,21.12) 30.99,19.78 44.71,19.78 46.88,21.94 46.88,40.84 46.55,41.17 46.55,42.17 46.71,42.33 46.71,46.63 40.82,52.52 40.82,53.21 38.59,55.44 38.59,55.77 38.08,56.29 37.87,56.29 36.27,57.89 36.27,58.87 35.55,59.59 35.45,59.59 32.64,62.4 32.64,66.84 31.16,68.31 31.16,71.17 26.84,75.5 26.84,76 27.08,76.24 27.08,76.8 26.29,77.59 26.29,77.69 21.76,82.22 21.76,86.52 22.07,86.84 22.07,88.89 22.35,89.17 22.35,89.55 23.42,90.62 25.17,90.62 25.7,91.15 25.7,91.57 26.18,92.04 26.22,92.04 27.6,93.43 27.6,102.08 27,102.68 26.87,102.68 25.71,103.84 25.71,104.13 25.86,104.28 25.86,106.31 24.97,107.2 24.97,108.42 25.82,109.27 25.82,110.51 25.58,110.76 25.5,110.76 v1(25.45,110.81)
  BOTTOM w0.076: UE3.G5 25.53,111.69 25.37,111.54 25.37,111.45 25.24,111.32 25.24,111.02 v1(25.45,110.81)
DISPOFF#: length 10
  TOP w0.112: R61.1 71.78,87.76 v2(72.06,87.48)
  TOP w0.254: R61.1 70.5,87.76 PR407.1 69.23,89.03 68.18,89.03 67.56,89.64 v7(67.56,90.06)
  BOTTOM w0.254: v7(67.56,90.06) 66.35,90.06 65.87,90.54 65.87,92.45 D39.1
DMIC_CLK12: length 152
  IN1 w0.066: v10(18.62,168.24) 21.16,165.7 26.75,165.7 31.39,161.05 36.87,161.05 37.83,162.02 37.83,164.28 v10(38.66,165.1) ; v8(110.83,176.13) 110.7,176.13 108.88,174.3 108.88,171.27 109.77,170.37 110,170.37 110.17,170.19 110.17,169.97 110.73,169.41 111.26,169.41 112.09,168.58 112.09,167.78 111.01,166.7 107.89,166.7 107.42,167.16 68.91,167.16 68.57,166.82 67.32,166.82 67.11,167.03 53.3,167.03 v10(53.21,166.94)
  IN2 w0.066: v4(23.9,140.48) 23.9,141.4 19.73,145.56 19.73,163.78 18.62,164.89 v10(18.62,168.24) 18.62,174.88 v3(18.28,175.23) ; v10(53.21,166.94) 53.2,166.96 40.52,166.96 v10(38.66,165.1)
  IN3 w0.066: v4(23.9,140.48) 24.37,140.48 v5(24.45,140.4)
  BOTTOM w0.112: TC3.1 24.24,140.6 v5(24.45,140.4) 24.85,139.99 CA41.1 24.82,139.77 24.69,139.64 RA24.1
DMIC_CLK34: length 190.4
  TOP w0.112: v3(124.76,162.54) 124.42,162.54 124.42,162.54 JWFC1.32
  IN1 w0.066: v10(19.72,164.15) 25.3,164.15 29.86,159.6 38.26,159.6 38.8,160.14 38.8,163.91 41.02,166.12 50.53,166.12 50.74,165.91 53.43,165.91 53.81,166.29 66.77,166.29 66.98,166.08 69.21,166.08 69.55,166.42 107.12,166.42 107.58,165.96 110.02,165.96 110.4,165.58 111.49,165.58 112.86,166.95 112.86,168.86 111.92,169.8 111.92,170.54 112.46,171.08 112.46,172.28 113.22,173.04 v7(113.22,175.33)
  IN2 w0.066: v3(124.76,162.54) 125.25,163.03 125.25,163.87 123.95,165.17 120.71,165.17 118.24,167.63 v4(118.24,169.8) ; v10(19.72,164.15) 19.9,163.98 19.9,145.63 24.28,141.25 24.28,139.04 22.9,137.66 v4(22.67,137.66) 15.73,137.66 3.21,125.14 v3(2.33,125.14)
  IN3 w0.066: v4(22.67,137.66) 23.1,137.23 v5(24.69,137.23) ; v7(113.22,175.33) 115.15,175.33 115.99,174.48 115.99,171.55 117.75,169.8 v4(118.24,169.8)
  BOTTOM w0.112: RA32.1 v5(24.69,137.23)
DMIC_CLK_R: length 14
  IN4 w0.066: v1(24.49,143.55) 24.35,143.4 24.35,141.47 24.68,141.14 24.68,140.93 24.53,140.77 24.45,140.77 24.07,140.4 24.07,139.52 23.22,138.66 v1(23.22,136.72)
  BOTTOM w0.112: RA24.2 25.55,138.95 25.55,138.16 RA32.2 25.6,138.09 26.11,137.58 26.11,136.79 25.98,136.67 23.27,136.67 v1(23.22,136.72) ; UA1.6 24.71,143.77 v1(24.49,143.55)
DMIC_DATA12: length 159.9
  IN1 w0.066: v3(18.28,173.88) 18.16,173.76 18.16,168.32 20.97,165.51 26.67,165.51 31.31,160.86 36.95,160.86 38.03,161.94 38.03,164.07 v10(38.65,164.69) ; v10(52.98,166.64) 53.29,166.64 53.49,166.84 67.03,166.84 67.24,166.63 68.69,166.63 69.03,166.97 107.34,166.97 107.81,166.51 111.09,166.51 112.28,167.7 112.28,168.66 111.34,169.6 110.81,169.6 110.37,170.05 110.37,170.27 110.08,170.56 109.86,170.56 109.07,171.35 109.07,174.22 109.62,174.78 v8(110.83,174.78)
  IN2 w0.066: v4(23.37,140.4) 23.37,141.65 19.54,145.48 19.54,163.59 18.28,164.85 v3(18.28,173.88) ; v10(52.98,166.64) 40.6,166.64 v10(38.65,164.69)
  IN3 w0.066: v5(25.53,140.4) 25.2,140.4 24.88,140.08 24.32,140.08 24.26,140.14 23.76,140.14 23.49,140.4 v4(23.37,140.4)
  BOTTOM w0.203: CA34.1 25.57,142.66 25.11,143.11 UA1.5
  BOTTOM w0.254: CA34.1 25.57,142.28 25.6,142.24 C74.1 25.6,141.4 25.57,141.37 RA19.2 25.57,140.44 v5(25.53,140.4)
DMIC_DATA34: length 195.7
  TOP w0.112: JWFC1.31 124.42,162.14 124.42,162.14 124.73,162.14 v3(124.76,162.12)
  IN1 w0.066: v8(3.68,125.14) 3.79,125.14 12.99,134.34 12.99,137.15 16.97,141.13 16.97,144.52 18.57,146.12 21.53,146.12 21.78,146.37 21.78,150.24 22.54,151 30.8,151 31.75,150.05 31.75,143.3 v10(31.37,142.92)
  IN2 w0.066: v4(31.18,142.56) 31.37,142.75 v10(31.37,142.92) ; v4(118.62,169.45) 118.62,167.71 120.84,165.49 124.08,165.49 125.57,164 125.57,162.9 124.79,162.12 v3(124.76,162.12)
  IN3 w0.066: v4(31.18,142.56) 30.8,142.18 30.29,142.18 30.12,142.34 v5(29.72,142.34) ; v4(118.62,169.45) 117.64,169.45 115.67,171.42 115.67,173.45 v5(115.49,173.63)
  IN4 w0.066: v5(115.49,173.63) 115.13,173.28 112.95,173.28 112.27,172.59 112.27,169.74 109.35,166.82 106.33,166.82 106.22,166.71 38.51,166.71 36.01,164.21 34.85,164.21 32.06,161.42 32.06,160.58 31.42,159.93 31.42,158.9 35.81,154.5 35.81,152.85 36.17,152.49 36.17,147.48 36.09,147.4 33.06,147.4 31.83,146.17 31.83,145.54 31.42,145.13 30.37,145.13 29.27,144.03 29.27,142.79 v5(29.72,142.34)
  BOTTOM w0.112: v5(29.72,142.34) 29.5,142.34 29.41,142.25 C73.1 28.87,142.34 CA35.1 27.13,143.41 26.68,143.41 26.31,143.78 UA1.2 ; v5(115.49,173.63) 115.18,173.63 v2(115.07,173.74)
DOCK_PWR_EN: length 108
  TOP w0.112: U7.4 69.79,54.3 69.76,54.27 R73.2 69.76,53.79 69.34,53.37 v7(69.34,51.88) 69.42,51.8 70.15,51.8 v2(70.76,52.41)
  IN3 w0.066: v6(49.85,49.72) 67.18,49.72 v7(69.34,51.88)
  IN4 w0.066: v6(49.85,49.72) 46.69,52.88 46.69,59.34 46.28,59.74 46.28,68.25 41.65,72.88 41.65,78.39 41.94,78.68 41.94,81.77 41.75,81.95 41.75,82.99 37.23,87.51 37.23,88.78 37.49,89.04 37.49,89.48 36.73,90.24 36.73,91.55 36.78,91.61 36.78,91.81 36.78,95.39 35.82,96.35 35.82,97.45 33.75,99.52 33.75,100.33 33.06,101.03 33.06,105.35 32.71,105.69 32.71,105.74 31.95,106.5 31.78,106.5 31.51,106.76 31.29,106.76 29.71,108.35 29.71,111.42 29.37,111.75 29.37,114.69 29.81,115.12 30.03,115.12 30.18,115.27 30.18,115.85 30.03,116 29.33,116 28.91,115.57 28.34,115.57 27.29,114.53 26.88,114.53 26.59,114.83 25.14,114.83 v1(25.12,114.85)
  BOTTOM w0.076: UE3.H8 24.73,114.53 25.03,114.83 25.1,114.83 v1(25.12,114.85)
EC_FPM_EN: length 138.2
  TOP w0.112: v3(125.15,89.37) 126.57,89.37 v2(127.43,88.51) 127.71,88.23 131.78,88.23 132.45,88.9 JIO1.29
  IN2 w0.066: v3(125.15,89.37) 124.92,89.6 v4(124.79,89.6)
  IN3 w0.066: v4(124.79,89.6) 124.26,90.13 v6(123.8,90.13) ; v6(39.85,86.2) 41.71,86.2 43.8,84.1 45.86,84.1 47.77,82.19 64.66,82.19 65.87,80.99 69,80.99 69.08,81.07 69.76,81.07 v6(70.04,81.36)
  IN4 w0.066: v6(70.04,81.36) 70.19,81.51 70.19,83.16 71.26,84.22 75.22,84.22 79.06,88.06 94.03,88.06 94.42,87.67 110.49,87.67 114.39,91.58 121.54,91.58 123.27,89.86 123.52,89.86 v6(123.8,90.13) ; v6(39.85,86.2) 39.85,86.19 39.68,86.02 39.32,86.02 37.92,87.42 37.92,89.88 37.57,90.24 37.57,90.48 37.23,90.82 37.23,91.35 37.29,91.4 37.29,95.46 37.29,95.59 36.33,96.55 36.33,97.82 34.91,99.23 34.91,102.92 34.34,103.5 34.34,105.2 34.5,105.37 34.5,106.41 33.63,107.28 33.14,107.28 32.35,108.06 32.35,111.22 32.3,111.27 32.3,111.81 v1(32.21,111.9)
  BOTTOM w0.076: 31.24,111.67 30.25,111.67 29.84,112.08 29.84,112.16 29.72,112.28 29.65,112.28 29.65,112.29 29.41,112.29 29.4,112.28 29.16,112.28 29.01,112.43 28.3,112.43 UE3.D6
  BOTTOM w0.112: 31.24,111.67 31.47,111.9 v1(32.21,111.9)
EC_SLP_S0IX#: length 50.3
  TOP w0.076: v7(56.26,114.19) 56.63,113.82 UCPU1.AY5
  IN1 w0.066: v10(39.98,104.92) 39.98,106.15 44,110.16 47.72,110.16 50.71,113.16 52.51,113.16 53.47,114.11 53.47,115.26 53.87,115.66 55.47,115.66 56.25,114.88 56.25,114.25 56.26,114.24 v7(56.26,114.19)
  IN2 w0.066: v4(39.98,104.51) v10(39.98,104.92)
  IN3 w0.066: v6(38.05,104.87) 38.23,105.05 39.28,105.05 39.65,104.68 39.81,104.68 v4(39.98,104.51)
  IN4 w0.066: v1(29.5,121.44) 29.78,121.16 32.39,121.16 32.66,120.9 33.81,120.9 34.46,120.25 34.46,119.17 34.46,119.17 34.46,117.42 35.23,116.65 35.23,114.75 35.77,114.21 35.77,114.02 36.76,113.03 36.76,112.91 37.16,112.51 37.16,111.1 37.04,110.97 37.04,109.13 37.52,108.65 37.52,106.36 37.63,106.24 37.65,106.24 38.18,105.72 38.18,104.99 v6(38.05,104.87)
  BOTTOM w0.112: v7(56.26,114.19) 55.67,113.6 RC163.2
EC_SLP_S0IX#_EC: length 4.4
  BOTTOM w0.076: UE3.C11 29.01,117.09 29.01,117.76 29.17,117.91 29.17,118.59 28.8,118.96 28.8,119.24 28.88,119.32
  BOTTOM w0.112: R5749.2 29.39,119.88 28.88,119.37 28.88,119.32
EDP_AUXN: length 183.3
  TOP w0.076: v3(79.56,132.53) 79.42,132.39 79.42,132.18 UCPU1.E45
  IN2 w0.081: v7(78.98,33.4) 79.03,33.4 79.36,33.74 79.36,34.18 77.93,35.61 73.31,35.61 68.34,40.57 68.34,81.4 68.18,81.57 68.18,85.85 69.38,87.05 69.38,87.38 69.89,87.89 72.27,87.89 73.49,89.1 75.52,89.1 76.54,88.09 79.36,88.09 80.82,89.55 93.95,89.55 94.39,89.1 99.16,89.1 99.87,89.82 101.96,89.82 103.99,91.85 103.99,98.95 105.11,100.07 105.11,100.7 110.86,106.45 112.91,106.45 114.37,107.91 114.37,119.79 108.71,125.45 98.17,125.45 94.9,128.72 94.25,128.72 92.93,130.04 92.02,130.04 91.52,130.54 91.52,130.98 89.66,132.84 89.66,133.42 89.37,133.7 85.56,133.7 82.73,136.53 81.14,136.53 79.5,134.88 79.5,133.16 79,132.66 79,132.3 79.18,132.12 79.29,132.12 79.56,132.39 v3(79.56,132.53)
  BOTTOM w0.112: C176.1 80.56,34.66 80.56,34.51 80.3,34.25 79.51,34.25 79.13,33.87 79.13,33.55 v7(78.98,33.4)
EDP_AUXN_CONN: length 9.3
  IN1 w0.066: v7(79.62,38.81) 79.84,39.02 80.42,39.02 82.91,41.51 84.92,41.51 85.1,41.33 v8(85.1,41.2)
  BOTTOM w0.112: v7(79.62,38.81) 79.99,39.17 80.44,39.17 80.55,39.06 80.55,38.58 80.27,38.3 80.27,38.03 80.1,37.86 R417.2
EDP_AUXN_R: length 1.6
  BOTTOM w0.112: R417.1 80.1,36.95 80.27,36.78 80.27,36.49 80.39,36.36 80.39,36.01 80.2,35.82 C176.2
EDP_AUXP: length 183.4
  TOP w0.076: v3(79.18,131.83) 79.5,131.51 UCPU1.F45
  IN2 w0.081: v7(79.57,33.4) 79.57,34.26 78.01,35.81 73.39,35.81 68.55,40.66 68.55,81.49 68.38,81.65 68.38,85.77 69.59,86.97 69.59,87.29 69.98,87.68 72.36,87.68 73.58,88.9 75.44,88.9 76.45,87.89 79.45,87.89 80.91,89.34 93.86,89.34 94.31,88.9 99.24,88.9 99.96,89.62 102.04,89.62 104.19,91.76 104.19,98.86 105.32,99.99 105.32,100.62 110.94,106.24 112.99,106.24 114.58,107.83 114.58,119.88 108.8,125.66 98.25,125.66 94.98,128.92 94.33,128.92 93.02,130.24 92.1,130.24 91.72,130.62 91.72,131.07 89.87,132.92 89.87,133.5 89.46,133.91 85.64,133.91 82.82,136.73 81.06,136.73 79.29,134.97 79.29,133.24 78.8,132.75 78.8,132.21 v3(79.18,131.83)
  BOTTOM w0.112: C175.1 80.77,34.95 80.77,34.42 80.39,34.04 79.6,34.04 79.35,33.78 79.35,33.62 v7(79.57,33.4)
EDP_AUXP_CONN: length 9.2
  IN1 w0.066: v8(85.1,41.7) 85.06,41.66 82.85,41.66 80.36,39.17 79.84,39.17 v7(79.62,39.39)
  BOTTOM w0.112: v7(79.62,39.39) 80.53,39.39 80.77,39.15 80.77,38.3 80.77,38.3 80.77,38.03 80.94,37.86 R416.2
EDP_AUXP_R: length 1.6
  BOTTOM w0.112: C175.2 80.84,35.88 80.61,36.11 80.61,36.22 80.77,36.38 80.77,36.78 80.94,36.95 R416.1
EDP_BIA_PWM: length 84.3
  TOP w0.076: v7(59.81,126.38) 59.96,126.54 UCPU1.R11
  TOP w0.112: v7(70.15,89.96) 70.67,89.43 70.99,89.43 73.13,87.3 v2(73.36,87.3) 74.07,87.3 74.8,86.56 v3(75.61,86.56)
  IN2 w0.066: v3(75.61,86.56) 75.61,85.96 75.12,85.47 v4(72.64,85.47)
  IN3 w0.066: v4(72.64,85.47) 71.61,85.47 70.99,86.1 68.31,86.1 67.2,87.21 v6(58.89,87.21) ; v7(59.81,126.38) 59.64,126.22 55.18,126.22 54.67,125.71 50.61,125.71 v6(50.6,125.69)
  IN4 w0.066: v6(58.89,87.21) 59.15,87.47 59.15,87.79 58.67,88.28 58.67,90.3 58.94,90.56 58.94,91.19 57.92,92.2 57.92,97.47 55.61,99.79 55.61,101.75 55.44,101.92 55.44,105.69 54.7,106.43 54.7,109.51 53.06,111.15 53.06,115.84 52.68,116.22 52.68,117.79 52.26,118.22 52.26,121.45 50.18,123.53 49.62,123.53 49.27,123.89 49.27,124.36 v6(50.6,125.69)
  BOTTOM w0.112: v7(70.15,89.96) 70.37,90.18 70.37,91.01 69.77,91.61 69.77,92.9 70.96,94.09 D40.3
EDP_CAB_DET#: length 166.3
  TOP w0.112: v2(46.04,100.95) 46.53,101.45 RC180.2 47.18,101.64 48.77,101.64 v8(51.21,100.33)
  IN1 w0.066: v10(48.99,91.51) 50.38,92.89 51.22,93.73 51.22,100.32 v8(51.21,100.33) 51.21,100.85 54.93,104.57 55.17,104.57 55.44,104.84 55.44,107.43 56.39,108.39 56.39,110.4 56.94,110.95 56.94,111.9 56.69,112.15 56.69,112.7 56.94,112.95 57.57,112.95 58.04,113.42 58.04,114.11 58.32,114.39 58.32,115.99 58.21,116.1 58.21,116.61 v8(57.56,117.26) ; v10(36.5,28.64) 36.8,28.34 36.8,26.58 37.44,25.95 45.87,25.95 60.8,11.02 73.31,11.02 83.49,21.2 84.84,21.2 84.84,21.2 v8(85.1,21.2)
  IN2 w0.066: v10(48.99,91.51) 49.24,91.26 49.24,83.98 48.88,83.62 48.88,54.08 37.52,42.71 37.52,39.89 36.54,38.91 36.54,36.97 37.06,36.45 37.06,32.22 36.5,31.67 v10(36.5,28.64)
EDP_COMP: length 0.8
  GND1 w0.254: v12(83.16,132.1) 83.24,132.18 v4(83.24,132.45)
  GND3 w0.254: v13(82.88,132.54) 82.97,132.45 v4(83.24,132.45)
EDP_HPD: length 142.6
  TOP w0.076: v7(59.05,128.34) 59.05,128.51 59.31,128.77 UCPU1.L10
  IN2 w0.066: v4(84.77,37.66) 85.06,37.66 v3(85.1,37.7)
  IN3 w0.066: v4(84.77,37.66) 84.11,38.32 82.87,38.32 79.67,41.52 65.82,41.52 62.53,38.23 v6(57.16,38.23)
  IN4 w0.066: v6(57.16,38.23) 57.06,38.32 57.06,50.26 56.68,50.65 56.68,70.27 56.04,70.91 56.04,82.74 54.98,83.8 54.81,83.97 54.81,89.98 54.41,90.39 54.41,93.82 53.14,95.09 53.14,95.74 52.63,96.26 52.63,100.24 52.88,100.5 52.88,101.6 52.61,101.87 52.61,102.4 52.61,104.43 50.74,106.31 50.74,115.12 50.07,115.79 50.07,116.39 48.77,117.69 48.77,120.29 47.37,121.69 47.05,121.69 46.78,121.96 46.78,123.83 47.06,124.12 47.06,127.32 47.67,127.92 48.38,128.64 52.14,128.64 52.52,129.02 52.52,129.85 54.03,131.36 56.03,131.36 v7(59.05,128.34)
  BOTTOM w0.112: RC126.2 59.05,128.89 v7(59.05,128.34) 58.33,128.34 v2(58.23,128.23)
EDP_ID0: length 125.9
  IN2 w0.066: v4(54.24,121.22) 54.01,121.45 54.01,121.63 55.12,122.75 55.12,123.86 55.24,123.98 55.25,123.98 55.68,124.42 56.04,124.42 56.04,124.42 57.07,124.42 v3(57.36,124.71)
  IN3 w0.066: v5(81.62,32.92) 80.37,31.66 67.49,31.66 66.55,30.72 62,30.72 v6(60.96,31.76) ; v4(54.24,121.22) v6(54.74,121.22)
  IN4 w0.066: v6(60.96,31.76) 59.57,33.15 59.57,37.73 60.44,38.6 60.44,44.45 59.6,45.28 59.6,52.23 59.84,52.47 59.84,74.54 60.21,74.9 60.21,78.82 60.22,78.82 60.43,79.04 60.43,79.34 60.22,79.55 60.21,79.55 60.21,87.45 59.27,88.39 59.27,90.14 59.58,90.45 59.58,91.41 58.62,92.37 58.62,97.48 56.11,99.99 56.11,102.04 55.94,102.21 55.94,105.9 55.22,106.62 55.22,110.05 55.04,110.22 55.04,111.98 v1(54.91,112.1) 54.91,112.28 53.57,113.63 53.57,116.09 53.82,116.35 53.82,119.47 54.74,120.38 v6(54.74,121.22)
  BOTTOM w0.112: v1(54.91,112.1) 55.45,112.1 55.78,112.43 56.18,112.43 56.97,113.22 RC193.1
EDP_TXN_P0: length 176.3
  IN2 w0.081: v3(80.93,133.52) 80.88,133.72 81.03,133.97 81.03,134.33 82.05,135.35 82.24,135.35 84.33,133.26 84.33,133.25 85.09,132.49 88.34,132.49 89.5,131.33 89.5,129.43 90.64,128.3 92.79,128.3 93.54,127.54 94.41,127.54 97.68,124.27 98.66,124.27 108.22,124.27 113.19,119.3 113.19,108.4 112.42,107.62 110.37,107.62 103.93,101.19 103.93,100.56 102.81,99.43 102.81,92.34 101.47,91 99.39,91 98.67,90.28 94.88,90.28 94.33,90.83 80.44,90.83 78.88,89.27 77.03,89.27 76.01,90.28 72.98,90.28 71.76,89.07 69.4,89.07 68.2,87.87 68.2,87.54 66.6,85.93 66.6,81.49 67.17,80.92 67.17,40.09 74.18,33.07 77.46,33.07 v7(77.6,32.94)
  BOTTOM w0.112: v7(77.6,32.94) 77.76,33.1 78.02,33.1 78.3,33.38 78.3,33.92 78.42,34.04 78.78,34.41 78.78,34.81 C177.1
