# Allegro board Dell Latitude 5290 2-IN-1 LA-F371P Boardview.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on IN2 (solid shape): 39.46,21.44 39.55,21.37 39.53,21.26 39.42,21.02 39.56,20.7 39.53,20.63 39.75,20.05 39.98,20.63 39.94,20.7 40.08,21.02 39.98,21.26 39.95,21.37 40.05,21.44 43.61,21.44 43.93,21.12 43.93,20.55 43.11,19.72 39.64,19.72 38.83,20.54 37.48,20.54 37.38,20.6 37.41,20.71 38.13,21.44
GND on IN2 (solid shape): outline of 105 points within 44.52,91.88 47.97,106.24
GND on IN2 (solid shape): 134.85,137.78 134.92,137.75 134.95,137.68 135.25,137.35 135.56,137.68 135.59,137.75 135.66,137.78 140.1,137.78 141.56,136.32 141.58,136.3 141.95,135.93 141.95,135.8 141.8,135.66 141.64,135.66 141.55,135.7 141.54,135.79 141.41,136.17 141.01,136.14 140.94,136.11 140.87,136.14 140.55,136.2 140.33,135.95 140.26,135.88 140.16,135.9 139.3,136.76 137.67,136.76 137.52,136.61 137.26,136.61 136.98,136.88 134.31,136.88 133.87,137.32 130.44,137.32 130.35,137.42 130.35,137.67 130.47,137.78
GND on IN2 (solid shape): outline of 136 points within 41.19,43.48 57.36,81.21
GND on IN2 (solid shape): 76.68,71.36 76.68,71.06 75.43,69.81 75.43,61.8 74.95,61.32 74.84,61.3 74.78,61.39 74.78,67.08 74.83,67.13 74.85,67.13 75,67.68 74.51,67.39 74.51,67.39 74.51,59.97 74.48,59.9 74.4,59.87 74.37,59.87 74.29,59.9 74.26,59.97 74.26,62.69 71.76,65.18 71.49,65.18 71.49,65.18 71.43,65.17 71.4,65.21 71.4,65.27 71.44,65.35 71.52,65.37 71.68,65.38 71.81,65.45 71.88,65.48 71.95,65.45 72.51,65.7 71.95,65.94 71.88,65.92 71.81,65.94 71.68,66.02 71.52,66.02 71.44,66.04 71.4,66.12 71.4,71.42 71.7,71.72 76.32,71.72
GND on IN2 (solid shape): 17.6,57.71 17.67,57.81 17.79,57.76 18.62,57.2 19.54,57.59 19.65,57.62 19.72,57.53 19.72,56.5 19.69,56.43 19.62,56.4 19.5,56.39 19.39,56.33 19.32,56.31 19.25,56.34 19.01,56.44 18.77,56.33 18.76,56.32 18.72,56.3 18.68,56.32 18.66,56.35 18.64,56.38 18.67,56.43 18.68,56.43 18.54,57.03 18.23,56.5 18.25,56.43 18.22,56.36 18.1,56.13 18.18,55.89 18.21,55.82 18.18,55.75 18.19,55.29 18.65,55.28 18.72,55.31 18.79,55.28 18.89,55.22 19,55.2 19.07,55.17 19.1,55.1 19.26,54.83 19.58,54.82 19.67,54.82 19.72,54.73 19.72,49.91 19.66,49.81 19.55,49.83 17.6,51.79
GND on IN2 (solid shape): outline of 213 points within 114.57,125.63 128.03,129.78
GND on IN2 (solid shape): 6.66,42.21 6.75,42.16 6.75,42.07 6.72,41.89 6.79,41.72 6.79,41.49 6.96,41.32 6.99,41.25 6.96,41.17 6.88,41 6.99,40.75 6.88,40.5 6.99,40.25 6.96,40.17 6.88,39.99 6.97,39.82 6.97,37.85 6.91,37.76 6.15,37.8 5.81,37.24 5.81,37.06 5.82,36.98 5.83,36.9 5.81,36.81 5.71,36.78 5.64,36.79 5.56,36.8 4.54,36.8 3.93,36.36 4.19,35.52 4.09,35.45 3.81,35.45 3.44,35.81 3.44,40.01 4.68,41.25 4.75,41.28 4.82,41.25 5.03,41.15 5.26,41.17 5.35,41.17 5.4,41.09 5.45,40.95 5.55,40.83 5.59,40.75 5.55,40.67 5.45,40.55 5.4,40.41 5.35,40.33 5.26,40.33 4.78,40.21 4.77,39.72 4.78,39.65 4.75,39.58 4.59,39.39 4.54,39.15 4.54,38.35 5.06,37.79 5.65,38.27 5.66,38.31 5.99,38.31 6.61,38.94 6.61,42.21
GND on IN2 (solid shape): 6.66,42.21 6.75,42.16 6.75,42.07 6.72,41.89 6.79,41.72 6.79,41.49 6.96,41.32 6.99,41.25 6.96,41.17 6.88,41 6.99,40.75 6.88,40.5 6.99,40.25 6.96,40.17 6.88,39.99 6.97,39.82 6.97,37.85 6.91,37.76 6.15,37.8 5.81,37.24 5.81,37.06 5.82,36.98 5.83,36.9 5.81,36.81 5.71,36.78 5.64,36.79 5.56,36.8 4.54,36.8 3.93,36.36 4.19,35.52 4.09,35.45 3.81,35.45 3.44,35.81 3.44,40.01 4.68,41.25 4.75,41.28 4.82,41.25 5.03,41.15 5.26,41.17 5.35,41.17 5.4,41.09 5.45,40.95 5.55,40.83 5.59,40.75 5.55,40.67 5.45,40.56 5.4,40.42 5.4,40.41 5.35,40.33 5.26,40.33 4.78,40.21 4.77,39.72 4.78,39.65 4.75,39.58 4.59,39.39 4.54,39.15 4.54,38.35 5.06,37.79 5.65,38.27 5.66,38.31 5.99,38.31 6.61,38.94 6.61,42.21
GND on IN2 (solid shape): 121.52,91.64 121.57,91.63 123.18,90.02 128.12,90.02 129.01,90.92 129.04,90.91 129.12,90.89 129.2,90.9 129.33,90.96 129.42,91.07 129.5,91.12 129.59,91.09 130.21,90.47 132.37,90.47 133.92,88.91 133.95,88.82 133.89,88.75 133.85,88.73 133.81,88.71 133.77,88.68 133.7,88.66 133.64,88.68 133.42,88.76 133.2,88.67 133.13,88.65 133.07,88.67 132.74,88.75 132.52,88.51 132.51,88.39 132.55,88.28 132.71,88.13 132.94,88.11 132.96,88.12 133.25,87.83 133.27,87.72 133.18,87.66 125.38,87.66 124.97,88.07 124.94,88.16 125,88.23 125.1,88.77 124.56,88.67 124.49,88.61 124.4,88.64 124.31,88.73 124.28,88.83 124.35,88.9 124.43,88.94 124.49,89.02 124.54,89.06 124.6,89.07 124.76,89.08 124.89,89.16 124.92,89.2 124.96,89.16 125.04,89.16 125.39,89.14 125.34,89.49 125.26,89.57 125.14,89.6 125.11,89.61 125.09,89.64 124.88,89.89 124.56,89.8 124.49,89.77 124.41,89.8 124.1,89.89 123.88,89.65 123.81,89.58 123.78,89.48 123.71,89.4 123.61,89.43 121.52,91.52 121.49,91.55 121.49,91.59
GND on IN2 (solid shape): outline of 260 points within 77.96,44.31 80.67,79.72
GND on IN2 (solid shape): outline of 116 points within 69.27,77.64 77.95,84.52
GND on IN2 (solid shape): outline of 151 points within 33.44,27.47 57.3,55.67
GND on IN2 (solid shape): outline of 474 points within 48.47,54.45 55.91,93.87
GND on IN2 (solid shape): outline of 513 points within 113.91,135.58 128.81,146.38
GND on IN2 (solid shape): outline of 856 points within 124.78,138.11 142.01,147.84
GND on IN2 (solid shape): outline of 1299 points within 135.06,95 159.69,132.43
GND on IN2 (solid shape): outline of 1538 points within 120,89.52 155.07,128.95
GND on IN2 (solid shape): outline of 3398 points within 15.16,26.93 45.68,130.37
GND on IN2 (solid shape): outline of 5772 points within 35.98,135.64 115.53,168.95
GND on IN2 (solid shape): outline of 16820 points within 0.25,0.25 162.65,178.25
GND on GND2 (solid shape): 9.8,19.28 10.58,18.5 10.58,16.93 9.8,16.15 9.8,15.25 1.8,15.25 1.09,15.54 0.8,16.25 0.8,20 0.78,20.18 0.74,20.35 9.8,20.35
GND on GND2 (solid shape): 3.42,51.64 8.38,51.64 8.4,51.64 9.8,51.64 9.8,46.55 2.12,46.55 2.12,46.56 0.75,46.56 0.79,46.71 0.8,46.86 0.8,47.2 0.86,47.53 1.02,47.82 1.08,47.9 1.24,48.19 1.3,48.53 1.3,50.11 1.42,50.59 1.75,50.95 1.97,51.09 1.98,51.09 2.55,51.48 2.81,51.6 3.1,51.64
GND on VCC (solid shape): 11.05,19.81 11.05,16.95 10.37,16.27 9.8,16.27 9.8,15.25 1.8,15.25 1.09,15.54 0.8,16.25 0.8,20 0.78,20.18 0.74,20.35 4.03,20.35 4.39,20.71 10.14,20.71
GND on VCC (solid shape): 3.42,51.64 8.38,51.64 8.4,51.64 9.8,51.64 9.8,46.55 9.49,46.24 3.17,46.24 3.17,46.25 0.59,46.25 0.75,46.54 0.8,46.86 0.8,47.2 0.86,47.53 1.02,47.82 1.08,47.9 1.24,48.19 1.3,48.53 1.3,50.11 1.31,50.24 1.33,50.35 1.33,50.35 1.49,50.69 1.75,50.94 2.55,51.48 2.81,51.6 3.1,51.64
GND on IN3 (solid shape): 15.75,126.29 15.75,125.03 15.53,124.81 15.11,124.81 14.75,124.46 11.62,124.46 11.36,124.72 11.36,126.34 11.53,126.51 15.54,126.51
GND on IN3 (solid shape): 51.46,130.82 51.46,129.67 51.4,129.61 51.4,129.14 51.33,129.07 49.28,129.07 49.15,129.2 49.15,130.82 49.28,130.95 51.33,130.95
GND on IN3 (solid shape): 50.57,26.52 50.57,26.32 50.54,26.29 44.29,26.29 44.2,26.35 44.22,26.46 44.34,26.57 50.51,26.57
GND on IN3 (solid shape): 24,65.19 24.02,65.08 23.93,65.02 22.69,65.02 20.99,66.72 20.98,66.76 20.97,66.79 20.97,66.89 21.06,66.94 22.25,66.94
GND on IN3 (solid shape): 8.99,18.96 9.75,18.96 10.52,18.19 10.52,16.8 9.8,16.08 9.8,15.25 1.8,15.25 1.09,15.54 0.8,16.25 0.8,20 0.78,20.18 0.74,20.35 7.6,20.35
GND on IN3 (solid shape): 41.72,78.11 41.81,78.04 41.92,78.02 41.95,78.02 49.08,70.89 49.1,70.78 49.01,70.71 48.73,70.71 42.84,76.6 42.1,76.6 41.91,76.7 41.72,76.6 36.93,76.6 36.17,77.37 36.15,77.48 36.24,77.54 40.2,77.54 40.77,78.11
GND on IN3 (solid shape): 33.91,69.58 33.91,69.22 33.89,69.16 33.82,69.12 33.52,68.89 33.68,68.54 33.68,67.79 33.62,67.69 33.51,67.72 33.05,68.18 33.03,68.18 32.97,68.24 31.15,68.24 30.22,68.24 29.99,68.47 28.5,68.47 28.26,68.7 28.25,68.74 28.23,68.78 28.23,68.85 29.25,68.85 30.52,70.12 31.67,70.12 31.68,70.13 33.37,70.13
GND on IN3 (solid shape): 160.08,134.28 160.08,117.21 150.37,107.5 150.37,105.86 149.95,105.44 148.67,105.44 148.38,105.73 148.38,106.12 158.41,116.15 158.41,127.33 158.8,127.33 158.8,127.28 158.81,127.23 158.82,127.18 158.85,127.13 158.88,127.09 158.92,127.05 158.96,127.02 159,127 159.05,126.98 159.1,126.98 159.16,126.98 159.21,126.98 159.26,127 159.3,127.02 159.35,127.05 159.38,127.09 159.41,127.13 159.44,127.18 159.45,127.23 159.46,127.28 159.46,127.33 159.45,127.38 159.44,127.43 159.41,127.48 159.38,127.52 159.35,127.56 159.3,127.59 159.26,127.61 159.21,127.63 159.16,127.64 159.1,127.64 159.05,127.63 159,127.61 158.96,127.59 158.92,127.56 158.88,127.52 158.85,127.48 158.82,127.43 158.81,127.38 158.8,127.33 158.41,127.33 158.41,133.11 159.65,134.35 160.01,134.35
GND on IN3 (solid shape): 3.42,51.64 8.38,51.64 8.4,51.64 9.8,51.64 9.8,46.55 2.84,46.55 2.84,46.54 0.75,46.54 0.79,46.7 0.8,46.86 0.8,47.2 0.86,47.53 1.02,47.82 1.08,47.9 1.24,48.19 1.3,48.53 1.3,50.12 1.3,50.19 1.31,50.27 1.32,50.27 1.46,50.65 1.75,50.94 2.55,51.48 2.81,51.6 3.1,51.64
GND on IN3 (solid shape): 10.51,116.99 10.51,116.88 10.69,116.7 10.96,116.7 11.23,116.44 11.23,115.96 11.4,115.79 13.72,115.79 13.81,115.7 13.8,115.67 13.92,115.4 14.21,115.47 18.47,115.47 18.91,115.03 18.91,112.29 18.71,112.09 17.79,112.09 15.32,114.57 15.3,114.58 10.28,114.58 10.15,114.71 10.15,116.29 10.26,116.52 10.15,116.76 10.12,116.8 10.12,116.95 10.26,117.09 10.41,117.09
GND on IN3 (solid shape): 40.16,70.14 40.16,68.76 40.04,68.63 39.53,68.63 39.46,68.7 39.46,69.74 39.58,69.86 39.58,70.11 39.45,70.23 38.33,70.23 38.21,70.12 38.21,69.89 38.26,69.85 38.26,69.15 36.73,67.63 35.56,67.63 35.25,67.94 35.25,70.13 34.21,71.16 34.21,71.45 36.14,71.45 36.88,70.71 36.88,70.15 36.84,70.07 36.75,70.06 36.46,69.77 36.86,69.7 37,69.7 37.12,69.82 37.25,69.7 37.39,69.7 37.79,69.77 37.5,70.06 37.41,70.07 37.37,70.15 37.37,70.91 36.76,71.52 36.74,71.63 36.83,71.69 38.61,71.69
GND on IN3 (solid shape): 64.95,42.53 65.05,42.46 65.03,42.35 63.37,40.69 49.83,40.69 49.75,40.73 49.73,40.82 49.74,40.92 49.7,41.02 49.71,41.1 49.69,41.18 49.7,41.27 49.78,41.32 57.25,41.32 58.19,41.32 58.31,41.43 59.87,41.43 59.91,41.47 59.93,41.47 60.13,41.83 59.72,41.74 59.71,41.7 58.2,41.7 58.08,41.59 57.23,41.59 49.33,41.59 49.15,41.68 48.96,41.59 46.99,41.59 46.93,41.65 46.97,41.68 47.03,41.9 46.86,42.08 46.86,42.4 46.99,42.53
GND on IN3 (solid shape): outline of 118 points within 131.45,144.4 134.34,148.83
GND on IN3 (solid shape): 22.75,68.65 24.92,68.65 25.11,68.85 27.73,68.85 27.81,68.8 27.82,68.71 27.81,68.65 27.82,68.58 27.81,68.49 27.72,68.45 27.64,68.45 26.91,67.72 26.81,67.69 26.74,67.77 26.37,68 26.14,67.63 26.15,67.61 26.06,67.51 23.58,67.51 22.7,68.4 20.42,68.4 20.41,68.43 19.98,68.44 20.27,68.12 20.27,68.13 22.59,68.13 23.47,67.24 26.17,67.24 26.34,67.41 26.38,67.41 26.45,67.34 26.43,67.24 26.26,67.07 23.39,67.07 22.64,67.82 19.74,67.82 19.4,67.48 18.68,67.48 18.6,67.52 18.59,67.62 18.6,67.77 18.5,67.9 18.46,67.97 18.48,68.05 19.28,68.85 22.56,68.85
GND on IN3 (solid shape): 15.26,30.31 15.26,29.54 14.45,28.74 14.45,22.8 14.07,22.42 12.44,22.42 12.09,22.77 12.05,22.78 11.93,22.84 11.86,22.96 11.86,23 11.75,23.11 11.81,23.17 11.85,23.15 12.32,23.16 12.56,23.57 12.56,24.16 12.32,24.57 11.74,24.58 11.69,24.67 11.69,25.89 11.74,25.98 12.34,25.95 12.6,26.38 12.6,26.96 12.34,27.39 11.74,27.36 11.69,27.45 11.69,28.79 11.74,28.88 12.34,28.87 12.58,29.29 12.58,29.87 12.4,30.25 12,30.34 11.91,30.37 11.88,30.45 12.06,30.66 12.31,30.53 12.34,30.47 12.87,30.47 13.59,31.18 14.38,31.18
GND on IN3 (solid shape): outline of 96 points within 41.16,106.18 60.08,126.01
GND on IN3 (solid shape): 23.02,140.72 23.11,140.66 23.11,140.56 23.1,140.26 23.36,140.09 23.38,140.09 23.46,140.01 23.43,139.97 23.35,139.81 23.35,139.63 23.33,139.55 23.25,139.51 19.31,139.51 19.07,139.75 18.5,139.75 18.5,139.17 18.97,138.7 19.04,138.7 19.17,138.57 19.24,138.57 19.29,138.54 19.27,138.48 19.17,138.38 19.17,137.61 19.93,137.61 20.14,137.82 22.27,137.82 22.34,137.79 22.37,137.71 22.44,137.45 22.69,137.35 22.71,137.35 23.02,137.04 24.55,137.04 24.57,137.03 24.92,137.23 24.57,137.42 24.55,137.41 23.18,137.41 22.97,137.62 22.97,137.67 22.97,137.71 23,137.79 23.07,137.82 24.93,137.82 25.44,137.3 25.43,137.29 25.43,136.76 25.57,136.61 25.57,135.98 25.23,135.63 24.91,135.63 24.2,136.34 18.92,136.34 18.13,137.13 18.13,137.15 17.74,137.26 17.86,136.87 17.87,136.87 19.56,135.19 19.58,135.1 19.53,135.03 19.51,135.03 19.5,135.02 11.16,135.02 11.08,135.11 10.29,135.11 9.54,135.85 9.53,135.95 9.51,136.01 9.51,136.11 9.6,136.16 11,136.16 11.76,135.4 13.21,135.4 14.87,137.06 14.87,138.19 17.4,140.72
GND on IN3 (solid shape): outline of 90 points within 49.61,26.57 72.64,31.46
GND on IN3 (solid shape): outline of 111 points within 20.92,63.12 33.21,68.03
GND on IN3 (solid shape): outline of 292 points within 124.65,135.4 142.57,140.82
GND on IN3 (solid shape): outline of 290 points within 15.31,21.38 19.55,30.19
GND on IN3 (solid shape): outline of 518 points within 121.97,139.27 142.71,148.75
GND on IN3 (solid shape): outline of 567 points within 110.58,133.08 126.36,143.98
GND on IN3 (solid shape): outline of 624 points within 18.83,22.88 33.78,29.36
GND on IN3 (solid shape): outline of 707 points within 58.12,100.17 67.6,121.17
GND on IN3 (solid shape): outline of 1421 points within 0.25,108.43 19.81,162.63
GND on IN3 (solid shape): outline of 1700 points within 31.52,145.63 125.71,167.35
GND on IN3 (solid shape): outline of 21157 points within 0.25,0.25 162.65,178.25
GND on GND3 (solid shape): 14.14,163.21 14.14,161.97 14.07,161.89 12.93,161.89 12.9,161.92 12.9,163.15 13.07,163.32 14.03,163.32
GND on GND3 (solid shape): 10.77,163.07 10.77,161.96 10.72,161.91 9.56,161.91 9.51,161.96 9.52,162.24 9.52,162.94 9.51,163 9.71,163.19 10.65,163.19
GND on GND3 (solid shape): 9.8,19.5 10.7,18.6 10.7,17.11 9.8,16.2 9.8,15.25 1.8,15.25 1.09,15.54 0.8,16.25 0.8,20 0.78,20.18 0.74,20.35 9.8,20.35
GND on GND3 (solid shape): 3.42,51.64 8.38,51.64 8.4,51.64 9.8,51.64 9.8,46.55 3.02,46.55 3.02,46.53 0.74,46.53 0.79,46.7 0.8,46.86 0.8,47.2 0.86,47.53 1.02,47.82 1.08,47.9 1.24,48.19 1.3,48.53 1.3,50.11 1.35,50.44 1.51,50.72 1.51,50.72 1.62,50.84 1.75,50.94 2.55,51.48 2.81,51.6 3.1,51.64
GND on IN4 (solid shape): 41.71,48.72 41.71,48.64 41.7,48.62 37.27,48.62 36.13,49.76 40.67,49.76
GND on IN4 (solid shape): 14.14,163.21 14.14,161.97 14.07,161.89 12.93,161.89 12.9,161.92 12.9,163.15 13.07,163.32 14.03,163.32
GND on IN4 (solid shape): 51.49,130.88 51.49,129.15 51.36,129.02 49.25,129.02 49.12,129.15 49.12,130.88 49.25,131 51.36,131
GND on IN4 (solid shape): 71.98,44.27 71.98,39.3 71.86,39.18 71.73,39.18 66.17,44.73 66.17,49.34 66.45,49.61 66.64,49.61
GND on IN4 (solid shape): 26.67,149.42 26.67,145.23 26.59,145.16 25.07,145.16 24.18,144.27 23.95,144.27 23.57,144.65 22.3,144.65 21.97,144.99 21.97,145.48 22.35,145.86 22.35,149.42 22.48,149.54 26.54,149.54
GND on IN4 (solid shape): 10.77,163.07 10.77,161.96 10.72,161.91 9.56,161.91 9.51,161.96 9.52,162.24 9.52,162.94 9.51,163 9.71,163.19 10.65,163.19
GND on IN4 (solid shape): 56.33,49.95 56.4,50.04 56.51,50.02 56.53,50 56.53,45.85 56.4,45.72 56.1,45.72 55.79,46.04 55.79,46.9 56.03,47.14 56.16,47.14 56.33,47.31
GND on IN4 (solid shape): 50.18,21.15 50.63,20.7 50.63,20.3 50.55,20.3 50.5,20.24 50.39,20.22 50.33,20.31 50.33,20.52 49.43,21.41 49.43,22.55 49.55,22.67 50.07,22.67 50.18,22.78
GND on IN4 (solid shape): 54.88,44.91 54.94,45.01 55.05,44.99 55.21,44.83 55.21,31.53 55.09,31.4 54.98,31.4 54.93,31.45 54.88,31.48 54.88,32.23 54.88,32.23
GND on IN4 (solid shape): 56.49,82.76 56.56,82.85 56.67,82.83 56.75,82.74 56.75,71.09 56.69,70.99 56.58,71.02 56.49,71.1
GND on IN4 (solid shape): 115.42,91.39 115.51,91.33 115.49,91.22 111.86,87.59 110.91,87.59 110.82,87.65 110.84,87.76 114.47,91.39
GND on IN4 (solid shape): 53.8,15.83 53.89,15.77 53.87,15.65 52.67,14.46 52.6,14.41 52.55,14.44 52.51,14.48 52.5,14.53 52.5,14.74 53.59,15.83
GND on IN4 (solid shape): 122.48,89.61 122.48,88.22 122.25,87.99 120.87,87.99 119.36,86.48 112.97,86.48 112.44,87.02 94.47,87.02 94.44,87.05 94.41,87.16 94.51,87.22 112.01,87.22 115.87,91.07 121.02,91.07
GND on IN4 (solid shape): 43.96,76.3 44.03,76.38 44.14,76.36 44.83,75.66 44.83,74.28 48.41,70.7 48.41,70.49 48.35,70.4 48.23,70.42 43.96,74.69
GND on IN4 (solid shape): 59.23,44.63 59.29,44.73 59.4,44.71 59.54,44.57 59.54,38.13 59.36,37.95 59.25,37.92 59.18,38.02 59.18,40.43 59.23,40.48
GND on IN4 (solid shape): 61.94,84.38 61.94,75.57 63.3,74.21 63.3,70.07 66.27,67.1 66.27,66.9 66.21,66.8 66.1,66.82 62.33,70.59 62.33,73.8 61.75,74.38 61.75,83.32 61.46,83.6 61.46,84.36 61.57,84.47 61.85,84.47
GND on IN4 (solid shape): 44.93,45.74 44.99,45.83 45.1,45.81 45.36,45.55 45.36,42.9 45.33,42.87 45.25,42.84 45.17,42.88 45.15,42.91 45.13,42.93 45.13,43.31 44.93,43.51
GND on IN4 (solid shape): 63.4,134.25 66.17,134.25 66.19,134.28 66.19,134.3 66.45,134.56 67.08,134.56 67.46,134.19 67.47,134.16 67.47,134.13 67.47,133.93 67.28,133.75 63.07,133.75 61.26,135.56 61.24,135.62 61.29,135.65 62,135.65
GND on IN4 (solid shape): 58.62,42.39 58.73,42.41 58.79,42.32 58.79,40.66 58.74,40.61 58.74,38.81 58.7,38.73 58.61,38.71 58.57,38.72 58.51,38.72 58.4,38.83 58.4,42.17
GND on IN4 (solid shape): 60.4,15.21 60.4,15.16 60.37,15.08 60.3,15.05 58.87,15.05 58.2,15.72 58.17,15.82 58.23,15.89 58.28,15.92 58.32,15.96 59.65,15.96
GND on IN4 (solid shape): 144.88,147.14 144.91,147.03 144.81,146.97 144.04,146.97 143,145.94 142.89,145.91 142.83,146.01 142.83,148.71 140.44,151.1 140.41,151.17 140.43,151.24 140.79,151.24
GND on IN4 (solid shape): 60.07,86.81 60.07,84.17 60.07,84.17 60.07,79.41 60.17,79.41 60.3,79.28 60.3,79.09 60.17,78.96 60.07,78.96 60.07,74.96 59.93,74.81 59.82,74.79 59.75,74.89 59.75,83.66 59.34,84.07 59.34,84.17 59.36,84.17 59.36,85.76 59.69,86.09 59.69,86.31 59.7,86.32 59.7,86.81 59.82,86.93 59.94,86.93
GND on IN4 (solid shape): 60.3,44.39 60.3,38.65 60.11,38.46 60,38.44 59.94,38.54 59.94,41.46 59.98,41.47 60.17,41.68 60.01,41.91 59.98,41.93 59.98,44.38 60.08,44.48 60.21,44.48
GND on IN4 (solid shape): 9.8,19.26 10.69,18.37 10.69,17.03 9.8,16.14 9.8,15.25 1.8,15.25 1.09,15.54 0.8,16.25 0.8,20 0.78,20.18 0.74,20.35 9.8,20.35
GND on IN4 (solid shape): 69.93,134.98 76.66,134.98 76.76,134.92 76.74,134.81 76.44,134.51 69.84,134.51 67.99,136.36 67.91,136.36 67.53,136.74 66.27,136.74 65.89,136.36 64.18,136.36 63.92,136.62 63.9,136.73 63.99,136.79 65.55,136.79 65.67,136.92 65.75,136.92 66.01,137.17 67.74,137.17
GND on IN4 (solid shape): 126.95,93.97 126.95,93.91 126.96,93.91 126.98,93.8 126.88,93.73 126.77,93.73 126.36,94.15 123.49,94.15 122.82,93.47 113.65,93.47 109.72,89.54 104.35,89.54 104.35,89.53 104.31,89.53 104.31,89.52 104.07,89.52 104.04,89.53 103.95,89.53 103.91,89.56 103.92,89.61 104.33,90.03 108.22,90.03 111.9,93.71 122.63,93.71 122.67,93.75 122.71,93.75 123.33,94.37 126.55,94.37
GND on IN4 (solid shape): 61.35,73.96 61.45,73.93 61.84,73.54 61.84,70.54 61.78,70.44 61.67,70.46 60.64,71.5 60.64,73.61 60.69,73.7 60.79,73.7 61.08,73.67 61.28,73.89
GND on IN4 (solid shape): 47.28,87.18 47.36,87.15 48,86.52 48.02,86.41 47.93,86.34 45.96,86.34 45.73,86.12 45.73,81.53 45.7,81.48 45.64,81.49 45.56,81.58 45.56,86.72 45.96,87.13 46.65,87.13 46.93,86.98 47.21,87.14
GND on IN4 (solid shape): 3.42,51.64 8.38,51.64 8.4,51.64 9.8,51.64 9.8,46.55 3.22,46.55 3.22,46.53 0.74,46.53 0.79,46.7 0.8,46.86 0.8,47.2 0.86,47.53 1.02,47.82 1.08,47.9 1.24,48.19 1.3,48.53 1.3,50.11 1.41,50.58 1.73,50.93 2.55,51.48 2.81,51.6 3.1,51.64
GND on IN4 (solid shape): 63.48,95.91 63.52,95.99 63.61,96.01 63.66,96 63.72,95.97 63.75,95.9 63.75,90.22 63.79,90.18 63.79,90.17 66.05,87.9 74.77,87.9 77.72,90.85 81.77,90.85 82.25,90.37 82.32,90.37 82.38,90.32 94.95,90.32 95.57,89.7 95.59,89.59 95.5,89.52 95.13,89.52 94.78,89.87 78.51,89.87 78.02,90.36 77.68,90.36 74.01,86.69 66.82,86.69 66.29,86.17 66.29,81.93 66.93,81.3 67.3,81.3 67.97,80.63 67.97,80.31 67.84,80.19 67.2,80.19 65.95,81.43 65.95,82.9 64.17,84.68 64.17,89.24 63.48,89.93
GND on IN4 (solid shape): 48.12,137.2 49.89,137.2 52.03,135.07 52.12,135.07 52.34,134.84 52.34,134.72 52.2,134.58 52.06,134.58 51.96,134.69 50.22,134.69 49.91,134.38 49.91,133.58 48.76,132.42 47.25,130.91 44.5,130.91 42.92,132.5 42.92,136.4 42.92,136.4 49.57,136.4 49.57,136.35 49.58,136.3 49.59,136.25 49.62,136.2 49.65,136.16 49.68,136.12 49.73,136.09 49.77,136.07 49.82,136.05 49.87,136.04 49.92,136.04 49.98,136.05 50.03,136.07 50.07,136.09 50.11,136.12 50.15,136.16 50.18,136.2 50.2,136.25 50.22,136.3 50.23,136.35 50.23,136.4 50.22,136.45 50.2,136.5 50.18,136.55 50.15,136.59 50.11,136.63 50.07,136.66 50.03,136.68 49.98,136.7 49.92,136.7 49.87,136.7 49.82,136.7 49.77,136.68 49.73,136.66 49.68,136.63 49.65,136.59 49.62,136.55 49.59,136.5 49.58,136.45 49.57,136.4 42.92,136.4 43.73,137.21 48.11,137.21
GND on IN4 (solid shape): 122.47,176.48 122.5,176.37 122.4,176.3 114.58,176.3 113.69,175.42 113.6,175.39 113.53,175.45 113.06,175.61 112.95,175.13 112.95,175.12 112.68,174.84 111.19,174.84 110.44,174.1 110.44,172.35 109.86,171.76 109.86,170.74 110.07,170.52 111.77,170.52 111.88,170.53 111.93,170.44 111.93,169.88 109.83,167.78 109.63,167.78 109.53,167.87 109.53,174.87 111.29,176.62 122.33,176.62
GND on IN4 (solid shape): 30.44,69.77 30.44,68.31 31.14,67.62 31.14,67.03 31,66.89 31.02,66.7 31.03,66.63 30.99,66.57 30.81,66.27 30.93,65.94 31.07,65.81 31.1,65.73 31.05,65.65 30.97,65.41 31.17,65.24 31.24,65.21 31.27,65.14 31.27,62.38 31.13,62.24 30.69,62.24 30.02,62.9 30.02,67.39 29.83,67.59 29.83,69.68 30.04,69.89 30.33,69.89
GND on IN4 (solid shape): 135.61,132.02 135.61,127.91 135.79,127.73 135.81,127.67 135.99,127.54 136.2,127.62 136.23,127.84 136.07,127.99 136.04,128 136.04,128.76 136.23,128.95 136.45,128.95 136.95,128.45 136.93,128.42 136.97,128.15 137.25,128.11 137.28,128.13 137.86,127.54 137.86,126.98 137.8,126.89 137.69,126.91 137.48,127.12 137.32,127.12 137.32,127.12 135.43,127.12 135.19,127.36 135.19,130.25 134.62,130.82 134.62,131.99 134.77,132.15 135.49,132.15
GND on IN4 (solid shape): 18.38,144.82 18.38,139.46 18.38,139.44 18.38,139.39 18.4,139.34 18.4,139.31 18.4,137.86 17.87,137.32 17.84,137.32 17.8,137.3 17.76,137.27 17.73,137.24 17.71,137.21 17.69,137.17 17.68,137.13 12.36,131.81 12.36,127.53 12.32,127.5 12.32,126.05 11.58,125.31 11.25,125.31 11.01,125.56 11.01,125.58 11.02,125.61 11.03,125.63 11.06,125.65 11.07,125.66 11.07,127.09 10.72,127.45 10.72,133.64 11.1,134.02 12.81,134.02 14.54,135.75 14.54,142.43 17.05,142.43 17.06,142.39 17.07,142.35 17.09,142.31 17.11,142.28 17.15,142.25 17.18,142.23 17.22,142.21 17.26,142.2 17.31,142.2 17.35,142.21 17.39,142.23 17.42,142.25 17.45,142.28 17.48,142.31 17.5,142.35 17.51,142.39 17.51,142.43 17.51,142.47 17.5,142.52 17.48,142.55 17.45,142.59 17.42,142.62 17.39,142.64 17.35,142.65 17.31,142.66 17.26,142.66 17.22,142.65 17.18,142.64 17.15,142.62 17.11,142.59 17.09,142.55 17.07,142.52 17.06,142.47 17.05,142.43 14.54,142.43 14.54,144.8 14.83,145.1 18.1,145.1
GND on IN4 (solid shape): 42.81,59.82 42.81,58.94 42.78,58.87 42.7,58.84 42.47,58.7 42.54,58.44 42.57,58.36 42.54,58.28 42.48,58 42.75,57.88 42.75,57.89 42.81,57.89 42.81,57.74 42.75,57.74 42.75,57.74 42.46,57.54 42.7,57.29 42.78,57.26 42.81,57.19 42.81,57.14 42.75,57.05 42.64,57.07 42.03,57.67 42.03,60.04 42.14,60.14 42.48,60.14
GND on IN4 (solid shape): 52.33,12.64 52.39,12.73 52.51,12.71 52.89,12.33 52.89,11.76 53.88,10.76 54.07,10.76 54.11,10.72 54.16,10.69 54.25,10.67 54.34,10.68 54.48,10.9 54.34,11.11 54.33,11.11 54.25,11.13 54.16,11.11 54.11,11.08 54.07,11.03 53.99,11.03 53.16,11.87 53.16,11.98 53.25,12 53.27,11.97 53.45,11.86 53.64,11.94 53.68,12.02 53.7,12.11 53.69,12.13 53.78,12.21 53.83,12.21 54.7,11.34 54.7,10.43 54.6,10.33 52.75,10.33 52.5,10.59 52.5,10.85 52.67,10.85 52.94,10.77 53.09,11 53.06,11.1 52.99,11.17 52.99,11.5 52.33,12.16
GND on IN4 (solid shape): 57.17,81.6 57.21,81.61 57.47,81.61 57.47,73.69 57.71,73.45 57.7,73.42 58.25,73.09 57.93,73.65 57.9,73.64 57.74,73.8 57.74,76.26 57.8,76.35 57.91,76.33 58.15,76.1 58.44,76.1 58.48,76.14 58.53,76.15 58.56,76.1 58.56,42.92 58.13,42.49 58.13,38.72 58.32,38.53 58.32,38.51 58.4,38.32 58.61,38.28 58.7,38.26 58.74,38.18 58.74,33.12 58.68,33.03 58.57,33.05 57.55,34.06 57.55,70.49 57.02,71.03 57.02,81.51 57.06,81.58 57.14,81.61
GND on IN4 (solid shape): 55.91,33.86 55.98,33.95 56.09,33.93 64.51,25.51 64.51,22.22 64.43,22.14 64.37,22.14 64.34,22.13 64.25,22.15 64.22,22.23 64.22,22.89 63.95,23.16 63.93,23.27 64.02,23.33 64.03,23.33 64.24,23.54 64.24,23.83 59.62,28.45 56.46,28.45 56.38,28.5 56.37,28.59 56.39,28.8 56.29,28.97 56.26,29.05 56.29,29.12 56.37,29.23 56.4,29.37 56.17,29.68 55.8,29.56 55.72,29.52 55.64,29.56 55.61,29.6 55.58,29.68 55.62,29.76 55.72,29.85 55.78,29.99 55.78,30.06 55.77,30.13 55.76,30.16 55.91,30.31
GND on IN4 (solid shape): outline of 108 points within 48.83,30.89 55.64,75.17
GND on IN4 (solid shape): 62.25,16.46 62.34,16.41 62.34,16.31 62.53,15.96 62.73,16.31 62.73,16.41 62.82,16.46 62.99,16.46 63.22,16.23 63.22,16.21 63.32,16 63.55,15.99 63.56,15.99 63.62,15.99 63.62,15.87 63.44,15.69 61.87,15.69 61.58,15.41 61.56,15.41 61.38,15.34 61.32,15.16 61.29,15.08 61.21,15.05 60.96,15.05 60.89,15.08 60.86,15.16 60.79,15.34 60.62,15.41 60.59,15.41 60.25,15.75 60.22,15.83 60.26,15.91 60.3,16.26 59.94,16.23 59.87,16.18 59.79,16.21 59.77,16.23 58.32,16.23 58.28,16.27 58.25,16.35 58.28,16.43 58.32,16.46
GND on IN4 (solid shape): 106.13,165.86 106.13,165.77 106.03,165.67 41.14,165.67 39.26,163.8 39.26,156.19 39.59,155.86 39.59,155.51 39.56,155.48 39.23,155.48 39.23,155.52 38.77,155.98 38.77,160.26 38.51,160.53 38.01,160.53 38.01,160.02 38.06,159.97 38.06,156.07 38,155.98 37.89,156 37.03,156.86 37.03,160.49 36.91,160.6 36.9,160.6 36.9,160.78 36.87,160.81 36.87,160.83 36.6,161.07 36.44,160.75 36.43,160.65 36.34,160.6 35.44,160.6 35.36,160.65 35.35,160.75 35.27,161.04 34.97,161 34.89,160.96 34.82,161 34.52,161.04 34.44,160.75 34.43,160.65 34.34,160.6 33.47,160.6 33.36,160.72 33.36,160.74 36,163.38 36.23,163.38 36.28,163.42 36.34,163.42 37.55,164.63 37.56,164.64 38.84,165.91 106.08,165.91
GND on IN4 (solid shape): 44.58,45.61 44.58,42.77 44.96,42.39 44.99,42.39 45.07,42.36 45.1,42.29 45.1,42 45.1,42 45.1,41.9 45.09,41.89 45.09,41.03 45.66,40.47 45.66,39.34 45.63,39.32 45.63,37.74 45.66,37.71 45.66,36.96 45.88,36.74 45.88,30.78 45.83,30.69 45.72,30.69 45.69,30.71 45.62,30.73 45.62,35.97 45.08,36.52 44.62,36.52 44.01,37.13 44.01,37.41 44.02,37.47 44.07,37.52 44.25,37.8 44.11,38.09 44.06,38.17 44.1,38.26 44.18,38.37 44.21,38.51 44.08,38.78 43.79,38.83 43.7,38.85 43.66,38.93 43.66,41.58 43.7,41.66 43.79,41.68 44.17,41.86 44.05,42.27 44.01,42.36 44.05,42.44 44.17,42.85 43.79,43.03 43.7,43.05 43.66,43.13 43.66,45.45 44.02,45.81 44.37,45.81
GND on IN4 (solid shape): outline of 150 points within 143.61,144.14 147.05,145.99
GND on IN4 (solid shape): 36.17,95.57 36.37,95.37 36.37,94.63 36.37,90.05 36.34,90.01 36.29,90.02 36.22,90.08 36.22,94.63 35.93,94.92 35.77,94.92 35.77,94.96 35.64,95.17 35.41,95.23 35.4,95.24 35.02,95.24 34.91,95.35 34.74,95.35 34.74,95.35 34.73,95.42 34.71,95.48 34.48,95.67 34.19,95.6 34.07,95.37 34.16,95.13 34.19,95.06 34.16,94.99 34.11,94.62 34.43,94.43 34.51,94.41 34.54,94.33 34.54,94 34.5,93.99 34.29,93.87 34.21,93.64 34.22,93.6 34.23,93.55 34.25,93.29 34.44,93.12 34.48,93.08 34.48,92.88 34.46,92.8 34.46,92.73 34.36,92.62 34,92.29 34.36,91.97 34.4,91.96 34.44,91.97 34.51,91.95 34.55,91.9 34.55,89.43 34.49,89.33 34.38,89.36 34.35,89.39 34.35,90.14 33.62,90.86 33.62,95.54 34.19,96.1 35.64,96.1
GND on IN4 (solid shape): 114.27,98.73 114.3,98.66 114.27,98.59 114.21,98.46 114.23,98.32 114.23,98.22 114.14,98.17 113.93,98.17 113.85,98.25 113.88,98.28 113.85,98.59 113.54,98.59 113.51,98.58 113.47,98.59 113.13,98.56 113.2,98.23 113.23,98.21 113.23,98.07 113.7,97.6 114.22,97.6 114.38,97.45 114.4,97.34 114.3,97.28 113.63,97.28 113.38,97.03 113.23,97.03 112.83,97.42 112.83,98.21 112.86,98.23 112.93,98.56 112.59,98.59 112.55,98.58 112.52,98.59 112.18,98.56 112.25,98.23 112.27,98.21 112.27,97.19 113,96.46 113.61,96.46 113.66,96.5 113.76,96.53 113.83,96.45 113.87,96.36 113.96,96.29 113.96,96.29 114.23,96.02 114.25,95.91 114.16,95.85 111.14,95.85 111.04,95.91 111.06,96.02 111.6,96.56 111.6,98.97 111.98,99.35 113.65,99.35
GND on IN4 (solid shape): outline of 173 points within 36.1,46.78 46.18,56.69
GND on IN4 (solid shape): 73.94,30.58 73.94,30.32 73.96,30.3 73.99,30.21 73.94,30.14 73.78,29.8 74.02,29.53 74.06,29.52 74.06,28.24 74.42,27.88 74.42,22.92 73.66,22.16 73.66,21.36 73.62,21.27 73.52,21.26 73.23,21.15 73.32,20.85 73.37,20.78 73.34,20.69 73.13,20.49 72.95,20.49 71.78,19.31 71.75,19.26 71.69,19.28 71.43,19.01 71.17,19.01 70.84,19.34 70.84,20.21 71.09,20.46 71.38,20.46 71.62,20.71 71.69,20.8 71.8,20.78 72.02,20.68 72.25,20.76 72.32,20.78 72.39,20.76 72.94,21.01 72.39,21.26 72.32,21.23 72.21,21.29 72.17,21.31 72.12,21.36 72.11,21.43 72.11,21.59 72.04,21.74 72.01,21.81 72.04,21.88 72.12,22.06 72.08,22.26 71.91,22.41 71.69,22.41 71.6,22.43 71.56,22.51 71.56,24.32 72.9,25.66 72.9,30.61 73.15,30.87 73.65,30.87
GND on IN4 (solid shape): outline of 269 points within 110.08,154.78 126.85,175.49
GND on IN4 (solid shape): outline of 255 points within 32.99,59.32 36.42,63.12
GND on IN4 (solid shape): outline of 263 points within 62.66,68.25 66.27,83.95
GND on IN4 (solid shape): outline of 82 points within 26.94,61.88 29.41,69.92
GND on IN4 (solid shape): outline of 274 points within 50.95,51.74 55.52,90.84
GND on IN4 (solid shape): outline of 337 points within 136.49,131.99 143.39,150.07
GND on IN4 (solid shape): outline of 330 points within 60.34,126.34 68.74,134.76
GND on IN4 (solid shape): outline of 428 points within 142.83,136.79 152.14,145.09
GND on IN4 (solid shape): outline of 616 points within 19.3,89.85 27.46,105.7
GND on IN4 (solid shape): outline of 705 points within 101.18,116.93 130.13,140.57
GND on IN4 (solid shape): outline of 817 points within 116.15,99.27 124.13,124.37
GND on IN4 (solid shape): outline of 911 points within 60.61,88.12 156.41,115.32
GND on IN4 (solid shape): outline of 968 points within 41.05,141.05 60.89,152.77
GND on IN4 (solid shape): outline of 1045 points within 31.5,11.75 54,84.95
GND on IN4 (solid shape): outline of 1068 points within 58.44,21.17 72.29,71.27
GND on IN4 (solid shape): outline of 1497 points within 148.08,109.5 159.58,137.35
GND on IN4 (solid shape): outline of 1470 points within 36.65,16.07 63.62,89.33
GND on IN4 (solid shape): outline of 2888 points within 122.3,97.34 148.24,131.48
GND on IN4 (solid shape): outline of 6126 points within 41.09,129 134.87,164.83
GND on IN4 (solid shape): outline of 13654 points within 50.7,89.42 128.32,150.96
GND on IN4 (solid shape): outline of 18603 points within 0.25,0.25 162.65,178.25
GND on BOTTOM: 70.56,101.55 71.41,101.55 71.63,101.32 71.63,98.79 71.57,98.73 70.19,98.73 70.17,98.75 70.17,101.16
GND on GND1: outline of 451 points within 0.25,0.26 162.65,178.25 ; 1 cut-out
GND on GND2: outline of 401 points within 0.25,0.26 162.64,178.25
GND on VCC: 11.2,88.51 9.81,88.99 9.01,90.24 8.57,90.93 7.79,91.21 1,91.21 0.47,91.42 0.26,91.95 0.26,95.32 0.33,95.49 0.5,95.56 7.41,95.56 7.94,95.79 8.17,96.32 8.17,103.57 11.01,103.57 11.49,103.08 11.49,88.51
GND on VCC: 65.57,100.72 62.36,103.93 62.36,118.81 87.61,118.81 88.37,119.57 91.29,119.57 94.59,122.87 103.99,122.87 105.26,124.14 109.98,124.14 109.98,102.53 99.59,92.14 95.23,92.14 94.47,92.9 80.67,92.9 78.63,90.87 75.17,90.87 65.57,100.47
GND on VCC: 8.17,108.46 8.17,109.42 7.94,109.95 7.41,110.18 0.5,110.18 0.33,110.25 0.26,110.42 0.26,114.84 0.3,114.98 0.42,115.07 0.9,115.23 1.52,115.69 1.76,116.42 1.76,117.18 1.52,117.91 0.9,118.37 0.42,118.53 0.3,118.62 0.26,118.76 0.26,130.28 0.33,130.45 0.5,130.52 3.35,130.52 3.88,130.75 4.1,131.28 4.1,134.72 3.88,135.25 3.35,135.48 0.5,135.48 0.33,135.55 0.26,135.72 0.26,136.11 0.29,136.23 0.38,136.32 0.93,136.64 1.2,136.92 1.31,137.29 1.31,140.61 1.2,140.98 0.93,141.26 0.38,141.58 0.29,141.67 0.26,141.79 0.26,150.21 0.29,150.33 0.38,150.42 0.93,150.74 1.2,151.02 1.31,151.39 1.31,154.71 1.2,155.08 0.93,155.36 0.38,155.68 0.29,155.77 0.26,155.89 0.26,156.28 0.33,156.45 0.5,156.52 3.35,156.52 3.88,156.74 4.1,157.28 4.1,160.72 3.88,161.26 3.35,161.48 0.5,161.48 0.33,161.55 0.26,161.72 0.26,162.65 0.28,162.63 4.85,162.63 5.84,161.63 5.84,157.57 8.15,155.26 12.09,155.26 12.57,154.77 12.57,108.46
GND on VCC: outline of 106 points within 0.38,137.48 162.65,178.25
GND on GND3: outline of 543 points within 0.25,0.26 162.65,178.25
GND_SIGNAL on TOP (solid shape): 78.94,80.54 78.94,78.51 79.1,78.35 79.65,78.35 79.79,78.21 79.79,77.63 79.78,77.63 79.78,77.4 79.62,77.24 79.08,77.24 78.69,76.84 78.69,76.28 78.6,76.19 77.16,76.19 77.1,76.25 77.1,77.11 77.13,77.15 77.65,77.15 78.19,77.69 78.19,80.63 78.24,80.67 78.81,80.67
VDD on TOP (solid shape): 135.48,129.8 135.48,129.16 135.83,128.82 135.83,128.21 135.76,128.14 135.13,128.14 135.06,128.21 135.06,128.74 134.65,129.16 133.48,129.16 133.35,129.29 133.35,130.05 133.48,130.18 135.11,130.18
VIN_1.0VA on TOP (solid shape): 126.73,140.73 127.6,140.73 127.68,140.65 127.68,139.17 127.61,139.11 126.77,139.11 126.11,139.77 124.65,139.77 124.59,139.83 124.59,140.59 124.65,140.65 125.09,140.65 125.35,140.91 125.35,141.48 125.41,141.54 125.92,141.54
VIN_1.0VA on BOTTOM (solid shape): 128.28,140.96 128.28,139.85 128.15,139.73 124.82,139.73 124.78,139.77 124.78,140.59 124.84,140.65 125.22,140.65 125.41,140.84 125.41,141.61 125.6,141.8 127.44,141.8
VIN_1.8VA on TOP (solid shape): 139.95,140.65 139.95,139.77 140.59,139.13 142.79,139.13 142.89,139.03 142.89,137.77 142.77,137.66 141.17,137.66 140.78,138.05 138.93,138.05 138.84,138.14 138.84,138.74 138.62,138.95 138.62,140.65 138.71,140.74 139.87,140.74
VIN_1.8VU on TOP (solid shape): 111.32,100.08 111.32,99.13 111,98.81 108.97,98.81 108.63,98.47 108.63,97.44 108.54,97.35 107.44,97.35 107.16,97.63 107.16,99.6 107.31,99.76 110.05,99.76 110.43,100.14 111.25,100.14
VIN_PRIM on TOP (solid shape): 53.98,148.31 53.98,147.4 53.87,147.3 53.38,147.3 52.96,146.88 52.96,145.1 52.9,145.04 52.2,145.04 51.5,144.34 50.69,144.34 50.62,144.41 50.62,145.55 51.75,146.69 51.75,148.34 51.84,148.43 53.86,148.43
VIN_PRIM on BOTTOM (solid shape): 52.96,146.94 52.96,145.1 52.9,145.04 51.63,145.04 51.56,145.1 51.56,146.94 51.63,147 52.9,147
VIN_VCCIO on TOP (solid shape): 127.57,130.3 127.57,129.16 127.13,128.72 127.13,126.81 127.06,126.75 126.17,126.75 125.79,127.13 124.97,127.13 124.84,127.26 124.84,128.46 126.75,130.37 127.51,130.37
VIN_VCCIO on BOTTOM (solid shape): 127.13,128.65 127.13,126.81 127.06,126.75 126.17,126.75 125.86,127.07 125.86,128.46 126.11,128.72 127.06,128.72
+BAT_TABLET on TOP (solid shape): 141.41,114.99 141.41,110.74 141.25,110.58 138.2,110.58 137.92,110.86 137.92,112.97 137,113.89 137,115.01 137.11,115.13 141.27,115.13
+BATT on TOP (solid shape): 141.41,110.24 141.41,106.94 141.12,106.65 138.14,106.65 137.92,106.86 137.92,110.2 138.06,110.34 141.31,110.34
+BATT on TOP (solid shape): 148.08,103.32 148.08,99.95 147,98.87 144.02,98.87 143.76,99.13 143.76,103.44 144.08,103.76 147.64,103.76
+BATT on IN2 (solid shape): 151.13,109.54 151.13,100.2 150.62,99.7 146.11,99.7 145.35,100.46 145.35,104.52 143.19,106.68 138.49,106.68 137.92,107.25 137.92,109.73 139.89,111.7 148.97,111.7
+BATT on VCC: 146.16,99.76 145.67,100.25 145.67,104.69 144.38,105.98 138.66,105.98 138.05,106.6 138.05,109.81 139.3,111.06 148.99,111.06 150.62,109.43 150.62,100.12 150.26,99.76
+CHG_SRC_20V on TOP (solid shape): 130.05,104.59 130.05,99.89 129.79,99.63 129.79,98.69 129.36,98.26 126.11,98.26 125.17,97.32 124.16,97.32 123.98,97.5 123.98,98.13 123.62,98.49 123.06,98.49 123.06,98.5 122.86,98.5 122.77,98.59 122.77,99.24 123.34,99.24 123.68,99.57 123.34,99.9 122.82,99.9 122.77,99.94 122.77,100.68 122.56,100.9 122.56,101.98 122.87,102.3 125.16,102.3 125.35,102.49 125.35,104.84 125.48,104.97 129.67,104.97
+CHG_SRC_20V on BOTTOM (solid shape): 125.16,102.11 125.16,101.09 125.03,100.97 122.94,100.97 122.68,101.22 122.68,102.17 122.81,102.3 124.97,102.3
+CHG_SRC_20V on BOTTOM (solid shape): 130.14,100.05 130.14,98.73 129.95,98.54 126.85,98.54 126.73,98.66 126.73,100.06 126.95,100.28 129.91,100.28
+CHG_VIN_20V on TOP (solid shape): 118.01,101.3 118.01,98.36 117.75,98.11 115.95,98.11 115.82,98.24 115.82,101.35 115.95,101.47 117.83,101.47
+CHG_VIN_20V on TOP (solid shape): 28.22,36.87 28.22,31.84 27.69,31.31 26.54,31.31 26.42,31.18 26.42,30.16 25.4,29.15 23.44,29.15 23.32,29.28 23.32,31.61 23.39,31.79 23.32,31.97 23.32,33.82 24.38,34.89 24.38,36.59 24.51,36.72 25.73,36.72 26.04,37.02 28.07,37.02
+CHG_VIN_20V on BOTTOM (solid shape): 119.76,99.13 119.76,97.49 119.68,97.4 117.84,97.4 116.85,98.4 116.85,99.97 117.04,100.16 118.73,100.16
+CHG_VIN_20V on IN2 (solid shape): outline of 176 points within 26.29,35.7 30.05,44.13
+CHG_VIN_20V on IN3 (solid shape): 118.05,100.04 118.05,97.5 117.92,97.37 116.78,97.37 116.52,97.63 116.52,100.04 116.78,100.29 117.79,100.29
+CHG_VIN_20V on IN3 (solid shape): 80.49,53.63 80.49,50.06 79.95,49.51 77.68,49.51 77.33,49.87 77.33,53.58 77.7,53.95 80.17,53.95
+CHG_VIN_20V on IN3 (solid shape): 81.09,80.65 81.09,80.03 81.46,79.65 81.46,78.55 81.31,78.4 80.23,78.4 79.7,78.93 79.7,80.64 79.83,80.76 80.98,80.76
+CHG_VIN_20V on IN3 (solid shape): outline of 108 points within 28.93,42.78 45.9,46.93
+CHG_VIN_20V on VCC: 77.32,51.75 76.96,52.11 76.96,78.06 79.76,80.86 79.76,86.57 82.15,88.97 92.68,88.97 96.11,88.08 110.09,88.08 115.32,93.3 115.32,100.16 115.55,100.4 117.75,100.4 118.05,100.1 118.05,91.8 116.2,89.96 116.2,85.82 95.49,85.82 95.17,85.84 94.86,85.92 92.78,86.61 92.16,86.76 91.51,86.82 84,86.82 82.57,86.23 81.98,84.8 81.98,82.21 82.14,81.44 82.57,80.79 85.98,77.38 85.98,72.53 84.1,71.59 83.29,70.84 82.98,69.78 82.98,51.75
+INV_PWR_SRC on TOP (solid shape): 74.42,79 74.42,77.92 74.93,77.41 76.71,77.41 76.83,77.28 76.83,75.73 77.01,75.55 79.93,75.55 80.08,75.71 81.01,75.71 81.3,76 81.3,76.26 81.45,76.4 85.17,76.4 85.31,76.27 85.31,74.86 84.82,74.37 81.69,74.37 80.64,73.32 77.6,73.32 77.5,73.22 77.5,73.22 76.83,72.56 76.83,71.95 76.58,71.69 74.42,71.69 74.2,71.92 74.2,79 74.26,79.06 74.36,79.06
+LCDVDD on BOTTOM (solid shape): 40.77,23.94 40.77,22.8 39.37,21.4 38.11,21.4 37.97,21.54 37.97,22.04 38.1,22.16 38.35,22.16 38.61,22.42 38.61,23.81 38.99,24.2 40.51,24.2
+LCDVDD on BOTTOM (solid shape): 84.96,39.69 84.96,33.57 84.81,33.41 82.79,33.41 82.67,33.54 82.67,39.68 82.93,39.94 84.71,39.94
+LCDVDD on IN1 (solid shape): 84.58,20.13 84.58,19.5 84.45,19.37 83.82,19.37 83.44,18.99 83.19,18.99 82.8,19.37 82.8,19.88 83.31,20.39 84.33,20.39
+LCDVDD on IN1 (solid shape): 42.16,22.54 43.31,22.54 43.43,22.42 43.43,21.66 43.05,21.27 42.93,21.27 42.92,21.3 42.72,21.4 42.53,21.3 42.52,21.27 41.25,21.27 41.18,21.3 41.15,21.36 41.02,21.54 40.81,21.54 40.78,21.52 39.5,22.8 39.5,23.94 39.62,24.07 40.64,24.07
+LCDVDD on IN2 (solid shape): 84.3,34.44 84.3,32.53 84.24,32.47 83.61,32.47 83.53,32.56 83.53,34.12 83.92,34.51 84.23,34.51
+LCDVDD on IN2 (solid shape): 85.98,20.27 85.98,19.69 85.79,19.5 84.2,19.5 83.95,19.75 83.95,20.07 84.28,20.4 85.85,20.4
+LCDVDD on IN3 (solid shape): 84.26,34.61 84.26,33.46 84.17,33.37 83.47,33.37 83.31,33.52 83.31,34.61 83.44,34.74 84.14,34.74
+LCDVDD on IN3 (solid shape): 84.9,39.82 84.9,39.12 84.77,38.99 83.62,38.99 83.49,39.12 83.49,39.85 83.58,39.94 84.77,39.94
+LED_AN on TOP (solid shape): 73.47,51.5 73.47,49.72 73.34,49.6 72.33,49.6 72.2,49.72 72.2,51.5 72.33,51.63 73.34,51.63
+LED_AN on TOP (solid shape): 71.25,71.57 71.97,71.57 72.01,71.53 72.01,66.98 71.64,66.61 70.48,66.61 70.36,66.74 70.36,68.77 69.09,70.04 69.09,72.07 69.22,72.2 70.61,72.2
+LED_AN on BOTTOM (solid shape): 84.45,31.17 84.45,29.72 83.95,29.21 80.48,29.21 79.92,29.77 79.92,31.44 80.03,31.55 84.07,31.55
+LED_AN on IN1 (solid shape): 85.28,30.8 85.28,29.72 85.03,29.47 83.57,29.47 83.25,29.78 83.25,30.8 83.5,31.05 85.03,31.05
+LED_AN on IN1 (solid shape): 73.22,51.88 73.22,49.4 73.09,49.28 72.58,49.28 72.45,49.4 72.45,52.01 72.58,52.14 72.96,52.14
+LED_AN on IN1 (solid shape): 71.95,67.95 71.95,66.42 71.56,66.04 71.15,66.04 70.89,66.3 70.89,66.63 71.18,66.92 71.18,68.07 71.31,68.2 71.69,68.2
+LED_AN on IN2 (solid shape): 85.15,30.86 85.15,29.59 85.03,29.47 84.58,29.47 84.39,29.66 84.39,30.8 84.58,30.99 85.03,30.99
+LED_AN on IN3 (solid shape): 84.9,30.93 84.9,29.59 84.77,29.47 84.2,29.47 84.07,29.59 84.07,30.86 84.26,31.05 84.77,31.05
+RTCVCC on BOTTOM (solid shape): 31.47,97.27 31.47,95.87 31.75,95.59 31.75,94.5 32,94.25 32,93.54 31.88,93.41 30.48,93.41 30.37,93.52 30.37,94.27 30.61,94.51 30.61,95.36 29.88,96.09 29.88,97.36 30.14,97.62 31.12,97.62
+RTCVCC on IN4 (solid shape): outline of 236 points within 62.04,114.1 64.71,118.94
+RTCVCC_EC on BOTTOM (solid shape): 44.91,107.41 44.91,106.87 44.79,106.75 43.4,106.75 43.31,106.85 43.31,107.38 43.43,107.51 44.81,107.51
+RTCVCC_EC on IN3 (solid shape): 31.52,105.22 31.52,105.14 31.7,104.96 32.02,104.96 32.18,105.12 32.18,105.32 32.64,105.78 33.53,105.78 33.6,105.71 33.6,105.29 32.75,104.44 32.25,104.44 32.13,104.31 31.43,104.31 30.81,104.94 29.64,104.94 28.96,105.62 28.96,105.94 29.06,106.03 30.71,106.03
+SD_VDD1 on BOTTOM (solid shape): 63.96,83.13 63.96,82.22 63.89,82.16 63.6,82.16 63.52,82.09 63.52,80.64 63.38,80.5 62.68,80.5 62.55,80.62 62.55,82.59 63.17,83.21 63.88,83.21
+SD_VDD1 on BOTTOM (solid shape): 69.85,36.72 69.85,36.6 69.84,36.6 69.84,36.55 69.77,36.37 69.59,36.31 69.55,36.31 69.53,36.3 69,36.3 68.86,36.17 68.86,34.87 68.81,34.82 68.71,34.82 68.66,34.87 68.66,36.61 68.85,36.8 69.76,36.8
+SD_VDD1 on BOTTOM (solid shape): 73.66,82.74 73.66,81.98 73.53,81.85 73.53,81.35 73.15,80.96 73.15,79.95 73.03,79.82 72.64,79.82 72.52,79.95 72.52,80.96 71.88,81.6 72.51,81.6 72.51,81.54 72.52,81.49 72.54,81.44 72.56,81.4 72.59,81.36 72.63,81.32 72.67,81.29 72.72,81.26 72.77,81.25 72.82,81.24 72.87,81.24 72.92,81.25 72.97,81.26 73.02,81.29 73.06,81.32 73.1,81.36 73.13,81.4 73.15,81.44 73.17,81.49 73.17,81.54 73.17,81.6 73.17,81.65 73.15,81.7 73.13,81.74 73.1,81.79 73.06,81.82 73.02,81.85 72.97,81.88 72.92,81.89 72.87,81.9 72.82,81.9 72.77,81.89 72.72,81.88 72.67,81.85 72.63,81.82 72.59,81.79 72.56,81.74 72.54,81.7 72.52,81.65 72.51,81.6 71.88,81.6 71.79,81.69 71.28,81.69 70.96,82.01 70.96,82.71 71.12,82.87 73.53,82.87
+SD_VDD1 on IN1 (solid shape): 63.31,81.6 63.31,79.55 63.2,79.43 62.38,79.43 62.3,79.52 62.3,81.62 62.41,81.74 63.17,81.74
+SD_VDD1 on IN1 (solid shape): 69.9,37.94 69.9,36.52 69.67,36.28 68.93,36.28 68.77,36.44 68.77,37.91 68.88,38.02 69.83,38.02
+SD_VDD2 on TOP (solid shape): 72.49,66.19 72.49,64.78 72.25,64.54 72.25,64.12 72.2,64.07 70.48,64.07 70.42,64.14 70.42,66.21 70.57,66.36 72.33,66.36
+SD_VDD2 on BOTTOM (solid shape): 71.01,67.27 71.01,66.64 71.22,66.42 72.17,66.42 72.48,66.12 72.48,65.47 72.35,65.34 70.99,65.34 70.36,65.98 70.36,67.31 70.5,67.45 70.83,67.45
+SD_VDD2 on IN2 (solid shape): 74.15,62.65 74.15,39.26 74.05,39.15 73.34,39.15 73.14,39.35 73.14,62.23 71.4,63.96 71.4,64.95 71.53,65.08 71.72,65.08
+SD_VDD2 on IN3 (solid shape): 74.01,40.22 74.01,39.33 73.89,39.21 72.66,39.21 72.19,38.74 72.19,35.94 71.35,35.1 69.11,35.1 68.94,35.27 68.94,36.07 68.99,36.12 70.75,36.12 71.1,36.47 71.1,39.51 72.11,40.52 73.71,40.52
+TPM_LPM on BOTTOM (solid shape): 43.21,98.91 43.21,96.86 43.1,96.75 42.88,96.75 42.7,96.57 42.7,95.46 42.63,95.39 40.95,95.39 40.89,95.44 40.89,96.38 41.38,96.86 41.38,96.86 41.79,97.27 41.79,98.07 41.64,98.22 41.64,98.8 41.73,98.89 41.73,98.89 41.84,99 43.12,99
+VREFCA on TOP (solid shape): 93.22,98.34 93.26,98.34 93.3,98.34 93.34,98.32 93.53,98.32 93.74,98.11 93.74,96.8 93.9,96.64 93.9,96.44 93.75,96.29 93.62,96.29 93.34,96.57 93.37,96.62 93.41,96.64 93.45,96.67 93.48,96.7 93.5,96.74 93.52,96.78 93.53,96.83 93.53,96.87 93.53,96.92 93.52,96.96 93.5,97.01 93.47,97.04 93.44,97.08 93.4,97.1 93.36,97.12 93.32,97.14 93.27,97.14 93.22,97.14 93.18,97.13 93.14,97.11 93.1,97.09 93.06,97.06 93.03,97.02 92.98,97.12 92.85,97.24 92.85,97.52 92.99,97.52 92.99,97.47 93,97.43 93.02,97.38 93.05,97.35 93.08,97.31 93.12,97.28 93.16,97.26 93.2,97.25 93.25,97.24 93.3,97.25 93.34,97.26 93.38,97.27 93.42,97.3 93.46,97.33 93.49,97.36 93.51,97.41 93.53,97.45 93.53,97.49 93.53,97.54 93.53,97.59 93.51,97.63 93.49,97.67 93.46,97.71 93.42,97.74 93.38,97.76 93.34,97.78 93.3,97.79 93.25,97.79 93.2,97.79 93.16,97.77 93.12,97.75 93.08,97.72 93.05,97.69 93.02,97.65 93,97.61 92.99,97.56 92.99,97.52 92.85,97.52 92.85,98.1 93.07,98.32 93.18,98.32
+VREFDQ_A on TOP (solid shape): 103.95,99.63 103.95,99.19 103.82,99.06 103.31,99.06 103.12,98.87 103.12,96.59 102.93,96.39 102.43,96.39 102.36,96.46 102.36,96.97 102.23,97.09 100.2,97.09 100.08,97.22 100.08,97.73 100.2,97.86 102.3,97.86 102.43,97.98 102.43,99.63 102.49,99.7 103.89,99.7
+VREFDQ_B on TOP (solid shape): outline of 157 points within 72.24,96.69 76.9,99.14
+VREFDQ_B on BOTTOM (solid shape): 73.22,97.9 74.45,97.9 74.48,97.92 74.49,97.92 74.52,97.96 76.66,97.96 76.82,97.79 76.82,97.41 76.62,97.21 76.56,97.19 75.92,97.19 75.89,97.2 75.84,97.21 75.79,97.2 75.76,97.19 75.42,97.19 75.19,96.97 72.64,96.97 72.55,96.88 71.97,96.88 71.95,96.9 71.95,97.57 75.57,97.57 75.57,97.53 75.59,97.48 75.61,97.44 75.63,97.4 75.67,97.37 75.71,97.34 75.75,97.32 75.79,97.31 75.84,97.31 75.89,97.31 75.93,97.32 75.97,97.34 76.01,97.37 76.05,97.4 76.07,97.44 76.1,97.48 76.11,97.53 76.11,97.57 76.11,97.62 76.1,97.66 76.09,97.71 76.06,97.75 76.03,97.78 75.99,97.81 75.95,97.83 75.91,97.85 75.86,97.86 75.82,97.86 75.77,97.85 75.73,97.83 75.69,97.81 75.65,97.78 75.62,97.75 75.6,97.71 75.58,97.66 75.57,97.62 75.57,97.57 71.95,97.57 71.95,97.7 72.07,97.83 72.07,98.5 72.61,98.5
AC_IN on IN1 (solid shape): 36.22,22.26 36.22,21.35 35.66,20.79 35.66,20.49 36.12,20.03 36.12,18.81 36.07,18.76 35.61,18.76 35.33,19.04 35.33,19.78 34.16,20.94 34.16,21.2 34.34,21.38 34.65,21.38 35.69,22.42 36.07,22.42
ANTCTRL0_L on TOP (solid shape): 113.01,167.82 113.01,166.3 112.92,166.21 111.93,166.21 111.75,166.38 111.75,167.51 111.82,167.59 112.38,167.59 112.64,167.84 112.99,167.84
ANTCTRL1_L on TOP (solid shape): 113.03,169.5 113.03,168.09 112.97,168.02 112.52,168.02 112.32,167.82 111.76,167.82 111.72,167.86 111.72,169.25 111.83,169.35 111.99,169.35 112.18,169.54 112.99,169.54
B+ on TOP (solid shape): 104.98,161.28 104.98,158.28 104.72,158.03 103.43,158.03 103.07,158.38 103.07,161.25 103.3,161.48 104.78,161.48
B+ on TOP (solid shape): 111.51,101.67 111.51,100.78 111.38,100.65 110.49,100.65 110.43,100.71 110.43,101.73 110.49,101.79 111.38,101.79
B+ on TOP (solid shape): 39.89,37.16 39.89,35.47 39.75,35.32 39.53,35.32 39.01,34.81 37.93,34.81 37.78,34.96 37.78,36.97 38.09,37.28 39.78,37.28
B+ on TOP (solid shape): 128.14,131.83 128.14,131.07 127.95,130.88 126.75,130.88 126.68,130.94 126.68,130.96 126.72,131 126.72,131.93 126.75,131.95 128.02,131.95
B+ on TOP (solid shape): 111.06,126.44 111.06,125.56 110.91,125.41 108.44,125.41 108.32,125.54 108.32,126.44 108.43,126.56 110.95,126.56
B+ on TOP (solid shape): 123.95,122.92 123.95,120.59 123.74,120.37 122.67,120.37 122.54,120.51 122.54,121.75 122.2,122.09 122.2,122.89 122.34,123.03 123.84,123.03
B+ on TOP (solid shape): 125.12,149.08 125.12,147.56 124.99,147.44 124.9,147.45 124.82,147.44 124.19,147.44 123.9,147.15 123.14,147.15 123.05,147.23 123.05,149.08 123.25,149.28 124.92,149.28
B+ on TOP (solid shape): 143.07,137.23 143.07,135.88 142.76,135.57 140.51,135.57 140.42,135.66 140.42,135.97 140.59,136.13 140.6,136.13 140.98,136.51 141.77,136.51 141.88,136.63 141.88,137.26 141.97,137.35 142.94,137.35
B+ on TOP (solid shape): 145.16,122.11 145.67,122.11 145.8,121.99 145.8,120.4 145.54,120.14 140.65,120.14 140.46,119.95 140.46,119.39 139.93,119.39 139.6,119.06 139.93,118.73 140.46,118.73 140.46,118.24 140.4,118.18 137.29,118.18 137.1,117.98 137.1,116.14 136.91,115.95 132.78,115.95 132.46,116.27 132.46,121.86 133.1,122.49 144.78,122.49
B+ on BOTTOM (solid shape): 104.68,162.85 104.68,158.25 104.57,158.14 100.89,158.14 99.33,159.7 99.33,162.91 99.41,163 104.54,163
B+ on BOTTOM (solid shape): 128.29,138.93 128.29,136.29 128.15,136.15 126.81,136.15 126.68,136.27 126.68,138.91 126.76,138.99 128.23,138.99
B+ on BOTTOM (solid shape): 126.03,90.18 126.03,88.3 125.93,88.2 123.95,88.2 123.72,88.43 123.72,89.07 123.8,89.14 124.36,89.14 124.61,89.4 124.61,90.03 124.84,90.26 125.96,90.26
B+ on BOTTOM (solid shape): 145.22,122.05 145.67,122.05 145.73,121.99 145.73,120.4 145.35,120.02 139.76,120.02 139.32,120.46 139.32,122.24 139.57,122.49 144.78,122.49
B+ on IN1 (solid shape): outline of 302 points within 38.02,30.18 49.4,37.63
B+ on GND1 (solid shape): 83.34,78.82 83.34,77.27 83.24,77.17 82.43,77.17 82.3,77.29 82.3,78.83 82.45,78.98 83.18,78.98
B+ on IN2 (solid shape): 52.39,33.15 52.39,32.39 49.72,29.72 48.32,29.72 47.69,30.35 47.69,31.56 50.16,34.04 51.5,34.04
B+ on IN2 (solid shape): 111.95,101.41 111.95,101.09 111.63,100.78 110.81,100.78 110.68,100.9 110.68,101.54 110.87,101.73 111.63,101.73
B+ on IN2 (solid shape): 83.21,78.9 83.21,78.21 83.07,78.07 82.08,78.07 82.08,78.06 81.54,78.06 81.49,78.12 81.49,78.94 81.58,79.03 83.08,79.03
B+ on IN2 (solid shape): 63.72,62 63.72,45.04 62.31,43.63 61.14,43.63 60.99,43.78 61.34,44.13 61.34,45.02 61.59,45.28 61.59,61.94 61.98,62.32 63.4,62.32
B+ on IN3 (solid shape): 125.27,88.61 125.27,88.15 125.04,87.92 123.55,87.92 123.44,88.03 123.44,88.36 123.85,88.76 125.12,88.76
B+ on IN3 (solid shape): 84.61,78.47 84.61,76.85 84.15,76.39 82.93,76.39 81.66,77.66 81.66,79.9 82.04,80.28 82.8,80.28
B+ on IN3 (solid shape): 112.98,126.28 112.98,125.81 112.17,125 111.89,125 111.46,125.44 110.09,125.44 109.98,125.54 109.98,126.77 110.24,127.02 112.23,127.02
B+ on IN3 (solid shape): 116.65,102.24 119.42,102.24 119.72,101.93 119.72,94.26 118.68,93.22 118.62,93.22 118.28,93.56 118.28,100.33 117.77,100.83 117.16,100.83 117.16,100.84 111.12,100.84 111,100.97 111,101.86 111.38,102.24 113.92,102.24 114.68,103 115.89,103
B+ on IN3 (solid shape): 77.7,62.27 79.2,62.27 79.38,62.22 79.55,62.27 82.4,62.27 82.78,61.89 82.78,58.08 82.42,57.72 77.39,57.72 76.05,59.07 75.79,59.07 75.69,59.08 75.6,59.07 62.53,59.07 61.8,59.81 61.8,62.17 62.19,62.56 77.41,62.56
