# Allegro board Dell Latitude 5290 2-IN-1 LA-F371P Boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_DDI2_P0: length 146.7
  TOP w0.076: UCPU1.D50 82.25,132.9 82.04,132.9 81.88,132.74 81.88,132.56 v3(81.92,132.53)
  IN2 w0.081: v7(43.87,42.71) 43.87,42.51 43.74,42.38 43.59,42.38 43.38,42.59 43.38,43.06 43.65,43.33 46.05,43.33 46.38,43.65 46.38,43.93 46.11,44.2 46.11,44.31 46.34,44.54 46.46,44.54 46.72,44.28 47.01,44.28 47.36,44.63 47.36,44.91 47.09,45.18 47.09,45.29 47.32,45.52 47.43,45.52 47.7,45.26 47.98,45.26 48.33,45.61 48.33,45.89 48.07,46.16 48.07,46.27 48.3,46.5 48.41,46.5 48.68,46.23 48.96,46.23 54.49,51.76 54.49,76.64 58.38,80.53 58.38,87.92 56.46,89.84 56.46,92.76 55.58,93.64 55.58,94.45 53,97.02 52.78,97.25 52.78,105.99 52.45,106.32 51.88,106.89 51.88,110.86 52.22,111.2 52.22,116.9 56.98,121.66 57.58,121.66 59.77,123.85 59.77,125.6 59.96,125.79 65.4,125.79 66.22,126.61 67.6,126.61 68.82,127.83 77.23,127.83 79.03,129.63 79.03,130.04 79.88,130.9 79.88,131.26 80.71,132.08 81.03,132.08 81.73,132.78 81.84,132.78 81.92,132.7 v3(81.92,132.53)
  BOTTOM w0.112: CV24.1 26.69,42.63 27.2,42.63 27.22,42.65 28.02,42.65 28.51,42.15 v11(31.56,42.15) 34.19,42.15 35.93,40.41 40.98,40.41 42.88,42.31 43.61,42.31 43.87,42.56 v7(43.87,42.71)
PCH_DDI2_P1: length 147.6
  IN2 w0.081: v3(83.41,132.87) 83.3,132.87 83.23,132.94 83.23,133.12 83.33,133.22 83.49,133.22 83.74,132.98 83.74,132.35 83.35,131.97 82.85,131.97 82.26,131.38 82.26,130.47 82.07,130.29 82.07,129.46 81.65,129.04 81.65,128.27 80.16,126.79 80.16,124.72 79.73,124.28 67.8,124.28 66.4,122.88 62.2,122.88 61,121.68 59.92,121.68 56.77,118.53 56.77,117.26 56.53,117.03 56.53,116.7 55.82,115.99 55.82,115.64 54.88,114.69 54.88,112.47 53.98,111.58 53.98,110.44 53.44,109.9 53.44,107.54 54.34,106.64 54.34,97.89 57.14,95.1 57.14,94.29 58.09,93.34 58.09,90.61 59.95,88.75 59.95,79.89 56.86,76.79 56.86,50.57 44.5,38.22 44.18,38.22 v7(43.88,38.51)
  BOTTOM w0.112: CV26.1 26.66,41.38 28.24,41.38 28.26,41.4 28.81,41.4 28.83,41.38 v11(30.29,41.38) 33.61,41.38 35.36,39.63 41.23,39.63 42.67,38.19 43.56,38.19 v7(43.88,38.51)
PCH_DDI2_P2: length 147.5
  IN2 w0.081: v7(39.75,38.14) 39.75,38.19 39.95,38.39 40.29,38.39 40.54,38.64 40.54,40.74 40.62,40.82 41.2,40.82 41.4,41.02 41.4,41.51 41.2,41.71 40.62,41.71 40.54,41.8 40.54,42.2 53.9,55.56 53.9,76.89 57.79,80.78 57.79,87.68 55.87,89.6 55.87,92.51 54.99,93.4 54.99,94.2 52.76,96.43 52.19,97 52.19,105.74 51.29,106.65 51.18,106.75 51.18,111 51.29,111.11 51.63,111.45 51.63,117.14 52.34,117.85 56.74,122.25 57.32,122.25 59.13,124.06 59.13,126.3 59.64,126.81 59.94,126.81 60.82,127.68 67.84,127.68 68.69,128.54 77.08,128.54 78.35,129.81 78.35,130.29 79.87,131.81 79.87,132.08 80.46,132.67 80.79,132.67 81.79,133.67 81.79,134.22 82.13,134.56 82.22,134.56 82.42,134.36 82.42,134.24 82.36,134.17 v3(82.28,134.17)
  BOTTOM w0.112: CV30.1 26.66,40.11 27.71,40.11 27.73,40.13 28.28,40.13 28.3,40.11 33.26,40.11 35.23,38.14 37.79,38.14 38.32,37.62 39.97,37.62 40.27,37.92 40.27,38.15 40.04,38.38 39.94,38.38 39.75,38.19 v7(39.75,38.14)
PCH_DDI2_P3: length 148
  IN2 w0.081: v3(82.85,133.85) 82.67,133.67 82.5,133.67 82.3,133.47 82.3,132.37 81.67,131.73 81.67,130.72 81.13,130.18 80.64,130.18 80.32,129.86 80.32,128.46 79.9,128.04 79.61,128.04 79.3,127.72 79.3,126.34 78.52,125.55 68.2,125.55 67.75,125.1 67.21,125.1 65.65,123.54 62.61,123.54 62.58,123.58 61.42,123.58 60.16,122.32 59.67,122.32 58.04,120.69 57.73,120.69 55.63,118.59 55.63,117.19 54.25,115.82 54.25,112.69 53.19,111.63 53.19,110.61 52.85,110.27 52.85,107.3 53.75,106.39 53.75,97.65 56.55,94.85 56.55,94.05 57.43,93.16 57.43,90.43 59.36,88.51 59.36,80.13 55.49,76.26 55.49,51.17 42.6,38.28 42.6,36.97 40.3,34.67 39.86,34.67 v7(39.64,34.89)
  BOTTOM w0.112: v7(39.64,34.89) 39.45,34.71 37.26,34.71 33.29,38.67 v11(29.49,38.67) 28.36,38.67 28.34,38.69 27.79,38.69 27.77,38.67 27.44,38.67 26.98,38.21 26.67,38.21 CV34.1
PCH_DP1_HPD_UT2: length 4.9
  IN4 w0.066: v1(57.63,20.1) 58.82,21.29 58.82,23.97 v1(58.42,24.37)
PCH_DP1_HPD_UV2: length 6.1
  BOTTOM w0.112: UV2.32 17.52,24.85 17.26,24.59 v2(17.04,24.59) 16.61,24.16 RV39.2
PCH_DP2_HPD_UT1: length 5.3
  IN3 w0.066: v5(42.34,61.79) 40.79,63.33 v5(37.69,63.33)
PCH_DPWROK: length 10.1
  IN4 w0.066: v1(29.25,122.39) 28.65,121.79 28.65,119.99 28.16,119.5 27.14,119.5 v1(27.04,119.61)
  BOTTOM w0.076: 27.04,119.32 26.78,119.06 26.78,117.35 26.62,117.19 26.62,116.22 26.77,116.07 26.77,114.84 UE3.F8
  BOTTOM w0.112: 27.04,119.32 v1(27.04,119.61)
PCH_DPWROK_P: length 138.5
  TOP w0.076: UCPU1.BB20 64.95,111.86 64.85,111.76 64.85,110.43
  TOP w0.112: v8(65.04,107.06) RC78.1 CC16.1 65.2,109.01 v2(65.2,109.79) 64.85,110.15 64.85,110.43
  IN1 w0.066: v8(65.04,107.06) 65.04,106.04 64.91,105.91 64.91,104.03 64.47,103.59 64.47,97.33 57.6,90.46 52.85,90.46 47.6,85.22 47.6,83.58 47.34,83.32 47.34,81.6 42.03,76.29 32.85,76.29 31.56,75 23.59,75 v7(23.38,75.2)
  IN3 w0.066: v5(29.04,119.06) 28.93,118.95 25.16,118.95 24.57,119.53 24.17,119.53 23.77,119.93 21.11,119.93 20.07,118.89 18.63,118.89 17.69,117.95 16.69,117.95 16.03,117.29 12.45,117.29 v6(12.14,117.59)
  IN4 w0.066: v7(23.38,75.2) 16.35,82.23 16.35,90.74 16.1,90.99 16.1,91.64 12.54,95.2 12.54,104.34 12.13,104.75 12.13,109.39 11.93,109.58 11.93,110.42 11.78,110.57 11.78,115.94 12.14,116.31 v6(12.14,117.59)
  BOTTOM w0.076: 29.39,119.32 29.13,119.06 v5(29.04,119.06)
  BOTTOM w0.112: 29.39,119.32 29.82,119.75 29.82,121.87 29.69,122 29.69,122.89 29.29,123.3 RE248.1
PCH_ENVDD: length 152.9
  TOP w0.076: UCPU1.U13 60.96,126.08 v7(60.96,126.37)
  TOP w0.112: D60.2 39,23.58 38.23,22.8 37.34,22.8 v3(36.83,23.31)
  IN2 w0.066: v4(36.5,23.64) v3(36.83,23.31)
  IN3 w0.066: v4(36.5,23.64) 38.32,25.47 40.98,25.47 41.29,25.77 51.24,25.77 51.89,26.42 53.03,26.42 53.86,27.24 63.88,27.24 v6(64.36,27.73) ; v6(49.47,126.56) 49.8,126.22 50.9,126.22 51.08,126.04 54.53,126.04 55.04,126.55 59.22,126.55 59.59,126.92 60.41,126.92 v7(60.96,126.37)
  IN4 w0.066: v6(64.36,27.73) 64.22,27.73 59.05,32.9 59.05,40.49 59.09,40.53 59.09,83.23 57.66,84.67 57.66,88.75 57.65,88.75 57.42,88.98 57.42,89.2 57.68,89.46 57.68,91.49 57.25,91.92 57.25,97.19 54.94,99.51 54.94,100.76 54.94,101.14 54.94,101.14 54.94,101.47 54.67,101.74 54.67,105.17 53.14,106.7 53.14,108.73 52.86,109.01 52.86,110.05 52.32,110.58 52.32,115.63 52.01,115.94 52.01,116.75 51.37,117.39 51.37,117.53 51.37,118.64 51.19,118.82 51.19,121.01 49.83,122.37 49.41,122.37 49.03,122.75 49.03,123.41 48.34,124.1 48.34,125.42 48.59,125.67 48.88,125.67 49.05,125.85 49.05,126.14 v6(49.47,126.56)
PCH_JTAG_TCLK: length 76.8
  TOP w0.076: UCPU1.B56 86.1,134.38 86.1,134.6 86.14,134.68 86.14,134.99 85.93,135.2 85.93,135.54 v3(85.66,135.81)
  TOP w0.112: v2(84.15,139.16) 84.15,139.09 85.09,138.15 RC17.2 85.09,137.38 85.17,137.31 85.17,136.3 v3(85.66,135.81)
  IN2 w0.066: v3(85.66,135.81) 86.16,136.32 86.16,136.57 86.42,136.83 96.84,136.83 98.03,138.01 113.05,138.01 116.73,134.33 124.78,134.33 124.97,134.14 130.14,134.14 130.61,134.62 133.11,134.62 133.79,133.95 146.57,133.95 146.65,134.02 151.22,134.02 151.7,134.5 v4(152.62,134.5)
  IN3 w0.066: v5(153.21,134.5) v4(152.62,134.5)
PCH_PCIE_WAKE#: length 71.6
  TOP w0.112: RC90.2 63.01,101.23 v3(62.34,101.91) 62.15,102.09 62.15,105.44 62.29,105.58 62.29,109.52 62.93,110.16 v2(62.93,110.62) 62.93,111 62.53,111.4 UCPU1.BB15
  IN2 w0.066: v3(62.34,101.91) 62.34,101.09 62.15,100.9 61.39,100.9 60.66,100.17 60.66,98.62 61.09,98.19 61.09,95.85 61.42,95.52 v4(61.52,95.52)
  IN3 w0.066: v4(61.52,95.52) 61.33,95.71 61,95.71 58.42,98.29 55.66,98.29 53.33,100.62 52.83,100.62 52.62,100.41 52.32,100.41 49.75,102.98 47.87,102.98 45.65,105.2 42.93,105.2 41.81,106.31 41.81,106.85 40.96,107.7 39.31,107.7 35.08,111.93 32.19,111.93 29.95,109.7 29.95,109.42 29.04,108.52 28.03,108.52 27.77,108.78 26.28,108.78 26.16,108.9 25.86,108.9 25.13,109.62 23.74,109.62 v5(23.56,109.44)
  BOTTOM w0.076: v5(23.56,109.44) 23.26,109.14 22.88,109.14 22.71,108.98 22.5,108.98 UE3.L1 22.71,108.8 22.96,108.55 22.96,107.43 22.35,106.82 RE55.1
PCH_PLTRST#: length 22.3
  TOP w0.076: UCPU1.AN10 59.45,117.91 59.82,117.54 v7(59.85,117.54)
  IN3 w0.066: v5(46.74,121.29) 49.6,121.29 50.71,120.18 51.27,120.18 51.27,120.18 55.56,120.18 55.67,120.07 56.65,120.07 58.21,118.52 59.08,118.52 59.29,118.3 59.29,118.28 59.85,117.72 v7(59.85,117.54)
  BOTTOM w0.112: 46.74,119.95 v5(46.74,121.29) 46.55,121.29 46.39,121.13 46.39,120.81 46.18,120.6 UC4.1 ; 46.74,119.95 46.74,118.48 46.5,118.24 RC150.2 RC154.2 ; 46.74,119.95 UC4.2
PCH_PLTRST#_EC: length 13.5
  IN4 w0.066: v1(19.06,104.85) 19.37,104.85 19.94,105.42 19.94,107.04 20.91,108.01 20.91,108.32 21.03,108.45 21.58,108.45 21.81,108.22 22.94,108.22 23.06,108.35 v1(23.06,108.8)
  BOTTOM w0.076: v1(23.06,108.8) UE3.K1
  BOTTOM w0.112: v1(19.06,104.85) 17.81,103.6 17.81,102.06 17.35,101.6 RE183.1 16.62,100.34 UE5.4
PCH_POPIRCOMP: length 2.2
  TOP w0.254: UCPU1.AU16 62.98,115.31 62.71,115.05 v7(62.59,115.05)
  BOTTOM w0.508: v7(62.59,115.05) 62.74,114.9 RC167.1
PCH_PWR_EN: length 58.9
  IN3 w0.066: v6(52.45,100.67) 49.98,103.15 47.94,103.15 45.71,105.37 43.07,105.37 42.03,106.42 42.03,106.87 39.48,109.42 38.53,109.42 35.51,112.44 31.81,112.44 28.92,109.55 28.35,109.55 28.25,109.46 27.07,109.46 26.96,109.57 26.14,109.57 25.41,110.3 23.04,110.3 22.07,111.26 21.4,111.26 21.3,111.17 20.85,111.17 19.91,112.1 19.91,113.43 20.89,114.4 v5(21.53,114.4)
  IN4 w0.066: v1(54.32,89.33) 53.66,89.99 53.66,90.57 53.46,90.77 53.46,93.11 52.26,94.31 52.26,100.48 v6(52.45,100.67)
  BOTTOM w0.112: R148.1 55.75,87.9 R146.2 ; R148.1 54.86,89.37 v2(55.3,89.8) ; R148.1 v1(54.32,89.33)
PCH_PWR_EN_R: length 2.4
  BOTTOM w0.112: R148.2 R147.2 52.95,87.87 52.91,87.84 U21.3
PCH_PWROK: length 87.6
  TOP w0.076: 63.92,110.43 63.92,111 63.59,111.33 v3(63.59,111.79) 63.69,111.89 64.01,111.89 64.24,112.12 64.49,112.12 64.95,112.58 UCPU1.BA20
  TOP w0.112: v2(63.92,109.78) 63.92,110.43
  IN2 w0.066: v3(63.59,111.79) 63.21,111.79 v4(63.06,111.63)
  IN3 w0.066: v4(63.06,111.63) 62.88,111.63 v5(62.74,111.77) 62.55,111.96 60,111.96 59.09,112.87 56.58,112.87 54.49,114.96 54.49,116.99 53.32,118.16 49.8,118.16 49.55,118.42 47.19,118.42 47.19,118.41 47.05,118.41 46.91,118.41 46.78,118.41 46.77,118.42 46.47,118.42 45.33,119.56 45.33,119.63 43.23,121.73 43.23,121.88 43.23,121.96 43.23,122.24 43.23,122.38 43.23,126.44 43.23,126.65 43.23,126.72 43.23,126.72 43.23,126.92 42.55,127.6 38.61,127.6 v6(38.56,127.55)
  IN4 w0.066: v1(59.97,147.73) 59.16,148.54 59.16,149.62 56.19,152.58 54.49,152.58 53.78,153.29 53.56,153.29 43.91,153.29 42.61,151.99 42.61,148.83 41.47,147.69 41.47,143.98 38.74,141.26 38.74,135.02 38.98,134.78 38.98,132.46 38.18,131.66 38.18,128.85 38.45,128.58 38.45,128.44 38.45,127.66 v6(38.56,127.55)
PCH_RSMRST#: length 5.1
  BOTTOM w0.076: UE3.M5 21.02,112.51 20.45,112.51 20.36,112.6 20.03,112.6 19.98,112.55 19.82,112.55 19.69,112.41
  BOTTOM w0.112: 19.69,112.41 19.06,112.41 18.77,112.7 17.01,112.7 RE245.2
PCH_RSMRST#_R: length 290.6
  IN1 w0.066: v8(63.72,113.5) 64.17,113.05 64.17,112.67 64.12,112.63 64.12,112.16 64.39,111.9 64.39,108.22 v8(64.12,107.95) 64.12,107.56 64.46,107.22 64.46,104.04 64.15,103.72 64.15,97.46 57.38,90.69 52.67,90.69 47.42,85.44 47.42,83.68 47.14,83.4 47.14,81.85 41.9,76.61 32.54,76.61 v7(31.94,76.01)
  IN3 w0.066: v5(16.26,112.59) 16.26,111.96 16.7,111.52 17.02,111.52 17.97,110.57 19.94,110.57 21.17,109.34 22.24,109.34 22.74,108.84 24.04,108.84 24.29,108.58 25.13,108.58 25.54,108.18 25.84,108.18 25.92,108.09 27.35,108.09 v6(27.42,108.02) ; v6(77.72,85.94) 74.04,85.94 72.6,87.39 68.85,87.39 67.08,89.16 64.57,89.16 64.38,89.35 58.67,89.35 57.42,90.6 57.42,91.2 56.22,92.4 50.96,92.4 49.26,94.1 46.28,94.1 45.91,94.1 41.47,98.54 39.02,98.54 38.42,99.14 32.45,99.14 v6(31.98,98.67)
  IN4 w0.066: v1(149.28,127.83) 149.05,127.6 149.05,120.25 148.67,119.87 148.67,117.14 156.6,109.21 156.6,96.53 150.75,90.68 150.75,89.83 148.91,87.99 128.85,87.99 127.43,89.41 127.43,89.6 126.64,90.39 124.43,90.39 123.72,89.68 123.16,89.68 121.44,91.4 115.94,91.4 111.94,87.4 94.23,87.4 93.89,87.74 79.55,87.74 78.3,86.49 78.27,86.49 v6(77.72,85.94) ; v6(27.42,108.02) 27.29,107.88 27.29,105.63 27.59,105.33 28.04,105.33 29.82,103.55 29.82,103.01 30.02,102.8 30.02,102.2 30.89,101.33 30.89,100.81 31.69,100.01 31.69,98.96 v6(31.98,98.67) 31.98,97.34 31.05,96.41 31.05,91.85 29.39,90.18 27.76,90.18 25.44,87.86 25.44,85.14 27.15,83.42 27.15,77.99 29.13,76.01 v7(31.94,76.01)
  BOTTOM w0.112: RC189.2 149.26,127.84 v1(149.28,127.83)
PCH_RTCX1: length 22.5
  TOP w0.076: UCPU1.AM18 63.86,118.56 63.42,118.12 63.42,114 63.63,113.79 63.94,113.79 64.1,113.64 v3(64.1,113.54)
  TOP w0.112: YC2.1 58.72,102.14 CC23.1 58.8,103.77 58.8,104.51 v3(58.72,104.59) 58.72,104.61 58.93,104.81 v2(58.93,106.52)
  IN2 w0.066: v3(64.1,113.54) 64.1,113.43 64.48,113.05 64.48,112.03 63.71,111.27 62.66,111.27 60.66,109.27 60.66,108.21 59.43,106.98 59.43,105.72 59.05,105.35 59.05,104.92 v3(58.72,104.59)
PCH_RTCX2: length 20.2
  TOP w0.076: v3(64.39,113.86) 64.07,114.17 64.07,114.37 63.63,114.81 63.63,118.11 63.75,118.24 64.55,118.24 UCPU1.AM20
  TOP w0.112: v2(59.78,105.56) 59.64,105.42 v3(59.64,104.59) RC87.1
  IN2 w0.066: v3(59.64,104.59) 59.64,105.18 59.95,105.5 59.95,106.87 61.14,108.06 61.14,109.07 62.83,110.76 63.87,110.76 64.93,111.82 64.93,113.32 v3(64.39,113.86)
PCH_RTCX2_R: length 2.6
  TOP w0.112: YC2.2 61.32,103.6 CC24.1 RC87.2
PCH_SMB_ALERT#: length 8.6
  TOP w0.076: 53.34,125.92 53.47,125.92 53.91,126.37 58.83,126.37 UCPU1.R10
  TOP w0.112: RC49.1 51.61,125.46 51.74,125.59 53.01,125.59 53.34,125.92
PCH_SPI_CLK: length 27.3
  TOP w0.076: 52.45,112.8 53.87,114.22 54.08,114.22 54.57,114.71 UCPU1.AV2
  TOP w0.112: RP2.7 50.55,108.72 50.74,108.9 51.05,108.9 ; 51.05,108.9 v8(51.05,108.08) ; 51.05,108.9 51.45,109.3 51.45,111.8 52.45,112.8
  IN1 w0.066: v8(51.05,108.08) 51.9,107.24 51.9,107.22 52,107.12 52,106.75 51.27,106.02 51.04,106.02 48.41,103.4 v10(48.41,103.16)
  IN2 w0.066: v4(48.43,102.02) 48.43,103.15 v10(48.41,103.16)
  IN3 w0.066: v4(48.43,102.02) v5(47.98,102.02)
  BOTTOM w0.112: v5(47.98,102.02) 47.98,101.27 47.37,100.66 v2(47.37,100.15) 47.37,94.81 47.87,94.31 JSPI2.4
PCH_SPI_CLK_TPM: length 27.7
  IN1 w0.066: v14(40.72,88.77) 40.72,90.22 41.35,90.86 41.35,97.5 46.21,102.35 46.21,103.72 48.62,106.13 49.87,107.38 50.6,107.38 v8(51.05,106.93)
  GND1 w0.066: v4(41.08,88.74) 40.75,88.74 v14(40.72,88.77)
  IN3 w0.066: v4(41.08,88.74) 41.26,88.56 v5(41.43,88.56)
  BOTTOM w0.112: U4246.19 40.02,89.72 40.17,89.56 C226.1 40.63,89.14 v2(41.05,88.72) 41.21,88.56 v5(41.43,88.56)
PCH_SPI_CS0#: length 45.7
  IN1 w0.066: v8(55.28,115.4) 55.53,115.15 55.53,113.45 56.2,112.78 56.2,108.47 55.24,107.51 55.24,106.57 55.24,105.32 55.24,104.92 55.09,104.77 54.87,104.77 54.86,104.77 50.95,100.86 50.95,97.65 47.73,94.43 47.73,91.16 v7(47.29,90.73)
  BOTTOM w0.112: v7(47.29,90.73) 48.23,91.67 51.55,91.67 51.8,91.92 51.8,92.51 ; UH1.1 56.64,92.14 56.26,92.52 51.81,92.52 51.8,92.51 ; 51.8,92.51 51.8,94.24 51.22,94.81 v2(50.16,94.81) 48.65,94.81 JSPI2.5
PCH_SPI_CS1#: length 28.4
  TOP w0.076: UCPU1.AU2 54.63,115.16 54.55,115.08 53.69,115.08 52.45,113.84
  TOP w0.112: v3(47.33,108.48) 47.48,108.48 50.41,111.41 50.41,111.8 52.45,113.84
  IN2 w0.066: v3(47.33,108.48) 47.37,108.44 47.37,107.65 47.35,107.63 47.35,107.26 47.37,107.24 47.37,99.24 48.57,98.04 48.57,94.99 49.05,94.52 v4(49.05,93.77)
  IN3 w0.066: v5(47.85,92.81) 48.09,92.81 v4(49.05,93.77)
  BOTTOM w0.112: v5(47.85,92.81) JSPI2.1
PCH_SPI_CS2#: length 94.4
  IN1 w0.066: v10(46,93.28) 43.9,95.38 43.9,95.48 44.15,95.72 44.24,95.72 46.47,93.49 46.56,93.49 46.66,93.59 46.66,93.68 44.43,95.91 44.43,96 44.52,96.09 44.62,96.09 46.54,94.17 46.64,94.17 46.73,94.26 46.73,94.35 44.8,96.28 44.8,96.38 44.9,96.47 44.99,96.47 46.54,94.91 46.64,94.91 46.73,95.01 46.73,95.1 45.18,96.66 45.18,96.75 45.27,96.84 45.36,96.84 46.84,95.36 46.94,95.36 47.03,95.46 47.03,95.55 45.55,97.03 45.55,97.12 45.64,97.22 45.74,97.22 47.22,95.74 47.31,95.74 47.4,95.83 47.4,95.92 45.92,97.4 45.92,97.5 46.02,97.59 46.11,97.59 47.59,96.11 47.68,96.11 47.78,96.2 47.78,96.3 46.3,97.78 46.3,97.87 46.39,97.96 46.49,97.96 47.96,96.48 48.06,96.48 48.15,96.58 48.15,96.67 46.67,98.15 46.67,98.24 46.77,98.34 46.86,98.34 48.08,97.11 48.18,97.11 48.27,97.21 48.27,97.3 47.05,98.53 47.05,98.62 47.14,98.71 47.23,98.71 48.19,97.75 48.29,97.75 48.38,97.85 48.38,97.94 47.42,98.9 47.42,98.99 47.51,99.09 47.61,99.09 48.19,98.5 48.29,98.5 48.38,98.59 48.38,98.69 47.79,99.27 47.79,99.37 47.89,99.46 47.98,99.46 48.19,99.25 48.29,99.25 48.38,99.34 48.38,99.44 48.17,99.65 48.17,99.74 48.38,99.95 48.38,100.24 49.57,101.43 49.57,102.04 53.36,105.82 53.94,105.82 54.23,106.11 54.23,106.77 55.94,108.49 55.94,109.21 55.86,109.29 53.58,109.29 53.52,109.36 53.52,109.55 53.58,109.62 55.86,109.62 55.94,109.7 55.94,112.27 54.93,113.29 54.93,114.45 v8(53.98,115.4)
  IN2 w0.066: v10(46,93.28) 46,93.05 v4(46.1,92.95)
  IN3 w0.066: v5(44.2,93.51) 45.03,93.51 45.59,92.95 v4(46.1,92.95)
  BOTTOM w0.112: U4246.20 39.52,89.5 39.63,89.38 39.63,87.52 v2(40.28,86.88) 41.16,85.99 42.21,85.99 45.07,88.85 45.07,91.09 44.2,91.96 v5(44.2,93.51)
PCH_SPI_DO2_XDP: length 164.5
  IN1 w0.066: v8(52.7,108.8) 51.27,110.23 48.72,110.23 45.44,106.95 44.07,106.95 v14(43.81,106.69)
  GND1 w0.066: v14(43.81,106.69) 43.5,106.38 v4(43.5,106.31)
  IN3 w0.066: v4(43.5,106.31) 43.62,106.19 46.33,106.19 46.49,106.35 48.31,106.35 48.31,106.35 49.82,106.35 56.57,99.6 59.07,99.6 61.61,97.06 61.69,97.06 61.69,97.06 62.01,97.06 62.01,97.06 62.67,97.06 62.82,96.91 62.98,96.91 62.98,96.91 65.64,96.91 73.93,88.62 80.21,88.62 81.44,89.86 94.02,89.86 94.69,89.58 106.65,89.58 107.08,89.15 109.29,89.15 114.43,94.29 v6(114.43,98.43)
  IN4 w0.066: v6(114.43,98.43) 114.57,98.43 115.66,97.33 130.21,97.33 130.41,97.13 145.92,97.13 148.45,99.67 148.45,111.7 146.12,114.03 146.12,126.58 v1(143.22,129.48)
PCH_SPI_DO_XDP: length 178.5
  TOP w0.112: v2(49.34,109.82) 49.34,109.96 49.89,110.5 v8(50.29,110.5)
  IN1 w0.066: v14(43.44,106.89) 43.72,107.16 45.38,107.16 48.72,110.5 v8(50.29,110.5)
  GND1 w0.066: v14(43.44,106.89) 43.32,106.89 v4(43.09,106.66)
  IN3 w0.066: v6(114.05,96.5) 114.05,94.18 109.21,89.34 107.16,89.34 106.73,89.77 94.73,89.77 94.06,90.05 81.36,90.05 80.12,88.82 74.01,88.82 65.72,97.11 62.9,97.11 62.75,97.26 61.93,97.26 61.93,97.26 61.77,97.26 61.77,97.26 61.69,97.26 59.67,99.28 59.26,99.68 59.15,99.8 56.65,99.8 49.9,106.54 49.47,106.54 49.47,106.54 49.31,106.54 46.3,106.54 46.15,106.39 44.09,106.39 43.83,106.66 v4(43.09,106.66)
  IN4 w0.066: v1(148.21,134.13) 148.21,133.76 149.25,132.72 150.58,132.72 152.11,134.24 153.5,134.24 153.66,134.09 153.66,132.72 153.34,132.4 152.14,132.4 149.59,129.85 149.59,128.64 148.73,127.78 148.73,120.39 148.35,120 148.35,117 150.41,114.95 150.41,99.18 146.63,95.4 129.51,95.4 129.06,95.86 114.69,95.86 v6(114.05,96.5)
  BOTTOM w0.112: RC100.1 v1(148.21,134.13)
PCH_SPI_IO2: length 30.8
  TOP w0.076: UCPU1.AW2 54.61,113.85 54.26,113.5 54.26,113.06 54.15,112.95 53.23,112.95 53.03,112.75 53.03,112.35 52.45,111.77
  TOP w0.112: RP3.6 54.48,107 RH19.2 v8(52.7,107.89) 52.68,107.89 52.39,108.18 52.39,108.26 52.18,108.46 52.18,111.5 52.45,111.77
  IN1 w0.066: v8(52.7,107.89) 52.15,107.89 51.23,108.81 50.07,108.81 48.7,107.44 v10(47.81,107.44)
  IN2 w0.066: v10(47.81,107.44) 47.76,107.39 47.76,105.66 47.94,105.48 v4(47.94,105.46)
  IN3 w0.066: v4(47.94,105.46) 47.95,105.47 48.04,105.47 v5(48.23,105.27)
  BOTTOM w0.112: v5(48.23,105.27) 47.99,105.02 47.99,103.39 v2(48.57,102.8) 48.9,102.48 48.9,100.71 47.86,99.67 47.86,95.61 48.16,95.31 JSPI2.6
PCH_SPI_IO3: length 40.2
  TOP w0.076: 57.58,110.73 57.15,111.16 57.15,112.08 57.4,112.33 57.4,112.71 57.21,112.9 57.06,112.9 55.88,114.08 55.88,114.49 55.93,114.54 UCPU1.AU4
  TOP w0.112: v8(54.98,106.18) 54.98,106.95 54.48,107.44 RH20.2 RH21.2 55.58,107.89 56.02,108.32 57.09,108.32 v2(57.35,108.59) 57.35,109.36 57.58,109.58 57.58,110.73
  IN1 w0.066: v10(48.57,98.87) 48.57,100.06 49.78,101.27 49.78,101.97 53.44,105.63 54.43,105.63 v8(54.98,106.18)
  IN2 w0.066: v10(48.57,98.87) 47.56,99.88 47.56,104.3 v4(47.96,104.69)
  IN3 w0.066: v5(48.46,104.1) 48.4,104.1 47.96,104.55 v4(47.96,104.69)
  BOTTOM w0.112: JSPI2.7 48.26,95.81 48.1,95.97 48.1,99.57 49.14,100.61 49.14,103.42 v5(48.46,104.1)
PCH_SPI_SI: length 44.8
  TOP w0.076: UCPU1.AV3 55.29,115.02 54.76,115.02 54.66,114.92 53.78,114.92 52.7,113.84 52.7,113.76 52.45,113.5
  TOP w0.112: RP2.5 51.55,107.54 51.83,107.25 51.83,106.56 51.72,106.44 49.88,106.44 49.77,106.56 49.77,107.38 50.05,107.66 RP2.8 50.05,109.37 50.27,109.59 v8(50.29,109.59) 50.67,109.59 50.8,109.72 50.8,111.85 52.45,113.5
  IN1 w0.066: v10(47.83,107.92) 48.09,108.18 48.18,108.18 48.57,107.78 48.66,107.78 48.76,107.88 48.76,107.97 48.37,108.36 48.37,108.46 48.46,108.55 48.55,108.55 48.94,108.16 49.04,108.16 49.13,108.25 49.13,108.34 48.74,108.74 48.74,108.83 49.5,109.59 v8(50.29,109.59)
  IN2 w0.066: v10(47.83,107.92) 47.56,107.65 47.56,107.57 47.55,107.55 47.55,107.34 47.56,107.32 47.56,105.23 47.7,105.09 48.44,105.09 48.97,104.56 v4(48.97,104.41)
  IN3 w0.066: v5(49.39,105.03) 48.97,104.61 v4(48.97,104.41)
  BOTTOM w0.112: v5(49.39,105.03) 49.39,105.43 48.85,105.98 47.69,105.98 47.44,105.73 47.44,102.52 47.04,102.12 47.04,101.7 46.46,101.12 46.46,99.47 45.6,98.61 45.6,97.99 46.39,97.19 46.39,94.55 47.64,93.31 JSPI2.2
PCH_SPI_SI_TPM: length 24.9
  IN1 w0.066: v14(41.17,89.66) 41.17,90.05 41.8,90.67 41.8,97.31 46.75,102.26 46.94,102.26 47.26,102.58 47.26,102.87 47.97,103.58 47.97,103.58 50.87,106.49 51.11,106.49 v8(51.55,106.93)
  GND1 w0.066: v14(41.17,89.66) 41.15,89.69 v4(40.75,89.69)
  IN3 w0.066: v4(40.75,89.69) 39.22,89.69 v5(39.04,89.87)
  BOTTOM w0.112: U4246.21 39.02,89.89 v5(39.04,89.87)
PCH_SPI_SO: length 37.7
  TOP w0.076: UCPU1.AW3 55.02,114.15 54.78,114.39 54.46,114.39 54.3,114.22 54.3,113.76 54.13,113.59 53.65,113.59 52.45,112.39 52.45,112.11
  TOP w0.112: 53.4,106.86 53.48,106.78 v8(53.48,106.18) ; 53.4,106.86 53.78,106.86 53.98,106.67 RP3.7 ; 53.4,106.86 52.84,106.86 51.94,107.76 51.94,111.6 52.45,112.11
  IN1 w0.066: v8(53.48,106.18) 53.44,106.18 49.35,102.09 49.35,101.96 v10(49.11,101.72)
  IN2 w0.066: v4(48.46,104.56) 48.46,104.37 49.11,103.73 v10(49.11,101.72)
  IN3 w0.066: v4(48.46,104.56) 48.46,104.61 v5(48.89,105.03)
  BOTTOM w0.112: JSPI2.3 47.64,93.81 46.7,94.75 46.7,101.02 v2(47.35,101.67) 47.35,102.09 47.7,102.44 47.7,105.4 47.93,105.64 48.62,105.64 48.87,105.39 48.87,105.06 v5(48.89,105.03)
PCH_SPI_SO_TPM: length 30.9
  IN1 w0.066: v8(53.48,105.03) 53.48,104.21 50.35,101.08 50.35,97.92 47.12,94.68 47.12,94.52 47.12,93.18 45.57,91.63 v7(45.57,90.74)
  IN3 w0.066: v5(45.09,88.13) 45.09,88.15 43.27,89.97 42.87,89.97 41.67,91.17 40.74,91.17 39.8,92.11 37.71,92.11 37.58,91.99 37.58,91.09 v5(37.52,91.02)
  BOTTOM w0.112: U4246.24 v5(37.52,91.02) ; v7(45.57,90.74) 45.42,90.59 v2(45.42,89.65) 45.42,88.46 v5(45.09,88.13)
PCI_CLK_LPC0: length 5.7
  TOP w0.076: 59.36,110.43 59.36,110.89 59.09,111.15 59.09,111.61 59.27,111.79 59.27,113.17 59.01,114.01 UCPU1.AW9
  TOP w0.112: RC71.1 59.37,109.17 v2(59.37,109.82) 59.36,109.83 59.36,110.43
PCI_CLK_LPC1: length 4.9
  TOP w0.076: UCPU1.AY9 58.88,113.23 58.98,113.13 58.98,113.13 59.12,112.99 59.12,112.7 59.12,112.05 59.12,112.02 58.9,111.8 58.9,110.53 58.8,110.43
  TOP w0.112: 58.8,110.43 58.79,110.42 58.79,109.49 58.8,109.48 RC70.1
PCIE_PRX_CARDTX_N9: length 147.3
  IN2 w0.076: 66.67,130.62 66.67,130.64 66.67,130.64 66.67,131.45 67.06,131.83 67.06,132.02 66.98,132.1 v3(66.7,132.1)
  IN2 w0.081: v7(37.36,37.45) 37.68,37.14 37.86,37.14 38,37.28 38,42.58 50.34,54.93 50.34,65.71 51.89,67.26 51.89,77.41 56.16,81.67 56.16,87 54.23,88.92 54.23,91.84 50.55,95.52 50.55,105.07 49.3,106.32 49.3,111.43 49.84,111.97 49.84,116.38 49.26,116.96 49.26,117.87 52.14,120.75 52.14,124.02 54.27,126.15 54.56,126.15 55.02,126.61 55.6,126.61 56.71,127.72 57.59,127.72 58.83,128.96 59.96,128.96 60.52,129.52 62.1,129.52 62.53,129.08 63.71,129.08 64.14,129.52 65.89,129.52 66.67,130.3 66.67,130.62
  IN3 w0.081: v5(63.87,36.01) 63.47,35.61 62.17,35.61 61.57,35.01 41.66,35.01 40.87,35.8 39.55,35.8 38.25,37.1 37.72,37.1 v7(37.36,37.45)
PCIE_PRX_CARDTX_N9_C: length 3.2
  BOTTOM w0.112: UR1.8 66.32,34.61 66.23,34.52 65.98,34.52 65.92,34.58 65.92,35.29 65.54,35.67 65.12,35.67 CR12.2
PCIE_PRX_CARDTX_P9: length 147.3
  IN2 w0.076: v3(67.61,132.1) 67.33,132.1 67.26,132.02 67.26,131.75 66.87,131.36 66.87,130.64 66.88,130.64 66.88,130.62
  IN2 w0.081: 66.88,130.62 66.88,130.22 65.97,129.32 64.23,129.32 63.79,128.88 62.45,128.88 62.01,129.32 60.61,129.32 60.05,128.75 58.92,128.75 57.67,127.51 56.79,127.51 55.68,126.4 55.1,126.4 54.64,125.95 54.36,125.95 52.34,123.93 52.34,120.66 49.47,117.78 49.47,117.04 50.04,116.47 50.04,111.89 49.5,111.35 49.5,106.41 50.76,105.15 50.76,95.6 54.44,91.92 54.44,89.01 56.36,87.08 56.36,81.59 52.09,77.32 52.09,67.17 50.55,65.63 50.55,54.84 38.2,42.5 38.2,37.19 37.94,36.93 37.4,36.93 v7(37.36,36.9)
  IN3 w0.081: v7(37.36,36.9) 38.17,36.9 39.46,35.6 40.78,35.6 41.58,34.8 61.65,34.8 62.26,35.41 63.58,35.41 v5(63.87,35.12)
PCIE_PRX_CARDTX_P9_C: length 3.2
  BOTTOM w0.112: UR1.7 66.32,34.21 66.23,34.3 65.89,34.3 65.68,34.51 v11(65.68,34.84) 65.68,35.22 65.45,35.45 65.12,35.45 CR14.2
PCIE_PRX_SSDTX_N7: length 76
  TOP w0.076: v3(64.27,131.89) 64.57,131.89 64.87,131.59 UCPU1.F20
  IN2 w0.081: v3(53,82.79) 52.96,82.82 52.81,82.82 52.73,82.74 52.73,82.59 52.84,82.49 53.17,82.49 53.23,82.42 53.23,82.33 53.07,82.17 52.07,82.17 50.75,83.49 50.75,91.91 50.26,92.41 48.43,92.41 46.76,94.08 46.76,97.99 45.56,99.19 45.56,101.29 45.45,101.4 45.45,107.12 42.29,110.27 42.06,110.5 42.06,118.43 42.06,118.91 42.92,119.77 42.92,121.82 42.92,122.33 45.19,124.6 45.45,124.6 48.73,127.88 51.75,127.88 52.5,128.63 52.5,130.08 55.19,132.77 58.18,132.77 59.11,131.83 63.75,131.83 63.99,132.06 64.1,132.06 v3(64.27,131.89)
PCIE_PRX_SSDTX_P7: length 76.1
  TOP w0.076: v3(64.29,132.29) 64.48,132.1 UCPU1.E20
  IN2 w0.081: v3(53.5,82.79) 53.44,82.72 53.44,82.25 53.15,81.97 51.98,81.97 50.55,83.4 50.55,91.83 50.17,92.2 48.35,92.2 46.56,93.99 46.56,97.91 45.36,99.1 45.36,101.2 45.24,101.32 45.24,107.03 42.15,110.13 41.86,110.41 41.86,118.34 41.86,118.34 41.86,119 42.72,119.86 42.72,121.73 42.72,122.42 45.1,124.8 45.37,124.8 48.65,128.08 51.66,128.08 52.3,128.72 52.3,130.16 55.1,132.97 58.26,132.97 59.2,132.03 63.67,132.03 63.9,132.27 64.26,132.27 v3(64.29,132.29)
PCIE_PRX_WLANTX_N5: length 109.3
  TOP w0.076: UCPU1.F16 62.88,131.61 62.76,131.61 62.56,131.82 62.56,132.4 v3(62.5,132.46)
  TOP w0.112: JNGFF3.43 27.47,53.87 27.61,54.02 27.61,54.5 28.8,55.69 29.37,55.69 29.59,55.47 29.59,55.21 v3(29.65,55.14)
  IN2 w0.081: v3(29.65,55.14) 29.65,56.99 28.08,58.57 28.08,59.43 28.59,59.94 29.25,59.94 42.32,73.01 42.32,86.58 43.9,88.16 43.9,104.84 41.11,107.63 41.11,119.15 41.88,119.93 41.88,122.44 41.89,122.45 41.89,122.5 45.06,125.67 48.01,128.61 51.59,128.61 51.89,128.92 51.89,130.88 54.6,133.59 58.27,133.59 59.03,132.83 62.46,132.83 62.6,132.69 62.6,132.57 v3(62.5,132.46)
PCIE_PRX_WLANTX_P5: length 109.3
  TOP w0.076: UCPU1.E16 63.04,131.88 62.96,131.79 62.84,131.79 62.74,131.89 62.74,132.35 v3(62.85,132.46)
  TOP w0.112: JNGFF3.41 27.97,53.87 27.83,54.02 27.83,54.41 28.89,55.48 29.28,55.48 29.38,55.38 29.38,55.25 v3(29.27,55.14)
  IN2 w0.081: v3(62.85,132.46) 62.8,132.51 62.8,132.77 62.54,133.04 59.11,133.04 58.36,133.79 54.51,133.79 51.69,130.97 51.69,129 51.5,128.82 47.92,128.82 44.98,125.87 41.69,122.58 41.69,122.53 41.68,122.52 41.68,120.01 40.91,119.24 40.91,107.55 43.7,104.76 43.7,88.24 42.11,86.66 42.11,73.09 29.17,60.14 28.5,60.14 27.88,59.52 27.88,58.49 29.45,56.91 29.45,55.32 v3(29.27,55.14)
PCIE_PRX_WTX_UR_N12_SW: length 20.1
  TOP w0.112: ML2.1 26.18,109.91 v3(26.1,109.83)
  IN2 w0.081: v3(26.1,109.83) 26.1,109.48 27.64,107.94 27.64,107.58 28.38,106.83 28.38,97.86 29.38,96.86 29.38,95.73 29.03,95.38 29.03,94.96 27.21,93.14 26.99,93.14 v3(26.89,93.05)
PCIE_PRX_WTX_UR_N12_SW_CONN: length 2.6
  TOP w0.112: ML2.2 26.18,112.58 25.89,112.87 25.89,113.36 25.74,113.5 25.74,113.67 25.88,113.8 JNGFF1.29
PCIE_PRX_WTX_UR_P12_SW: length 20.1
  TOP w0.112: ML2.4 25.38,110.07 v3(25.59,109.86)
  IN2 w0.081: v3(26.89,93.55) 26.89,93.47 27.02,93.35 27.13,93.35 28.82,95.04 28.82,95.46 29.18,95.82 29.18,96.77 28.18,97.77 28.18,106.75 27.43,107.5 27.43,107.85 25.9,109.39 25.9,109.65 25.68,109.86 v3(25.59,109.86)
PCIE_PRX_WTX_UR_P12_SW_CONN: length 2.6
  TOP w0.112: JNGFF1.31 25.38,113.81 25.53,113.67 25.53,113.41 25.67,113.27 25.67,112.86 25.38,112.57 ML2.3
PCIE_PRX_WWANTX_N11: length 68.4
  TOP w0.076: v3(69.91,132.14) 69.91,132.06 70.02,131.95 70.21,131.95 UCPU1.E28
  TOP w0.112: JNGFF1.41 22.88,115.45 22.78,115.55 22.71,115.55 22.6,115.66 22.6,115.87 23.57,116.84 24.77,116.84 24.88,116.73 24.88,116.57 24.71,116.4 v3(24.71,116.38)
  IN2 w0.076: v3(69.91,132.14) 69.93,132.13 69.93,132.02 69.84,131.93 69.49,131.93 68.95,132.47 68.95,133.91 67.53,135.33 67.08,135.33 66.74,135.66 66,135.66 66,135.66 65.93,135.66 65.93,135.67 65.91,135.67
  IN2 w0.081: 65.91,135.67 60.27,135.67 59.41,136.53 55.16,136.53 52.52,139.17 48.95,139.17 48.72,138.94 42.58,138.94 38.44,134.8 38.44,133.46 33.75,128.77 30.72,128.77 26.52,124.57 26.52,118.65 24.89,117.02 24.89,116.56 24.72,116.38 v3(24.71,116.38)
PCIE_PRX_WWANTX_N12: length 102.2
  TOP w0.076: UCPU1.E30 71.1,131.93 70.89,131.93 v3(70.87,131.95)
  TOP w0.112: v3(25.3,97.86) 25.35,97.91 25.35,98.26 25.7,98.62 26.9,98.62 27.23,98.29 27.96,98.29 27.98,98.3 28.53,98.3 28.55,98.29 29.16,98.29 29.76,97.68 30.62,97.68 33.32,94.98 33.32,93.07 32.69,92.43 v11(32.4,92.43) 30.75,92.43 30.63,92.55 U4.12
  IN2 w0.081: v3(70.87,131.95) 70.51,131.95 70.43,132.03 70.43,132.26 69.41,133.27 69.41,134.61 68.29,135.74 67.3,135.74 66.78,136.25 60.51,136.25 59.63,137.14 55.46,137.14 52.82,139.78 48.72,139.78 48.47,139.53 42.31,139.53 37.85,135.07 37.85,133.7 33.51,129.36 30.48,129.36 25.93,124.81 25.93,118.89 23.79,116.75 23.79,111.06 22.96,110.24 22.96,108.94 25.18,106.72 25.18,101.57 24.92,101.31 24.92,98.64 25.41,98.15 25.41,97.97 v3(25.3,97.86)
PCIE_PRX_WWANTX_P11: length 68.3
  TOP w0.076: UCPU1.E27 69.61,132.1 69.91,131.8 v3(69.91,131.7)
  TOP w0.112: JNGFF1.43 22.38,115.96 23.48,117.06 24.86,117.06 25.1,116.82 v3(25.1,116.38)
  IN2 w0.076: 65.91,135.46 66.25,135.13 67.45,135.13 68.75,133.83 68.75,132.39 69.41,131.73 69.88,131.73 v3(69.91,131.7)
  IN2 w0.081: 65.91,135.46 60.19,135.46 59.32,136.33 55.08,136.33 52.44,138.97 49.04,138.97 48.8,138.73 42.66,138.73 38.65,134.72 38.65,133.38 33.84,128.57 30.81,128.57 26.72,124.48 26.72,118.56 25.1,116.93 v3(25.1,116.38)
PCIE_PRX_WWANTX_P12: length 102.2
  TOP w0.076: UCPU1.F30 71.34,131.38 71.65,131.38 71.7,131.43 71.7,131.61 71.58,131.74 71.43,131.74 71.42,131.74 71.01,131.74 v3(70.87,131.59)
  TOP w0.112: v3(25.7,97.86) 25.57,97.99 25.57,98.17 25.79,98.4 26.81,98.4 27.14,98.07 v11(28.26,98.07) 29.07,98.07 29.67,97.47 30.53,97.47 33.11,94.89 33.11,93.16 32.62,92.67 32.12,92.67 32.11,92.65 30.84,92.65 30.72,92.76 30.22,92.76 30.14,92.85 30.14,92.98 30.06,93.05 U4.13
  IN2 w0.081: v3(25.7,97.86) 25.63,97.93 25.63,98.26 25.12,98.77 25.12,101.23 25.39,101.49 25.39,106.8 23.16,109.02 23.16,110.15 23.99,110.98 23.99,116.66 26.13,118.81 26.13,124.73 30.56,129.16 33.59,129.16 38.06,133.62 38.06,134.98 42.39,139.32 48.56,139.32 48.81,139.57 52.74,139.57 55.38,136.93 59.55,136.93 60.43,136.05 66.7,136.05 67.21,135.54 68.2,135.54 69.21,134.53 69.21,133.19 70.23,132.17 70.23,131.95 70.43,131.75 70.73,131.75 70.87,131.61 v3(70.87,131.59)
PCIE_PTX_CARDRX_N9: length 154.9
  IN2 w0.076: 67.5,130.62 67.5,130.64 67.5,130.64 67.5,131.13 68.14,131.76 68.14,132.34 66.99,133.48 66.99,134.42 67.15,134.58 67.34,134.58 67.42,134.5 v3(67.42,134.17)
  IN2 w0.081: 67.5,130.62 67.5,129.73 68.01,129.22 68.01,128.73 67.55,128.27 60.52,128.27 59.82,127.57 59.57,127.57 58.63,126.63 56.95,126.63 56.03,125.72 55.65,125.72 55.09,125.16 55.09,124.88 54.38,124.17 54.38,123.17 53.19,121.98 53.19,120.67 50.11,117.6 50.11,117.23 50.63,116.71 50.63,111.64 50.09,111.1 50.09,106.65 51.35,105.4 51.35,95.85 55.03,92.16 55.03,89.25 56.95,87.33 56.95,81.34 52.68,77.08 52.68,66.93 51.14,65.38 51.14,54.53 38.81,42.2 38.81,36.55 37.88,35.62 37.88,33.13 v4(38.13,32.87)
  IN3 w0.081: v4(38.13,32.87) 38.09,32.87 37.83,32.62 37.83,32.49 37.91,32.41 41.1,32.41 41.83,33.15 61.49,33.15 62.88,31.77 63.15,31.77 v5(63.6,32.22)
PCIE_PTX_CARDRX_N9_C: length 3
  BOTTOM w0.112: CR23.2 64.85,31.88 64.94,31.88 65.97,32.91 66.22,32.91 66.32,33.01 UR1.4
PCIE_PTX_CARDRX_P9: length 154.9
  IN2 w0.076: v3(67.42,134.82) 67.37,134.77 67.07,134.77 66.79,134.5 66.79,133.4 67.94,132.25 67.94,131.85 67.3,131.21 67.3,130.64 67.3,130.64 67.3,130.62
  IN2 w0.081: v4(37.6,32.87) 37.68,32.95 37.68,35.7 38.61,36.63 38.61,42.29 50.93,54.61 50.93,65.47 52.48,67.01 52.48,77.16 56.75,81.43 56.75,87.24 54.82,89.17 54.82,92.08 51.14,95.76 51.14,105.31 49.89,106.57 49.89,111.19 50.43,111.73 50.43,116.63 49.91,117.14 49.91,117.68 52.98,120.75 52.98,122.06 54.18,123.26 54.18,124.25 54.89,124.96 54.89,125.24 55.57,125.92 55.95,125.92 56.86,126.84 58.55,126.84 59.49,127.78 59.73,127.78 60.43,128.48 67.47,128.48 67.81,128.82 67.81,129.13 67.3,129.64 67.3,130.62
  IN3 w0.081: v5(63.6,31.33) 63.37,31.56 62.79,31.56 61.41,32.95 41.92,32.95 41.18,32.21 37.83,32.21 37.63,32.41 37.63,32.84 v4(37.6,32.87)
PCIE_PTX_CARDRX_P9_C: length 3
  BOTTOM w0.112: CR22.2 64.85,31.67 65.06,31.67 65.51,32.12 65.51,32.13 v11(65.6,32.22) 66.08,32.69 66.24,32.69 66.32,32.61 UR1.3
PCIE_PTX_SSDRX_N7: length 76.3
  TOP w0.076: UCPU1.B21 66.06,134.41 v3(65.66,134.81)
  TOP w0.112: v3(53.11,85.69) 53.23,85.82 53.54,85.82 53.8,86.07 54.5,86.07 54.63,85.94 54.63,85.76 54.42,85.55 CD42.1
  IN2 w0.081: v3(53.11,85.69) 52.96,85.84 52.4,85.84 51.28,86.96 51.28,91.93 50.42,92.79 48.62,92.79 47.15,94.26 47.15,98.21 45.95,99.4 45.95,100.96 45.95,101.45 45.83,101.56 45.83,107.28 42.45,110.66 42.45,118.27 42.45,118.58 42.45,118.59 42.45,118.75 43.31,119.61 43.31,122.17 45.35,124.21 45.61,124.21 48.26,126.86 51.35,126.86 53.47,128.97 53.78,128.97 53.95,129.13 53.95,130.85 54.62,131.52 56.57,131.52 56.88,131.21 58.11,131.21 58.34,131.44 64.3,131.44 64.66,131.8 65.79,132.92 65.79,133.37 66.03,133.61 66.03,134.73 65.95,134.81 v3(65.66,134.81)
PCIE_PTX_SSDRX_N7_C: length 2.1
  TOP w0.112: CD42.2 54.65,84.28 54.65,83.67 54.5,83.52 JNGFF2.35
PCIE_PTX_SSDRX_P7: length 76.4
  TOP w0.076: v3(65.66,135.19) 65.69,135.19 UCPU1.A21
  TOP w0.112: v3(53.11,86.07) 53.15,86.03 53.45,86.03 53.71,86.29 54.59,86.29 54.84,86.03 54.84,85.71 55,85.55 CD43.1
  IN2 w0.081: v3(65.66,135.19) 65.84,135.02 66.03,135.02 66.23,134.82 66.23,133.53 65.99,133.29 65.99,132.84 64.86,131.71 64.39,131.24 58.43,131.24 58.19,131 56.8,131 56.48,131.32 54.7,131.32 54.15,130.77 54.15,129.05 53.87,128.77 53.55,128.77 51.44,126.65 48.34,126.65 45.7,124.01 45.43,124.01 43.51,122.09 43.51,119.53 42.65,118.67 42.65,118.67 42.65,118.18 42.65,118.18 42.65,110.74 46.03,107.36 46.03,101.65 46.15,101.53 46.15,100.88 46.15,99.49 47.35,98.29 47.35,94.35 48.7,93 50.5,93 51.48,92.02 51.48,87.05 52.48,86.04 53.08,86.04 v3(53.11,86.07)
PCIE_PTX_SSDRX_P7_C: length 2
  TOP w0.112: JNGFF2.37 55,83.49 54.86,83.63 54.86,84.32 CD43.2
PCIE_PTX_WLANRX_N5: length 107.2
  TOP w0.076: v3(64.48,133.53) 64.48,133.45 64.65,133.28 64.82,133.28 64.94,133.39 UCPU1.C19
  IN2 w0.081: v7(27.51,57.62) 27.41,57.72 27,57.72 26.61,58.11 26.61,59.64 28.32,61.34 28.7,61.34 40.93,73.58 40.93,86.39 43.08,88.53 43.08,104.26 39.73,107.61 39.73,119.73 40.77,120.77 40.77,124.42 41.53,125.17 42.62,125.17 51.82,134.38 58.88,134.38 59.37,133.88 64.04,133.88 64.39,133.53 v3(64.48,133.53)
  BOTTOM w0.112: v7(27.51,57.62) 27.62,57.72 27.96,57.72 28.07,57.61 28.07,56.66 CV10.1
PCIE_PTX_WLANRX_N5_C: length 3.6
  TOP w0.112: JNGFF3.37 28.97,53.8 29.11,53.94 29.11,54.12 v7(28.93,54.3)
  BOTTOM w0.112: CV10.2 28.15,55.15 28.15,54.98 28.39,54.74 28.99,54.74 29.11,54.61 29.11,54.48 v7(28.93,54.3)
PCIE_PTX_WLANRX_P5: length 107.1
  TOP w0.076: UCPU1.D19 64.94,132.99 64.83,133.1 64.58,133.1 64.4,133.28 v3(64.22,133.28)
  IN2 w0.081: v7(27.51,58.2) 27.24,57.93 27.08,57.93 26.82,58.19 26.82,59.55 28.41,61.14 28.78,61.14 41.14,73.5 41.14,86.3 43.28,88.45 43.28,104.34 39.93,107.69 39.93,119.64 40.98,120.69 40.98,124.33 41.61,124.97 42.7,124.97 51.91,134.18 58.79,134.18 59.29,133.68 63.95,133.68 64.22,133.41 v3(64.22,133.28)
  BOTTOM w0.112: v7(27.51,58.2) 27.77,57.94 28.04,57.94 28.28,57.7 28.28,56.82 CV9.1
PCIE_PTX_WLANRX_P5_C: length 3.6
  TOP w0.112: v7(29.51,54.3) 29.32,54.11 29.32,53.93 29.47,53.78 JNGFF3.35
  BOTTOM w0.112: CV9.2 28.37,55.15 28.37,55.07 28.48,54.95 29.08,54.95 29.33,54.7 29.33,54.48 v7(29.51,54.3)
PCIE_PTX_WRX_UT_N12_SW: length 17.8
  TOP w0.112: v3(25.31,108.73) 25.21,108.82 25.21,109.64 24.79,110.06 24.22,110.06 24.15,110.13 ML1.1
  IN2 w0.081: v3(25.31,108.73) 25.21,108.62 25.21,108.57 26,107.78 26,101.19 25.73,100.92 25.73,99.23 27.18,97.78 27.18,96.36 27.42,96.12 27.42,95.48 27.19,95.25 27.09,95.25 v3(26.89,95.05)
PCIE_PTX_WRX_UT_N12_SW_CONN: length 2.6
  TOP w0.112: JNGFF1.35 24.38,113.85 24.18,113.65 24.18,113.45 23.89,113.16 23.89,112.83 24.15,112.57 ML1.2
PCIE_PTX_WRX_UT_P12_SW: length 17.9
  TOP w0.112: v3(24.87,108.74) 24.98,108.85 v11(24.98,109.21) 24.98,109.56 24.7,109.84 23.74,109.84 23.35,110.23 ML1.4
  IN2 w0.066: v3(26.89,95.55) 26.89,95.55
  IN2 w0.081: 26.89,95.55 26.99,95.45 27.11,95.45 27.22,95.56 27.22,96.03 26.97,96.27 26.97,97.69 25.53,99.14 25.53,101 25.8,101.27 25.8,107.69 25,108.49 25,108.6 v3(24.87,108.74)
PCIE_PTX_WRX_UT_P12_SW_CONN: length 2.6
  TOP w0.112: ML1.3 23.35,112.53 23.68,112.86 23.68,113.25 23.97,113.54 23.97,113.77 23.88,113.85 JNGFF1.37
PCIE_PTX_WWANRX_N11: length 73.9
  TOP w0.076: UCPU1.D24 68.07,133.2 68.15,133.27 68.15,133.5 68.07,133.58 67.87,133.58 67.7,133.75 67.7,133.87 67.7,133.87 67.7,134.59 67.7,134.6 67.7,134.78 67.7,135.08 67.31,135.47 67.31,136.11 67.23,136.19 67.23,136.19 67.21,136.21
  TOP w0.112: CV2.1 22.12,111.62 21.73,111.23 21.73,111.09 21.94,110.88 22.6,110.88 22.75,111.02 v3(22.77,111.02) ; 67.21,136.21 v3(67.13,136.29)
  IN2 w0.076: 65.91,137.02 65.93,137.02 65.93,137.02 66.77,137.02 67.21,136.59 67.21,136.36 v3(67.13,136.29)
  IN2 w0.081: v3(22.77,111.02) 22.77,111.01 22.65,110.88 22.56,110.88 22.49,110.96 22.49,111.55 23.09,112.14 23.09,116.78 25.53,119.22 25.53,124.95 30.32,129.74 33.35,129.74 37.39,133.79 37.39,135.22 42.08,139.91 48,139.91 48.27,140.18 53.04,140.18 53.31,139.91 54.82,139.91 55.61,140.7 61.91,140.7 63.23,139.38 63.23,137.68 64.11,136.81 65.11,136.81 65.32,137.02 65.91,137.02
PCIE_PTX_WWANRX_N11_C: length 2.5
  TOP w0.112: JNGFF1.47 21.38,113.9 21.29,113.81 21.29,113.65 21.85,113.09 21.85,112.91 CV2.2
PCIE_PTX_WWANRX_N12: length 98.3
  TOP w0.076: v3(68.16,136.01) 68.16,135.48 68.28,135.36 68.28,134.78 68.37,134.69 68.48,134.69 68.54,134.75 UCPU1.A25
  TOP w0.112: v3(25.31,96.47) 25.35,96.51 25.35,96.84 26.05,97.54 29.01,97.54 29.5,97.05 30.33,97.05 v11(30.81,96.57) 31.75,95.64 31.77,95.64 32.16,95.25 32.16,95.22 32.69,94.69 32.69,93.84 32.45,93.6 32.25,93.6 C30.1
  IN2 w0.081: v3(68.16,136.01) 68.16,136.44 66.71,137.89 63.08,141.53 52.33,141.53 51.78,140.98 47.8,140.98 47.53,140.7 41.72,140.7 36.59,135.58 36.59,134.11 34.39,131.9 31.36,131.9 24.48,125.02 24.48,119.55 22.29,117.37 22.29,113.91 21.7,113.32 21.7,110.44 22.34,109.79 22.34,108.73 24.59,106.48 24.59,101.83 23.98,101.22 23.98,98.13 25.33,96.77 25.33,96.49 v3(25.31,96.47)
PCIE_PTX_WWANRX_N12_C: length 1.8
  TOP w0.112: U4.14 30.06,93.55 30.21,93.69 30.68,93.69 C30.2
PCIE_PTX_WWANRX_P11: length 73.8
  TOP w0.076: 67.49,136.21 67.49,135.54 67.89,135.15 67.89,134.78 67.88,134.67 67.88,134.67 67.88,134.59 67.88,133.95 UCPU1.C24
  TOP w0.112: v3(67.51,136.29) 67.49,136.27 67.49,136.21 ; v3(22.77,110.64) v11(22.21,110.64) 21.87,110.64 21.51,111 21.51,111.44 CV1.1
  IN2 w0.076: 65.91,137.23 65.93,137.23 65.93,137.22 66.86,137.22 67.41,136.67 67.41,136.39 v3(67.51,136.29)
  IN2 w0.081: 65.91,137.23 65.24,137.23 65.03,137.01 64.19,137.01 63.44,137.77 63.44,139.47 61.99,140.91 55.53,140.91 54.73,140.11 53.4,140.11 53.13,140.39 48.18,140.39 47.91,140.12 41.99,140.12 37.19,135.31 37.19,133.87 33.26,129.95 30.23,129.95 25.32,125.04 25.32,119.31 22.89,116.87 22.89,112.23 22.29,111.63 22.29,110.87 22.48,110.68 22.73,110.68 v3(22.77,110.64)
PCIE_PTX_WWANRX_P11_C: length 2.5
  TOP w0.112: JNGFF1.49 20.88,113.87 21.07,113.68 21.07,113.56 21.64,113 21.64,112.84 CV1.2
PCIE_PTX_WWANRX_P12: length 98.3
  TOP w0.076: v3(67.77,136.03) 67.81,136.03 67.98,135.85 67.98,135.41 68.1,135.29 68.1,134.71 68.3,134.51 68.88,134.51 68.98,134.4 68.98,134.24 68.91,134.17 UCPU1.B25
  TOP w0.112: C31.1 31.95,94.12 32.26,93.82 32.36,93.82 32.48,93.93 32.48,94.6 v11(31.8,95.28) 30.86,96.21 30.84,96.21 30.45,96.6 30.45,96.63 30.24,96.84 29.41,96.84 28.92,97.32 26.14,97.32 25.57,96.75 25.57,96.6 v3(25.69,96.47)
  IN2 w0.081: v3(67.77,136.03) 67.96,136.23 67.96,136.36 66.57,137.75 62.99,141.32 52.42,141.32 51.86,140.77 47.88,140.77 47.61,140.5 41.8,140.5 36.79,135.49 36.79,134.02 34.47,131.7 31.44,131.7 24.68,124.94 24.68,119.47 22.49,117.28 22.49,113.83 21.9,113.24 21.9,110.52 22.55,109.88 22.55,108.81 24.8,106.56 24.8,101.75 24.18,101.13 24.18,98.21 25.54,96.86 25.54,96.62 25.68,96.47 v3(25.69,96.47)
PCIE_PTX_WWANRX_P12_C: length 1.7
  TOP w0.112: U4.15 30.06,94.05 30.21,93.91 30.74,93.91 C31.2
PCIE_RCOMPN: length 2.2
  TOP w0.305: UCPU1.F5 56.83,131.45 v7(57.1,131.71)
  BOTTOM w0.127: RC113.1 v2(56.45,130.63)
  BOTTOM w0.254: v7(57.1,131.71) 56.95,131.56 RC113.1
PCIE_RCOMPP: length 1.8
  TOP w0.305: UCPU1.E5 56.85,132.1 v7(57.1,132.35)
  BOTTOM w0.127: v2(57.49,132.06) 57.2,132.35 v7(57.1,132.35)
  BOTTOM w0.254: v7(57.1,132.35) 56.97,132.48 RC113.2
PCIE_WAKE#: length 141.9
  TOP w0.112: v3(22.1,62.61) 21.21,62.61 20.72,62.12 JNGFF3.70 ; v3(22.29,53.96) 24.15,53.96 24.47,53.64 JNGFF3.55
  IN1 w0.066: v8(19.63,122.44) 19.43,122.23 19.43,121.76 v10(20.17,121.02) 19.43,120.28 19.43,118.85 17.63,117.06 17.63,109.39 19.61,107.41 21.04,107.41 23.78,104.67 23.78,99.2 23.43,98.85 23.43,94.43 v10(23.56,94.3)
  IN2 w0.066: v3(22.29,53.96) 22.1,54.15 v3(22.1,62.61) 22.49,63 22.49,76.26 21.19,77.56 21.19,91.79 23.56,94.17 v10(23.56,94.3) 23.24,94.3 v4(23.14,94.4) ; v3(61.19,87.52) 61.19,89.24 v4(60.71,89.73) ; v4(20.47,120.84) 20.35,120.84 v10(20.17,121.02)
  IN3 w0.066: v4(60.71,89.73) 58.53,89.73 57.59,90.67 57.59,91.27 56.29,92.57 51.03,92.57 49.32,94.27 46.21,94.27 46.21,94.27 46.07,94.27 46.07,94.27 45.98,94.27 41.54,98.71 39.13,98.71 38.53,99.3 32.25,99.3 31.29,98.35 31.29,97.97 30.95,97.62 29.47,97.62 29.08,98.01 29.08,99.34 28.29,100.13 27.91,100.13 27.69,99.9 27.69,96.05 26.04,94.4 v4(23.14,94.4) ; v6(19.51,120.03) 20.32,120.84 v4(20.47,120.84)
  IN4 w0.066: v1(17.35,119.83) 17.45,119.93 19.41,119.93 v6(19.51,120.03)
  BOTTOM w0.076: UE3.N13 19.81,118.4
  BOTTOM w0.112: RE67.1 v1(17.35,119.83) 17.48,119.83 17.65,119.65 17.65,119.5 17.66,119.5 17.66,119.01 17.65,119.01 17.65,118.93 17.66,118.93 17.66,118.86 17.81,118.71 19.51,118.71 19.81,118.4
PD1_AUX_N: length 19.5
  IN3 w0.066: v5(18.38,67.71) 18.38,67.41 18.44,67.34 19.46,67.34 19.79,67.68 22.59,67.68 23.34,66.93 26.31,66.93 27.7,68.31 27.9,68.31 28.04,68.45 v5(28.04,68.65) 28.13,68.65 28.44,68.34 29.94,68.34 30.17,68.11 32.91,68.11 32.98,68.04
  IN3 w0.076: v5(33.69,66.34) 33.53,66.5 33.53,67.5 32.99,68.04 32.98,68.04
  BOTTOM w0.112: CT35.2 27.5,68.36 27.75,68.36 v5(28.04,68.65)
PD1_AUX_P: length 19.2
  IN3 w0.066: 32.91,67.87 32.91,67.87 32.83,67.94 30.1,67.94 29.87,68.17 28.48,68.17 28.17,67.86 v5(28.04,67.86) 28.04,68.02 27.92,68.15 27.77,68.15 26.38,66.76 23.27,66.76 22.52,67.51 19.86,67.51 19.52,67.18 18.44,67.18 18.38,67.11 v5(18.38,66.82)
  IN3 w0.076: 32.91,67.87 33.35,67.43 33.35,66.5 v5(33.19,66.34)
  BOTTOM w0.112: CT34.2 27.49,68.14 27.75,68.14 v5(28.04,67.86)
PD1_CC1: length 4.8
  IN3 w0.254: v5(37.19,67.34) 37.27,67.42 37.27,67.82 38.67,69.22 38.67,69.76 v5(38.44,69.99)
  BOTTOM w0.254: CT8.1 38.02,70.4 v5(38.44,69.99) ; UT1.K9 v5(37.19,67.34)
PD1_CC2: length 4.6
  IN3 w0.254: v5(37.69,67.34) 37.69,67.73 39.03,69.07 39.03,69.68 v5(39.33,69.99)
  BOTTOM w0.254: v5(39.33,69.99) 39.33,70.56 CT7.1 ; UT1.K10 v5(37.69,67.34)
PD1_DEBUG1: length 7
  BOTTOM w0.112: RT6.2 RT5.2 28.5,69.53 28.71,69.32 29.32,69.32 29.51,69.13 30.2,69.13 31.12,68.22 31.67,68.22 32.22,67.66 33.54,67.66 33.69,67.52 UT1.L2
PD1_DEBUG2: length 8.3
  BOTTOM w0.076: 32.64,67.32 32.83,67.32 33.07,67.09 33.44,67.09 UT1.K2
  BOTTOM w0.112: RT8.2 RT7.2 27.88,69.08 29.26,69.08 29.42,68.92 30.12,68.92 31.03,68 31.58,68 32.26,67.32 32.64,67.32
PD1_DEBUG3: length 5.1
  BOTTOM w0.112: UT1.L3 34.19,67.68 33.78,68.09 32.41,68.09 31.86,68.64 31.3,68.64 RT3.2
PD1_DEBUG4: length 6.6
  BOTTOM w0.076: 33.58,67.88 33.94,67.52 33.94,67.09 UT1.K3
  BOTTOM w0.112: 33.58,67.88 32.32,67.88 31.77,68.43 31.21,68.43 30.29,69.34 29.96,69.34 29.65,69.65 RT4.2 RT125.2
PD1_DEBUG_CTL1: length 6.8
  IN3 w0.066: v5(34.69,64.33) 34.69,63.58 34.28,63.17 30.18,63.17 29.46,62.45 v5(29.12,62.45)
PD1_DEBUG_CTL2: length 6.9
  IN3 w0.066: v5(29.12,61.88) 30.25,63 34.35,63 v5(35.19,63.83)
PD1_GPIO0: length 2.5
  BOTTOM w0.076: UT1.B2 33.94,62.58 33.94,61.79
  BOTTOM w0.112: 33.94,61.79 33.94,61.07 RT45.1
PD1_GPIO1: length 4.3
  BOTTOM w0.076: UT1.C2 33.44,63.08 33.44,62.74 33.28,62.58 33,62.58 32.89,62.48 32.89,62.09 32.64,61.84
  BOTTOM w0.112: RT99.1 32.54,60.56 RT46.1 32.58,60.75 32.4,60.92 32.4,61.59 32.64,61.84
PD1_GPIO2: length 14
  IN4 w0.066: v1(39.12,64.2) 39.44,63.88 39.44,60.59 40.93,59.09 40.93,57.09 v1(41.66,56.36)
  BOTTOM w0.076: UT1.D10 37.93,64.08 38.59,64.08 38.71,64.2 38.73,64.2
  BOTTOM w0.112: RT28.1 39.59,63.82 39.21,64.2 v1(39.12,64.2) 38.73,64.2 ; v1(41.66,56.36) 41.11,56.91 40.4,56.91 v2(39.97,57.34)
PD1_GPIO3: length 2.6
  BOTTOM w0.112: UT1.G11 38.41,65.11 39.7,65.11 RT20.1
PD1_GPIO5: length 5.9
  IN3 w0.066: v5(42.34,63.82) 41.83,64.33 v5(37.69,64.33)
  BOTTOM w0.112: v5(42.34,63.82) RT31.1
PD1_GPIO6: length 5.1
  IN3 w0.066: v5(39.12,65.47) 40.03,65.47 40.41,65.85 v5(40.41,67.38)
  BOTTOM w0.076: 38.73,65.47 38.63,65.47 38.53,65.58 37.89,65.58 37.69,65.38 UT1.G10
  BOTTOM w0.112: 38.73,65.47 v5(39.12,65.47) ; RT17.1 40.44,67.25 40.41,67.27 v5(40.41,67.38)
PD1_GPIO7: length 12.5
  IN4 w0.066: v1(36.19,63.83) 36.46,63.57 37.01,63.57 37.58,62.99 38.73,62.99 39.24,62.49 39.24,60.49 40.77,58.97 v1(40.77,56.28)
  BOTTOM w0.112: v2(38.85,56.69) 39.27,56.28 v1(40.77,56.28)
PD1_GPIO8: length 8.7
  IN4 w0.066: v1(40.22,69.67) 40.11,69.56 35.74,69.56 35.48,69.31 35.48,68.8 35.99,68.29 35.99,67.88
  IN4 w0.076: v1(35.69,65.84) 35.69,66.49 35.94,66.75 35.94,67.76 35.99,67.81 35.99,67.88
PD1_GPIO8_EXT: length 3.9
  BOTTOM w0.112: TC19.1 42.88,70.52 RT104.1 RT103.2 42.01,70.29 41.9,70.4 40.41,70.4 RT11.2
PD1_HWRST: length 77
  IN2 w0.066: v4(39.37,126.3) 39.24,126.18 39.24,126.05 38.83,125.63 38.83,122.6 38.85,122.58 38.85,122.4 37.82,121.38 37.82,107.74 40.36,105.2 40.36,104.28 41.66,102.99 41.66,88.66 39.19,86.2 39.19,78.55 38.46,77.81 38.46,73.95 36.65,72.15 36.65,71.65 v4(33.82,68.82)
  IN3 w0.066: v4(39.37,126.3) 38.61,126.3 v5(38.23,126.68) ; v4(33.82,68.82) 33.82,67.06 35.69,65.19 v5(35.69,63.83)
  IN4 w0.066: 38.29,61.79 38.29,61.21 40.07,59.43 v1(40.07,59.2)
  IN4 w0.076: v5(35.69,63.83) 35.76,63.83 36.22,63.38 36.96,63.38 38.29,62.05 38.29,61.79
PD1_LPS1: length 33.4
  TOP w0.254: v8(38.61,46.29) 38.89,46.57 PR216.2
  TOP w0.381: v8(16.61,34.25) 17.58,34.25 PQ134.6
  IN1 w0.254: v8(38.61,46.29) 37.59,46.29 36.07,44.77 31.5,44.77 29.34,42.61 27.94,42.61 27.56,42.23 21.08,42.23 20.45,41.59 20.45,41.21 19.94,40.71 16.76,40.71 15.62,39.56 15.62,35.63 16.61,34.63 v8(16.61,34.25)
PD1_LPS2: length 24
  IN3 w0.381: v5(34.47,46.7) 32.64,46.7 32.42,46.48 29.52,46.48 27.66,44.62 27.66,44.26 27.28,43.88 24.77,43.88 22.91,42.03 18.95,42.03 18.03,41.11 v4(18.03,39.49)
  BOTTOM w0.381: PR111.1 33.53,45.33 34.47,46.27 v5(34.47,46.7)
  vias: v2(21.07,38.63) v3(18.16,39.13)
PD1_LSRX: length 4.2
  BOTTOM w0.076: UT1.K4 34.43,67.09 34.43,67.68 34.32,67.79 34.32,67.88
  BOTTOM w0.112: 34.32,67.88 34.32,67.91 33.92,68.3 32.55,68.3 31.89,68.96 TC7.1
PD1_LSTX: length 5.1
  BOTTOM w0.112: UT1.L4 34.69,67.66 34.53,67.82 34.53,68.03 34.04,68.52 32.68,68.52 31.48,69.71 RT2.2
PD1_OTG_ID: length 78.7
  IN1 w0.066: v10(48.8,121.09) 49.09,121.38 v8(50.39,121.38)
  IN2 w0.066: v10(48.8,121.09) 48.76,121.09 48.3,121.54 48.07,121.54 47.67,121.14 46.92,121.14 46.8,121.27 45.89,121.27 45.47,120.85 45.47,120.07 v4(43.93,118.53)
  IN3 w0.066: v6(43.79,118.1) 43.93,118.24 v4(43.93,118.53) ; v5(43.26,62.8) 44.65,64.2 v7(52.7,64.2)
  IN4 w0.066: v6(43.79,118.1) 43.18,117.36 43.18,111.56 45.99,108.75 46.83,108.75 47.22,108.37 47.22,105.78 49.68,103.31 49.68,100.16 50.3,99.55 50.3,90.93 50.59,90.64 50.59,83.52 52.04,82.07 52.04,81.53 53.64,79.94 53.64,67.6 52.34,66.3 52.34,64.56 v7(52.7,64.2)
PD1_SBU1: length 2.5
  BOTTOM w0.076: 36.95,67.85 36.95,67.83 36.93,67.82 36.93,67.1 36.69,66.85 UT1.K8
  BOTTOM w0.112: RT117.1 37.23,68.59 37.23,68.23 36.95,67.95 36.95,67.85
PD1_SBU2: length 2.7
  BOTTOM w0.076: 36.73,67.85 36.73,67.83 36.75,67.82 36.75,67.71 36.68,67.63 36.51,67.63 36.45,67.57 36.45,67.18 36.53,67.11 36.63,67.11 36.69,67.17 UT1.L8
  BOTTOM w0.112: 36.73,67.85 36.73,68.04 37.01,68.32 37.01,68.59 RT118.1
PD1_USBC_AMSEL: length 71.6
  IN3 w0.066: v5(22.7,36.13) 22.82,36.13 22.88,36.19 27.56,36.19 30.71,39.33 34.47,39.33 35.66,38.14 37.79,38.14 39.74,36.2 41.21,36.2 41.76,35.65 44.93,35.65 46.23,36.95 v6(46.23,37.68)
  IN4 w0.066: v6(46.23,37.68) 46.53,37.99 46.53,40.71 46.17,41.08 46.17,42.89 46.31,43.04 46.31,45.78 41.14,50.94 36.39,50.94 35.79,51.54 35.79,55.68 36.38,56.27 36.38,57.3 35.93,57.75 35.93,58.73 35.42,59.25 35.31,59.25 32.77,61.79 ; v1(30.23,70.3) 30.8,69.72 30.8,68.2 32.27,66.73 32.27,62.29 32.64,61.92
  IN4 w0.076: 32.77,61.79 32.64,61.92
  BOTTOM w0.112: UV1.23 v5(22.7,36.13)
