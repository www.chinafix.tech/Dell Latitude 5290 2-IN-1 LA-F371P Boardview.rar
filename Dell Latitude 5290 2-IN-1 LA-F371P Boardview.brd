# Allegro board Dell Latitude 5290 2-IN-1 LA-F371P Boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3V_PRIM_R: length 1.5
  BOTTOM w0.112: R145.1 48.86,90.37 v2(48.63,90.6)
+3V_RF: length 3.3
  IN1 w0.508: v8(113.39,169.36) 113.5,169.36 113.87,168.98 113.87,166.98 v8(113.39,166.5)
  vias: v2(112.08,164.68)
+3V_SKYCAM: length 63.6
  IN3 w0.508: v7(154.52,149.12) 154.52,143.32 v5(153.29,142.09) v5(151.3,140.1)
  IN4 w0.254: v5(151.3,140.1) 151.3,140.21 v1(150.35,141.16) 150.2,141.16 149.95,141.41 v1(149.95,141.56)
  IN4 w0.381: v1(149.55,143.96) v1(149.95,143.56)
  IN4 w0.508: v1(127.38,156.69) 127.46,156.62 127.46,154.26 129.89,151.83 136.49,151.83 141.02,151.83 141.24,151.6 144.06,148.78 v1(147.89,148.78) ; v7(143.61,145.48) 144.53,146.4 146.15,146.4 146.94,145.61 v1(147.74,145.61) 147.9,145.61 v1(149.55,143.96)
  BOTTOM w0.102: v1(149.95,141.56) v1(150.35,141.16)
  BOTTOM w0.127: v1(149.55,143.96) v1(149.95,143.56)
  BOTTOM w0.356: R431.1 v1(127.38,156.69) ; v7(154.52,149.12) R93.1 ; v7(154.52,149.12) 155.07,149.67 157.31,149.67 157.67,149.32 157.67,148.43 R91.1 ; v7(154.52,149.12) 153.21,150.43 149.91,150.43 148.26,148.78 v1(147.89,148.78)
  BOTTOM w0.381: v7(143.61,145.48) C46.1
  vias: v2(150.85,140.01)
+3VALW: length 546.6
  TOP w0.254: PR1103.1 62.8,161.06 v8(62.81,161.08) ; Q354.5 v3(125.9,92.56) Q354.2 ; PR817.1 53.54,141.54 PR818.1 53.87,142.69 54.05,142.86 54.05,143.68 54.61,144.24 54.61,144.85 55.24,145.48 v7(55.24,145.61) ; v8(45.53,142.9) 45.53,142.88 45.52,142.86 PR735.2 ; PR1101.1 v8(79.69,160.4)
  TOP w0.508: v7(133.54,140.34) PR707.1 PR709.1 134.1,141.23 PR725.2 ; PR127.1 144.64,136.67 144.7,136.73 v7(144.7,136.96) ; v3(128.52,125.67) 128.02,126.18 PR804.1 ; PR503.2 116.4,122.3 116.97,122.87 v3(117.79,122.87) 118.59,122.87 119,123.28 PR734.2 ; v7(47.82,148.66) 47.83,148.67 PR813.2 ; v3(32,17.85) 31.62,18.23 30.99,18.23 PC286.1 ; v8(139.22,131.09) 138.94,130.81 PR124.1 ; v7(38.86,18.61) 39.05,18.42 U8.5 ; PR174.1 141.93,128.34 141.42,127.83 v7(141.42,127.73) ; v3(21.36,31.54) 21.34,31.56 PR262.1 ; PU105.5 31.62,19.12 30.99,18.48 PC286.1 ; PR610.2 103.56,123.64 106.98,127.07 111.38,127.07 111.72,126.72 v3(111.72,126.05) ; PR265.1 19.43,18.99 19.81,19.37 PR264.1 20.19,20.39 v3(20.38,20.39) ; PR705.2 130.56,136.92 133.02,136.92 v12(134.47,135.47) ; PC286.1 PR249.1
  IN1 w0.254: v8(45.53,142.9) 45.53,143.82 v10(45.52,143.83)
  IN1 w0.508: v7(141.42,127.73) 141.42,128.04 140.26,129.2 140.26,129.71 139.22,130.76 v8(139.22,131.09) 138.94,131.37 138.57,131.37 v12(134.47,135.47) ; v3(20.38,20.39) 20.41,20.41 23.22,20.41 24.49,19.14 26.14,19.14 28.19,17.08 31.11,17.08 31.88,17.85 v3(32,17.85) ; v8(123.19,130.8) 123.65,130.34 123.65,129.35 122.05,127.75 122.05,125.72 121.36,125.03 119.95,125.03 v3(117.79,122.87) ; v8(93.28,158.83) 92.32,158.83 90.25,160.9 87.66,160.9 86.23,162.32 82.31,162.32 80.72,160.73 80.02,160.73 v8(79.69,160.4) 79.22,160.4 79.01,160.62 73.99,160.62 72.29,162.32 65.44,162.32 64.2,161.08 v8(62.81,161.08) 62.51,161.08 61.44,160.01 56.26,160.01 54.41,158.15 54.41,157.39 54.05,157.04 53.71,157.04 v8(52.96,156.29) 50.52,153.85 50.52,148.76 49.94,148.17 49.07,148.17 48.59,148.66 v7(47.82,148.66)
  GND1 w0.508: v4(135.12,135.31) 134.63,135.31 v12(134.47,135.47)
  IN2 w0.254: v10(45.52,143.83) v4(45.09,143.83) ; v4(125.43,92.72) 125.59,92.56 v3(125.9,92.56)
  IN2 w0.508: v7(62.05,12.36) 62.05,12.5 58.79,15.76 58.79,16.75 54.7,20.84 44.73,20.84 43.26,19.37 v7(39.5,19.37) 38.68,20.18 37.44,20.18 36.6,19.34 33.5,19.34 v3(32,17.85) ; v7(144.7,136.96) 144.71,136.98 146.53,136.98 149.64,140.1 151.31,140.1 v3(151.89,139.51) ; v3(111.51,165.97) v4(111.51,165.06) ; v3(128.52,125.67) 126.95,125.67 v7(126.06,124.78) 125.73,124.45 118.84,124.45 118.33,123.94 118.33,123.42 v3(117.79,122.87) 117.09,122.87 114,125.97 111.87,125.97 111.79,126.05 v3(111.72,126.05) ; v3(21.36,31.54) 21.18,31.54 20.7,31.05 20.7,23.43 20.92,23.22 20.92,22.25 20.38,21.72 v3(20.38,20.39)
  IN2 w0.762: 116.93,103.23 114.88,101.18 114.88,96.86 112.22,94.2 v3(112.22,93.66)
  IN3 w0.254: v6(22.86,127.19) 23.11,127.45 27.81,127.45 28.07,127.19 v6(28.45,127.19)
  IN3 w0.508: 38.01,96.93 36.13,96.93 34.82,98.24 33.3,98.24 31.85,96.79 28.75,96.79 28.22,97.32 28.22,97.91 ; v7(35.43,134.2) 35.53,134.3 39.55,134.3 43.82,138.57 48.31,138.57 ; v7(144.7,136.96) 144.7,137.75 142.97,139.47 134.4,139.47 v7(133.54,140.34) ; v7(47.82,148.66) 47.54,148.93 44.17,148.93 41.25,151.86 40.41,151.86 33.96,158.31 33.96,159.84 v7(34.14,160.02) v7(36.14,160.02) ; 47.32,143.68 45.24,143.68 v4(45.09,143.83) 43.97,144.95 40.03,144.95 38.83,143.75 37.81,143.75 37.76,143.8 37.5,143.8 v6(37.36,143.93) ; v5(54.24,106.87) 54.93,106.87 55.29,106.51 v4(57.16,106.51) ; 39.33,96.93 41.47,96.93 42.9,95.49 42.9,94.02 44.65,92.27 v4(45.63,92.27) ; v5(139.42,93.16) v4(139.85,93.16) ; v4(111.51,165.06) 112.56,164.01 v6(112.79,164.01)
  IN3 w2.032: 19.74,83.31 19.74,82.75 20.9,81.59 22.68,81.59
  GND3 w0.508: v4(135.12,135.31) v15(134.68,135.31)
  IN4 w0.254: v6(28.45,127.19) 28.52,127.12 28.52,126 27.81,125.29 27.81,124.14 27.41,123.74 v1(27.41,123.51)
  IN4 w0.508: 23.16,128.51 22.91,128.26 22.91,127.24 v6(22.86,127.19) 20.87,125.2 20.87,124.8 20.84,124.77 20.84,124.76 20.81,124.73 20.81,123.16 20.77,123.12 ; v7(47.82,148.66) 47.82,143.51 47.9,143.6 v6(48.01,143.6) ; v6(112.79,164.01) 112.8,164 118.07,164 121.34,160.73 121.34,154.42 v1(126.16,149.59) ; v1(27.75,102.92) 27.83,102.92 28.05,102.69 28.05,100.01 ; 15.29,114.95 15.24,114.95 13.56,113.27 13.56,105.51 v6(13.63,105.44) ; v7(34.75,133.72) 35.05,133.42 35.05,132.68 34.12,131.75 34.12,128.07 34.62,127.57 34.62,124.96 35,124.58 35,124.25 ; 29.79,50.99 30.25,51.45 33.68,51.45 34,51.77 34,56.81 32.96,57.85 29.03,57.85 28.08,58.8 28.08,59.52 28.45,59.88 v1(30.15,59.88) ; v7(133.54,140.34) 134.24,139.64 134.24,137.35 134.68,136.91 v15(134.68,135.31) 134.68,133.86 134.04,133.22 134.04,131.06 133.18,130.2 132.18,130.2 131.55,129.57 131.55,127.98 128.55,124.98 126.26,124.98 v7(126.06,124.78) ; v7(35.43,134.2) 35.43,134.71 34.14,136.01 34.14,138.27 35.37,139.5 35.37,140.63 35.73,140.99 35.73,142.25 36.89,143.41 36.89,143.46 v6(37.36,143.93) ; 16.48,93.59 15.52,94.55 14.25,94.55 13.28,95.52 13.28,96.66 13.43,96.81 13.43,104.21 13.63,104.4 13.63,105.52 ; v1(56.47,137.62) 56.09,137.24 55,137.24 53.15,139.08 51.03,139.08 50.19,138.24 48.97,138.24 ; 23.21,129.06 22.78,129.48 22.78,133.44 v7(23.24,133.9) ; 35.05,123.69 35.05,123.41 35,123.36 35,121.53 35.27,121.26 35.27,119.84 35.28,119.84 35.28,119.73 v5(35.43,119.58) 35.15,119.3 35.15,117.36 35.63,116.89 35.63,115.02 v1(35.75,114.89)
  BOTTOM w0.254: UE5.5 17.92,99.14 18.39,98.67 18.39,97.27 18.11,96.99 17.5,96.99 16.94,96.43 ; 55.14,147.23 54.38,147.23 54.22,147.4 53.7,147.4 52.98,148.11 48.36,148.11 v7(47.82,148.66) ; 55.14,147.23 PR950.1 ; 55.14,147.23 55.14,145.71 v7(55.24,145.61) ; PR950.1 PR940.1 ; PR950.1 55.67,147.73 PR917.1 PR918.1 PR919.1 PR931.1
  BOTTOM w0.305: JAPS1.12 v7(34.14,160.02) ; JAPS1.16 v7(36.14,160.02)
  BOTTOM w0.356: 25.86,96.18 25.68,96 R5773.1
  BOTTOM w0.406: UC2.5 56.59,137.72 56.49,137.62 v1(56.47,137.62)
  BOTTOM w0.508: RT84.1 62.23,12.54 v7(62.05,12.36) ; v1(126.16,149.59) 132.6,149.59 134.87,147.32 134.87,143.31 134.15,142.58 134.15,140.95 v7(133.54,140.34) ; PR143.1 145.66,136.01 v7(144.7,136.96) ; PR175.1 148.04,129.47 v7(148.65,128.86) ; UC8.5 36.5,112.41 36.93,112.84 36.93,113.76 36.01,114.68 UC7.5 ; C236.2 31.37,99.8 32.05,100.48 QZ9.3 31.98,100.9 28.46,100.9 27.91,100.36 ; PR805.1 v7(126.06,124.78) ; PR142.1 141.79,128.09 v7(141.42,127.73) ; R234.1 54.25,105.97 RC394.2 ; R234.1 54.24,105.36 54.08,105.2 Q352.3 ; R234.1 v5(54.24,106.87) ; 25.86,96.18 25.86,98.26 26.16,98.57 26.84,98.57 27.67,99.4 ; v7(39.5,19.37) C42.1 38.81,18.66 v7(38.86,18.61)
  vias: v1(16.36,114.92) v1(16.36,114.59) v1(16.89,93.46) v1(16.89,93.13) v1(23.52,128.82) v1(23.52,128.56) v1(34.62,124.02) v1(34.57,123.61) v1(38.39,98.41) v1(38.66,98.43) v3(25.02,48.29) v4(27.71,50.97) v4(52.94,89.73) v4(52.93,89.22) v5(16.45,105.59) v5(19.37,84.66) v5(19.37,84.35) v5(19.67,84.66) v5(19.67,84.35) v5(20.55,122.53) v5(20.88,122.53) v5(28.13,99.56) v5(28.13,99.25) v5(52.4,89.73) v5(52.41,89.26) v6(13.64,105.74) v6(17.5,121.99) v6(17.5,121.63) v6(28.09,50.99) v6(28.4,50.99) v6(38.51,96.97) v6(38.81,96.97) v6(47.68,143.65) v6(48.34,138.6) v6(48.64,138.57) v7(24.14,81.68) v7(24.4,81.18) v7(24.75,81.7) v7(24.93,80.58) v7(24.96,81.17) v7(25.34,81.71) v7(25.51,81.14) v7(25.49,80.58) v7(26.01,80.86) v7(34.82,134.33) v7(51.8,83.94) v7(52.39,84.52) v7(52.39,83.94) v7(52.97,83.94) v7(53.56,83.94) v7(68.72,91.07) v7(69.22,90.79) v7(69.32,90.24) v7(69.84,90.45) v7(71.79,22.1) v7(71.79,21.52) v7(72.03,21.01) v7(72.61,21.01) v7(74.61,20.77) v7(75.18,20.77) v7(117.6,103.32) v7(117.6,102.68) v7(118.24,103.32) v7(118.24,102.68) v7(118.87,103.32) v7(118.87,102.68) v7(119.51,103.32) v7(119.51,102.68) v7(120.14,103.32) v7(120.14,102.68) v7(120.78,103.32) v7(120.78,102.68) v7(142.7,91.71) v9(17.56,80.74) v9(19.74,81.97) v9(23.33,81.21)
+3VALW_PD1: length 11.2
  IN4 w0.508: v1(31.22,66.23) 31.67,65.77 v1(31.67,61.74)
  BOTTOM w0.254: UT1.B1 32.86,62.83 31.76,61.74 v1(31.67,61.74) 31.14,61.74 CT18.1 ; v1(31.22,66.23) 32.21,66.23 32.6,65.84 UT1.H1
  BOTTOM w0.508: RT50.2 RT37.2 CT18.1
+3VALW_PD2: length 24.8
  IN3 w0.508: v7(56.01,10.35) 61.72,10.35 62.81,11.44 62.81,13.32 62.23,13.91 v7(62.23,14.54)
  IN4 w0.508: v5(55.13,14.48) 55.18,14.48 55.63,14.04 55.63,13.15 56.01,12.77 v7(56.01,10.35)
  BOTTOM w0.254: UT2.B1 58.13,15.21 58.55,14.8 59.26,14.8 CT29.1 ; UT2.H1 v5(55.13,14.48)
  BOTTOM w0.356: v7(56.01,10.35) 55.44,10.35 54.23,11.56 CT33.1
  BOTTOM w0.508: v7(62.23,14.54) RT84.2 RT85.2 CT29.1
+3VALW_TPM: length 1.3
  BOTTOM w0.112: C229.1 v2(36.96,98.69)
+3VALW_USH:
  vias: v1(142.06,90.06) v1(142.29,90.21) v2(136.75,93.52) v7(136.83,93) v7(137.57,93)
+3VALWP: length 13.3
  TOP w0.127: v2(122.7,109.47) 122.64,109.41 120.75,109.41
  IN2 w0.254: v3(117.7,117.54) 117.78,117.47 117.78,107.39 118.17,107 v7(118.75,107)
  vias: v7(119.63,107)
+3VLP: length 120.2
  TOP w0.254: v3(116.36,114.57) 116.36,115.52 PR519.1 ; v3(31.85,104.81) 38.97,104.81 v2(39,104.85) 44.08,104.85 59.09,96.58 59.39,96.28 v8(59.39,95.5)
  IN1 w0.254: v8(59.39,95.5) 60.16,95.5 61.7,97.04 v10(61.7,97.3)
  IN2 w0.254: v4(110.82,98.24) 112.24,98.24 113.39,99.38 113.39,104.08 115.9,106.59 115.9,114.11 v3(116.36,114.57) ; v4(31.85,105.27) v3(31.85,104.81) ; v10(61.7,97.3) 61.77,97.22 61.77,96.33 62.28,95.82 63.19,95.82 63.37,96 v4(63.37,96.48)
  IN3 w0.254: v4(110.82,98.24) v5(110.82,97.58) ; v5(63.68,96.23) 63.42,96.48 v4(63.37,96.48)
  BOTTOM w0.254: v5(63.68,96.23) 63.47,96.03 63.47,90.17 65.42,88.23 106.36,88.23 110.08,91.95 110.08,95.01 110.82,95.75 v5(110.82,97.58)
  vias: v5(31.88,105.73)
+3VS: length 846.8
  TOP w0.203: JUFC1.30 125.16,173.19 125.82,173.85 CS10.1
  TOP w0.254: RH3.1 49.08,122.21 v3(49.23,122.36) 49.23,122.37 50.19,122.37 RH4.1 ; RS18.2 3.17,120.89 3.17,122.8 3.84,123.46 5.96,123.46 v7(6.71,122.71) 6.71,120.55 RS19.2
  TOP w0.381: v7(127.05,172.28) 127,172.28 126.78,172.06 RS23.1 RS24.1 ; RS22.1 v7(127.03,170.88)
  TOP w0.508: v3(55.24,139.52) 55.37,139.4 RC9.1 ; v7(124.9,174.27) 124.93,174.25 125.53,174.25 CS10.1 ; R32.1 v7(101.66,119.7) ; 54.31,97.02 51.3,97.02 50.28,98.04 v7(45.07,98.04) 45.18,97.92 45.18,93.39 44.35,92.55 43.36,92.55 41.38,90.57 41.38,87.49 40.74,86.86 32.94,86.86 32.44,87.36 32.44,87.67 31.74,88.37 31.74,89.64 32.44,90.34 32.44,91.29 32.08,91.64 R456.2 ; 25.16,103.32 24.52,102.68 24.52,99.06 24.26,98.79 24.26,91.89 25.08,91.06 ; RC38.1 49.83,136.44 v7(49.9,136.37) ; RS17.1 v7(6.39,113.15) ; 44.13,128 43.15,128 42.06,126.92 v7(42.06,126.56) 42.06,126.4 42.6,125.87 RN2.1 RN1.1
  IN1 w0.508: v7(127.03,170.88) 127.03,170.68 128.63,169.08 128.63,156.66 127.53,155.57 127.53,152 128.55,150.98 128.55,150.15 129.58,149.12 131.26,149.12 131.83,148.56 131.83,144.81 132.3,144.34 135.22,144.34 136.21,145.33 136.21,146.9 137.05,147.74 140.86,147.74 v10(141.03,147.56) ; v7(11.07,108.29) 11,108.37 11,109.21 7.49,112.71 6.82,112.71 v7(6.39,113.15) 6.76,113.51 7.07,113.51 7.85,114.29 7.85,121.12 6.71,122.26 v7(6.71,122.71) 7.06,123.06 8.84,123.06 v7(9.29,123.51) ; 25.7,104.05 25.7,104.92 26.12,105.34 26.43,105.34 28.11,107.01 ; 25.76,90.51 26.06,90.51 26.57,91.02 28.73,91.02 29.04,91.33 29.92,91.33 30.28,90.97 31.24,90.97 31.57,91.3 ; v8(58.59,96.12) 59.96,96.12 61.14,97.3 61.14,99.63 62.98,101.48 62.98,102.13 62.48,102.63 62.48,103.07 61.9,103.66 61.9,104.79 60.71,105.98 60.71,106.67 v3(60.76,106.72)
  IN2 w0.254: v4(54.83,138.85) 55.24,139.26 v3(55.24,139.52) ; v3(49.23,122.36) 49.23,121.89 49,121.67 48.59,121.67 48.45,121.81 47.97,121.81 47.56,121.41 47.03,121.41 46.91,121.53 45.78,121.53 45.21,120.96 45.21,120.18 44.29,119.25 43.91,119.25 v4(43.54,118.89)
  IN2 w0.508: v4(154.01,137.14) 153.64,137.5 v3(153.64,138.62) ; v4(61.26,106.99) 60.99,106.72 v3(60.76,106.72) ; v4(30.79,121.11) 30.79,115.56 30.81,115.54 30.81,115.28 30.91,115.17 v3(30.91,109.39) ; v7(45.07,98.04) 45.01,97.98 45.01,92.03 45.73,91.32 48.45,91.32 48.85,90.91 48.85,84.27 48.34,83.76 48.34,54.33 41.48,47.46 v4(41.48,47.33) ; v4(26.45,136.65) 24.38,134.59 18.77,134.59 9.29,125.1 v7(9.29,123.51) ; v10(141.03,147.56) 141.17,147.56 v4(141.4,147.33)
  IN2 w1.016: 28.22,143.24 28.35,143.24 35.37,150.26 35.37,155.07 31.75,158.69 31.75,162.75
  IN3 w0.254: v5(4.69,138.12) 5.23,137.58 v5(8.45,137.58) 10.41,137.58 v5(10.43,137.57) 11.68,137.57 v5(12.64,136.62)
  IN3 w0.457: v4(43.54,118.89) 40.83,121.6 40.83,126.02 41.27,126.47 41.97,126.47 v7(42.06,126.56)
  IN3 w0.508: v7(138.62,103.89) 139.81,105.08 147.88,105.08 ; 147.88,105.08 148.03,105.23 148.03,106.34 158,116.32 158,133.43 159.51,134.94 159.51,136.05 157.8,137.76 v6(154.52,137.76) 154.01,137.25 v4(154.01,137.14) ; 147.88,105.08 148.96,105.08 149.58,104.46 149.58,96.25 147.65,94.32 146.79,94.32 145.19,92.72 145.19,88.99 145.16,88.97 ; v7(71.5,46.62) 48.06,46.62 47.35,47.33 v4(41.48,47.33) 41.34,47.19 v5(41.34,46.64) ; v5(54.23,112.08) 53.99,111.84 53.99,111.31 55.31,110 58.32,110 59.85,108.47 60.55,108.47 61.51,107.51 61.51,107.25 v4(61.26,106.99) ; 41.39,140.59 v5(37.34,140.59) 37.13,140.59 36.64,141.09 34.09,141.09 33.12,140.13 29.87,136.88 29.26,136.88 28.5,136.11 27.07,136.11 v5(26.99,136.2) ; v4(54.83,138.85) 54.81,138.88 53.9,138.88 53.85,138.92 53.21,138.92 50.3,141.82 45.92,141.82 45.73,141.62 43.81,141.62 43.08,141.62 42.49,141.62 42.17,141.3 ; v6(141.69,147.05) v4(141.4,147.33) ; v5(119.24,158.35) v5(119.24,160.05) 119.24,164.67 115.32,168.59 112.65,168.59 111.52,169.72 111.52,170.7 ; 18.77,101.41 17.32,101.41 17.14,101.23 15.47,101.23 11.97,104.73 11.97,107.4 v7(11.07,108.29)
  IN3 w1.016: 110.62,170.37 110.62,168.43 108.9,166.71 41.07,166.71 38.37,164.02 33.27,164.02
  IN4 w0.508: v7(127.03,170.88) 127.05,170.91 v7(127.05,172.28) 126.92,172.28 124.93,174.27 v7(124.9,174.27) 123.28,175.9 114.74,175.9 113.29,174.44 111.35,174.44 110.85,173.93 v7(110.85,171.38) ; v7(138.62,103.89) 138.62,100.75 137.92,100.05 130.63,100.05 129.44,98.86 119.6,98.86 115.14,103.33 115.14,113.88 115.68,114.43 115.68,116.07 115.18,116.57 103.58,116.57 101.66,118.49 v7(101.66,119.7) ; v1(47.4,116.37) 47.12,116.37 46.91,116.57 44.97,116.57 44.3,117.25 44.3,120.31 v1(44.01,120.6) ; 42.11,140.2 41.41,140.2 40.94,139.73 40.94,139.6 40.34,138.99 40.11,138.76 40.11,136.37 40.5,135.98 40.5,134.57 40.35,134.42 40.35,131.89 40.34,131.88 40.34,130.99 40.32,130.96 40.32,129.38 42.06,127.63 v7(42.06,126.56) ; v1(81.32,24.91) 77.98,24.91 77.62,24.55 76.66,24.55 75.9,25.31 75.9,30.65 73.86,32.68 73.86,35.37 73.96,35.48 73.96,38.42 73,39.38 73,45.12 v7(71.5,46.62) ; v6(141.69,147.05) 142.26,146.48 142.26,143.39 143.25,142.4 143.25,140.22 145.29,138.18 146.02,138.18 147.81,136.39 152.3,136.39 153.67,137.76 v6(154.52,137.76) 157.78,137.76 159.49,136.05 159.49,131.66 v1(158.95,131.13)
  IN4 w1.016: 26.66,134.88 26.66,126.66 25.96,125.96 25.96,124.97
  BOTTOM w0.254: RS20.1 7.82,147.84 3.91,143.93 3.91,138.9 v5(4.69,138.12)
  BOTTOM w0.356: 45.54,121.22 45.78,121.22 46.2,121.64 46.2,122.84 46.35,123 46.77,123 RH505.2 47.6,122.59 48.01,123 RC190.1 ; v7(9.29,123.51) 12.15,126.37 12.15,133.06 12.64,133.54 v5(12.64,136.62)
  BOTTOM w0.381: RC194.1 51.74,128.84 RH29.2 ; RC97.1 43.8,137.17 44.39,136.59 46.61,136.59 47.67,137.65 UC3.5
  BOTTOM w0.406: 45.54,121.22 44.92,120.6 v1(44.01,120.6) 43.61,120.6 43.31,120.91 43.31,125.31 v7(42.06,126.56) 42.06,128.16 RC200.2 44.37,128.59 46.43,128.59
  BOTTOM w0.508: UC3.5 48.79,137.65 49.9,136.54 v7(49.9,136.37) ; R454.2 44.61,98.49 v7(45.07,98.04) 45.07,96.57 44.59,96.09 R5750.1 ; v5(37.34,140.59) 37.34,138.57 37.22,138.46 R110.2 ; RC191.1 48.01,126.63 47.5,127.14 47.5,128.44 47.5,128.59 ; 46.43,128.59 47.5,128.59 ; 47.5,128.59 50.57,128.59 RH30.2 RH29.2 ; v5(41.34,46.64) 36.97,51 v9(27.83,51) 26.45,51 25.6,50.15 CV18.1 CV17.1 24.05,50.15 23.91,50.29 RV2.1 ; RC97.1 43.18,137.42 42.67,137.92 42.67,139.59 ; RC153.1 RC157.1 54.23,115.46 RC159.1 RC161.1 RC163.1 RC168.1 54.15,112.16 v5(54.23,112.08) 54.23,111.84 54.09,111.7 54.09,111.64 53.63,111.18 52.7,111.18 51.94,111.94 51.94,114.11 51.44,114.62 50.16,114.62 48.64,116.14 47.62,116.14 v1(47.4,116.37)
  vias: v1(42.21,139.97) v1(42.44,140.25) v4(26.91,143.05) v4(27.35,143.06) v5(19.06,100.97) v5(19.19,101.2) v5(26.54,136.21) v5(26.8,135.96) v5(142.11,89.6) v5(142.32,89.42) v5(144.87,88.52) v6(25.71,122.76) v6(25.86,122.54) v6(26.01,122.76) v6(26.14,122.52) v6(26.8,143.45) v6(27.11,143.45) v6(41.66,140.86) v6(41.88,141.09) v7(31.75,163.77) v7(32.26,164.28) v7(110.26,171.38) v7(111.43,171.38) v8(25.43,90.72) v8(25.58,90.36) v8(25.7,103.49) v8(25.73,103.04) v8(28.32,107.58) v8(28.52,107.35) v8(31.64,91.75) v8(31.8,91.54)
+3VS_AUDIO: length 12.4
  IN3 w0.508: v5(28.83,139.35) 28.64,139.54 23.93,139.54 v5(23.75,139.71)
  BOTTOM w0.127: v5(28.83,139.35) 29.25,139.35 v9(29.93,140.03)
  BOTTOM w0.356: v5(28.83,139.35) 27.9,139.35 RA29.1
  BOTTOM w0.508: v5(23.75,139.71) 22.62,139.71 R111.2 22.48,139.7 21.6,140.58 RA26.1
+3VS_AUDIO_R: length 1.4
  BOTTOM w0.112: 22.61,138.2 v2(23.61,137.2)
+3VS_CAM: length 1.4
  BOTTOM w0.127: R94.2 145.22,146.97 v9(145.28,146.92)
+3VS_CR:
  vias: v1(67.18,28.44) v1(68.45,37.2) v1(69.34,37.2) v1(70.15,29.28) v1(70.15,28.39) v9(69.41,27.05)
+3VS_CR_R: length 1.6
  BOTTOM w0.112: v2(70.54,24.82) 71.12,25.4 R205.1
+3VS_ECOM: length 17.3
  TOP w0.112: U3.10 v2(4.76,115.13) 4.76,114.76 CS6.1 4.06,114.49 4.26,114.69 U3.9 ; U3.3 3.76,117.99 4.95,119.18 v8(4.95,119.65)
  TOP w0.508: CS6.1 4.6,114.06 CS9.1 5.09,113.83 5.32,114.06 v8(5.65,114.06)
  IN1 w0.508: v8(5.65,114.06) 6.45,114.06 7.14,114.75 7.14,119.09 6.58,119.65 v8(4.95,119.65)
+3VS_GYRO: length 53.3
  TOP w0.254: v7(7.62,150.18) v7(7.62,149.29) v7(7.62,146.93)
  BOTTOM w0.112: CS3.1 6.69,141.9 6.76,141.97 LGA1.12 ; LGA1.8 10.47,140.67 10.73,140.4 12,140.4 12.51,140.91 12.51,148.4 10.73,150.18 v7(7.62,150.18) ; CS4.1 9.14,146.37 9.47,146.05 LGA1.2 ; LGA1.1 8.97,145.79 8.26,146.5 RS20.2 ; CS5.1 9.97,146.78 LGA1.3 ; LGA1.5 11.59,142.97 11.94,143.32 11.94,147.89 10.54,149.29 v7(7.62,149.29)
  BOTTOM w0.254: CS5.1 9.82,146.93 CS4.1 RS20.2 v7(7.62,146.93) 4.45,143.75 4.45,142.25 v2(4.52,142.18) 4.8,141.9 CS3.1
+3VS_IR: length 1
  TOP w0.127: C1037.1 v2(13.5,100.27)
  vias: v3(26.64,104.38) v3(26.95,104.38) v4(26.56,102.72) v5(25.98,102.43) v5(26.29,102.43)
+3VS_IR_R: length 2.4
  BOTTOM w0.508: R223.1 QZ9.1
+3VS_MUX: length 104.5
  TOP w0.381: RV59.1 30.39,26.77 30.1,26.48 27.52,26.48 v8(27.18,26.82)
  TOP w0.508: QC2.5 QC2.2 29.23,37.13 28.96,37.4 28.96,38.42 28.45,38.93 v7(28.45,39.31)
  IN1 w0.508: v10(27.18,30.75) v8(27.18,26.82)
  IN2 w0.508: v4(18.34,31.51) 18.34,30.7 v4(17.6,29.96) ; v4(26.29,35.24) 25.87,35.66 v4(25.87,39.63) 25.87,42.61 26.06,42.8 26.06,43.63 25.67,44.02 25.67,45.04 25.27,45.43 v4(25.27,46.17) ; v4(27.01,31.14) 27.18,30.98 v10(27.18,30.75)
  IN3 w0.508: v4(26.29,35.24) 24.8,35.24 v5(24.38,34.82) 23.84,35.37 22.53,35.37 22.3,35.6 21.36,35.6 20.57,34.81 v5(20.57,34.48) v5(20.57,33.16) ; v5(22.66,46.17) v4(25.27,46.17) 26.28,46.17 v5(26.35,46.09) ; v5(19.56,47.87) 19.56,45.98 20.11,45.43 22.59,45.43 v5(22.69,45.53) ; v4(17.6,29.96) 17.07,29.43 v5(17.07,29.4) 16.94,29.53 15.75,29.53 14.95,28.73 14.95,21.64 16.21,20.39 v5(17.32,20.39) 17.69,20.75 19.65,20.75 19.71,20.82 21.41,20.82 21.76,20.47 v5(21.97,20.47) 22.69,21.2 23.7,21.2 24.97,19.93 v5(25.5,19.93) ; 25.76,31.14 23.74,31.14 23.1,30.51 v5(22.86,30.51) 21.7,30.51 20.7,31.51 v4(18.34,31.51) 18.03,31.82 v5(16.78,31.82) ; v7(28.45,39.31) 26.67,39.31 26.35,39.63 v4(25.87,39.63)
  BOTTOM w0.356: RV81.2 20.89,33.48 v5(20.57,33.16) ; 25.53,32.75 24.65,32.75 23.69,33.71 23.69,34.82 RV58.1 ; 26.54,32.75 v5(26.54,31.14) 26.59,31.09 RV83.2 RV85.2 ; RV27.2 26.92,46.78 RV77.2 26.37,46.1 v5(26.35,46.09)
  BOTTOM w0.381: 25.91,32.98 25.91,34.48 25.57,34.82 v5(24.38,34.82)
  BOTTOM w0.508: RV73.1 v2(28.12,33.9) 27.05,32.83 ; RV43.2 17.55,33.16 17.09,32.7 RV13.2 v5(16.78,31.82) ; RV6.2 20.19,47.87 v5(19.56,47.87) 19.46,47.77 RV75.2 18.8,47.16 18.2,46.56 17.44,46.56 16.89,46.01 RV19.2 ; RV28.2 RV27.2 ; RV37.2 16.65,20.39 v5(17.32,20.39) RV41.2
+3VS_MUX_UV1: length 6.2
  IN3 w0.254: v5(25.87,39.05) 26.92,38 v5(26.92,37.49)
  BOTTOM w0.254: UV1.17 25.42,39.2 25.57,39.05 v5(25.87,39.05) ; v5(26.92,37.49) 26.92,37.39 v2(27.18,37.14) 28.07,37.14 RV73.2 29.07,37.19 RV74.1
+3VS_MUX_UV2: length 10.7
  BOTTOM w0.254: RV71.2 RV72.1 28.47,30.57 28.47,29.02 v2(27.74,28.28) 27.3,27.85 27.3,25.34 27.18,25.21 CV57.1 27.13,24.66 25.57,24.66 25.38,24.85 UV2.17
+3VS_TPM: length 4.8
  BOTTOM w0.508: 43.19,92.93 R5750.2 43.19,96.29 44.18,97.28 R453.2
  vias: v2(43.28,88.06) v5(38.68,88.76) v5(38.68,88.43) v5(41.68,87.09) v5(42,86.87)
+3VS_TS: length 65.6
  TOP w0.356: RC393.1 64,86.67 64.39,86.27 Q351.2
  TOP w0.508: v8(63.98,85.33) 64.39,85.74 Q351.2
  IN1 w0.508: v8(63.98,85.33) 63.98,83.99 64.92,83.05 64.92,81.52 66.74,79.71 66.74,69.88 64.53,67.67 64.53,55.78 66.78,53.53 66.78,44.77 73.28,38.27 73.28,29.66 74.32,28.61 v7(75.21,28.61)
  vias: v3(85.03,28.7) v3(85.36,28.7) v4(84.65,29.08) v4(84.65,28.64) v5(84.26,29.02) v5(84.26,28.7) v9(76.11,29.24)
+3VS_U4: length 16.1
  TOP w0.254: R456.1 31.74,90.7 C228.1 30.2,91.35 28.88,91.35 28.64,91.11 C227.1 28.47,90.54 C28.1 27.93,91.2 27.94,91.22 U4.10 27.44,92 26.94,91.5 25.98,91.5 v2(25.78,91.7) 25.78,93.67 26.16,94.05 ; U4.1 26.56,96.6 26.01,96.05 26.01,94.2 26.16,94.05 ; 26.16,94.05 U4.6
+3VS_USH: length 0.8
  TOP w0.112: v2(138.56,93.69) 138.25,93.38 v8(138.25,93)
  vias: v4(142.14,92.8) v5(142.06,92.47) v5(142.32,92.47) v8(138.53,92.94) v10(141.6,93.08) v10(141.88,93.08)
+3VS_WLAN: length 24.8
  TOP w2.032: 18.8,62.8 18.8,65.6 27.05,73.85 27.14,73.85 28.91,75.63 28.91,78.02 27.78,79.16 27.78,81.56 26.85,82.49
  vias: v7(18.67,61.22) v7(18.67,60.58) v7(19.24,61.22) v7(19.24,60.58) v7(24.84,83.95) v7(24.84,83.31) v7(25.41,83.95) v7(25.41,83.31) v7(37.13,58.65) v7(37.13,58.07) v7(37.71,58.65) v7(37.71,58.07) v9(20.43,58.04)
+3VS_WWAN: length 0.9
  TOP w0.127: v9(24.83,89.98) 25.08,89.73 25.08,89.33 v7(25.16,89.26)
  vias: v3(16.03,124.53) v3(16.05,124.27) v3(16.31,124.55) v3(16.33,124.27) v3(33.2,121.65) v3(33.48,121.65) v3(34.21,122.75) v3(34.52,122.67) v4(16.1,123.86) v4(16.54,123.89) v4(26.52,83.16) v4(26.99,82.89) v4(31.2,89.28) v4(33.68,122.09) v4(34.06,122.37) v5(16.38,123.38) v5(16.46,124.4) v5(16.66,124.25) v5(16.98,123.57) v5(33.27,121.83) v5(33.99,121.83) v7(24.85,86.83) v7(25.07,87.38) v7(25.16,88.69) v7(25.16,88.11) v7(25.78,88.74) v7(26.02,89.26) v7(30.68,89.41)
+3VS_WWAN_R:
  vias: v2(21.67,88.72)
+5V_DOCK: length 1.3
  TOP w0.127: C37.1 72.59,64.31 v9(72.81,64.53)
+5V_DOCK_R: length 1.4
  TOP w0.127: U7.1 72.79,58.27 v2(73,58.07)
+5V_FAN: length 8
  TOP w0.127: v2(154.05,142.31) 153.89,142.14 C21.2
  TOP w0.508: R438.1 153.75,141.25 R446.2 ; R446.2 R445.2 ; R446.2 C21.2
  IN1 w0.508: v8(152.88,140.36) 152.78,140.26 v8(152.78,136.29)
+5V_USB_P1:
  vias: v4(12.27,97.73) v4(12.27,97.25) v4(12.75,97.73) v4(12.75,97.25) v4(13.23,97.73) v4(13.23,97.25) v5(18.62,96.94) v5(18.62,96.64) v5(18.62,96.33) v5(18.97,96.81) v5(19.15,96.59) v5(19.15,96.28) v5(19.46,96.59) v5(19.46,96.28) v7(29.77,99.56) v7(29.8,99) v7(29.93,98.41) v7(30.35,98.93) v7(30.49,98.39) v9(29.27,99.32) v10(11.32,98.05) v10(11.32,97.73) v10(11.32,97.41) v10(11.32,97.09) v10(11.61,98.05) v10(11.61,97.73) v10(11.61,97.41) v10(11.61,97.09) v10(11.9,98.05) v10(11.9,97.73) v10(11.9,97.41) v10(11.9,97.09)
+5VALW: length 347.4
  TOP w0.381: 68.1,99.23 68.47,99.6 UZ1.3
  TOP w0.508: C27.1 35.99,99.56 36.91,100.47 R54.1 37.36,101.23 37.36,103.62 36.91,104.08 31.57,104.08 30.91,103.42 R50.2 ; v7(34.54,93.44) 35.95,93.44 36.7,94.19 36.7,95.68 35.96,96.43 ; v3(62.56,98.67) 62.61,98.62 66.13,98.62 66.74,99.23 68.1,99.23
  IN1 w0.508: v8(125.01,134.06) 124.66,134.41 124.66,136.97 124,137.63 124,143.47 123.39,144.08 123.39,144.84 122.52,145.71 120.18,145.71 119.28,146.61 119.28,149.28 116.05,152.5 115.51,152.5 114.57,153.44 114.57,154.28 113.74,155.11 113.74,156.54 113.18,157.11 113.18,161.52 110.58,164.13 v7(109.01,164.13)
  IN2 w0.508: v4(62.76,96.38) 62.7,96.38 62.53,96.55 62.53,98.64 v3(62.56,98.67) ; v7(109.01,164.13) 108.83,164.3 106.78,164.3 105.59,165.49 54.92,165.49 53.56,164.12 43.91,164.12 43.13,163.34 v7(43.13,162.65)
  IN3 w0.508: v6(62.17,96.65) 62.5,96.65 v4(62.76,96.38) ; v7(34.54,93.44) 34.52,93.44 34.47,93.49 28.75,93.49 28.4,93.13 20.47,93.13 v4(20.13,93.47) 18.73,93.47 16.51,91.25 16.51,89.34 17.04,88.82 18.03,88.82 18.43,88.42 v5(18.43,86.3) ; v5(53.17,87.21) 53.35,87.03 53.8,87.03 55.11,85.73 v6(62.99,85.73) v6(67.27,85.73) ; v6(63.88,23.69) 71.16,23.69 73.44,21.41 v5(73.44,21.05) ; v6(67.49,58.61) v5(42.68,58.61) ; v5(59.39,138.01) 59.39,136.72 58.36,135.7 57.21,135.7 53.89,132.37 v5(50.47,132.37) 51.18,133.08 51.18,137.81 49.81,139.18 43.53,139.18 41.32,136.97 36.7,136.97 36.32,137.35
  IN4 w0.508: v7(109.01,164.13) 109.01,164.12 109.74,163.39 111.86,163.39 113.39,161.86 113.39,156.66 116.08,153.96 119.85,153.96 122.05,151.76 v1(122.05,151.2) ; v6(67.27,85.73) 67.27,84.94 v1(68.4,83.81) ; v6(63.88,23.69) 59.47,28.09 v7(56.07,28.09) ; v6(62.17,96.65) 62.17,93.83 62.17,93.83 62.17,93.43 62.17,93.43 62.17,90.98 62.08,90.89 62.08,90.16 62.43,89.81 62.43,89.36 62.99,88.8 v6(62.99,85.73) 63.26,85.46 63.26,84.07 64.85,82.48 64.85,81.02 66.68,79.19 66.68,68.42 67.49,67.6 v6(67.49,58.61)
  BOTTOM w0.127: v7(55.37,28.73) 55.21,28.73 v9(54.47,29.47) ; v9(54.7,27.71) 55.08,28.09 v7(55.37,28.09) ; v9(57.78,30.34) 56.96,29.52 RT56.1
  BOTTOM w0.203: U21.4 52.95,87.44 v5(53.17,87.21) ; v7(21.12,134) U14.4 ; U17.4 v5(18.43,86.3) ; UZ4.4 v5(73.44,21.05)
  BOTTOM w0.254: U11.4 139.13,149.53
  BOTTOM w0.305: UZ2.3 60.08,138.19 60.01,138.11 59.49,138.11 v5(59.39,138.01) ; v5(50.47,132.37) 50.19,132.37 49.84,132.72 UZ3.3
  BOTTOM w0.508: v1(122.05,151.2) 137.47,151.2 139.13,149.53
  vias: v4(20.9,129) v4(33.59,137.4) v4(34.05,137.42) v4(34.09,137.91) v4(34.53,137.91) v4(34.49,137.42) v4(34.99,137.91) v5(25.4,129.09) v5(25.4,128.8) v5(35.37,137.78) v5(35.37,137.45) v5(35.37,137.12) v5(35.37,136.78) v5(35.69,137.78) v5(35.69,137.45) v5(35.69,137.12) v5(35.69,136.78) v5(42.68,58.1) v5(42.68,57.52) v7(13.91,96.33) v7(13.91,95.76) v7(18.43,56.11) v7(18.43,55.53) v7(18.49,56.71) v7(19.01,56.11) v7(19.01,55.53) v7(19.43,55.12) v7(34.14,96.51) v7(34.18,97.08) v7(34.54,97.65) v7(34.75,97.08) v7(34.75,96.51) v7(41.97,162.65) v7(41.97,162.01) v7(41.97,161.38) v7(41.97,160.74) v7(42.41,160.13) v7(42.55,162.65) v7(42.55,162.01) v7(42.55,161.38) v7(42.55,160.74) v7(42.99,160.13) v7(43.13,162.01) v7(43.13,161.38) v7(43.13,160.74) v7(43.56,160.12) v7(43.83,160.62) v7(44.13,160.12) v7(44.72,160.12) v7(55.37,29.36) v7(56.07,29.36) v7(56.07,28.73)
+5VALW_IR:
  vias: v2(13.61,94.67)
+5VALW_LP: length 2.6
  TOP w0.127: v2(49.78,155.2) 49.77,155.18 PC518.2
  TOP w0.254: PC518.2 48.44,155.18 48.04,154.79 PU501.6
+5VALW_PD1: length 2.2
  IN4 w0.254: v1(38.19,63.83) 38.19,64.85 37.69,65.35 v1(37.69,65.84)
  vias: v2(39.88,60.5)
+5VALW_PD2: length 4.3
  IN4 w0.254: v1(58.42,22.47) 56.55,20.6 55.63,20.6 55.13,20.1 v1(55.13,20.1)
  vias: v2(62.28,26.9)
+5VALWP: length 8.2
  IN2 w0.254: v7(47.75,161.44) 48.26,161.44 48.51,161.18 48.51,158.56 47.4,157.44 v3(47.4,154.29)
  vias: v2(47.43,159.73) v7(46.56,160.76) v7(46.56,160.15) v7(47.12,162.71) v7(47.12,162.07) v7(47.12,161.44) v7(47.12,160.8) v7(47.12,160.17) v7(47.75,162.71) v7(47.75,162.07) v7(47.75,160.8) v7(47.75,160.17)
+5VD: length 207.6
  IN1 w0.508: v8(151.97,141.25) 151.5,140.78 150.15,140.78 144.67,135.29 v10(141.96,135.29)
  IN1 w2.032: 68.39,55.37 66.46,57.31 66.46,67.26 69.15,69.95 69.15,76.48 68.5,77.13 68.5,80.25 66.52,82.23 66.52,84.79 64.01,87.3 64.01,92.37 65.63,94 66.17,94 67.09,94.93 67.09,102.53 71.73,107.16 72.44,107.16 73.16,107.89 75.31,107.89 ; 96.32,111.77 100.79,116.24 107.02,116.24 107.33,116.55 111.54,116.55 113.09,118.11 113.09,120.97 116.14,124.02 116.14,127.64 117.22,128.72
  IN2 w0.508: v10(141.96,135.29) 141.96,135.3 140.25,135.3 139.15,136.4 137.82,136.4 137.67,136.25 137.04,136.25 136.81,136.48 134.21,136.48 133.72,136.97 130.18,136.97 128.9,135.69 123.76,135.69
  IN2 w0.762: 141,96.7 144.03,93.66 147.24,93.66 149.56,91.35
  IN3 w0.254: v5(152.17,88.52) 150.86,88.52 149.81,89.57
  BOTTOM w0.127: v7(122.69,135.29) v9(123.34,135.29)
  BOTTOM w1.016: 116.33,134.91 116.33,133.66 114.76,132.08 114.76,97.94 116.15,96.55 137.64,96.55 138.3,97.21 138.3,98.58 139.1,99.38 140.96,99.38 140.97,99.37
  vias: v4(150.01,90.77) v4(150.01,90.26) v5(149.3,89.6) v5(149.53,89.4) v7(116.13,138.06) v7(116.13,137.43) v7(116.13,136.79) v7(116.13,136.11) v7(116.76,138.06) v7(116.76,137.43) v7(116.76,136.79) v7(116.76,136.11) v7(122.17,135.57) v7(122.68,135.89) v7(140.72,98.43) v7(141.29,98.43) v8(70.93,53.53) v8(70.93,53.21) v8(71.25,53.53) v8(71.25,53.21)
+5VD_LP: length 1.7
  TOP w0.254: PU502.6 116.61,143.98 PC531.2
+5VD_USH: length 14
  TOP w0.112: v2(137.78,88.36) 138.03,88.6 v8(138.03,89.19)
  IN1 w0.508: 138.89,89.26 138.98,89.35
  IN1 w0.762: 149.86,92.19 149.86,90.84 148.95,89.93 144.96,89.93 144.73,89.7 142.7,89.7 142.25,89.26 138.89,89.26
  vias: v4(150.04,93.11) v4(150.06,92.65) v5(149.44,92.55) v5(149.81,92.36) v5(150.01,92.14) v8(137.87,89.45) v8(138.18,89.46) v10(149.71,93.23) v10(149.71,92.95) v10(149.78,92.47)
+5VDP: length 13.4
  TOP w0.112: v2(121.51,134.15) 121.51,134.62 120.9,135.23
  TOP w0.254: v8(116.59,144.9) 117,144.48 PU502.5
  IN1 w0.508: v8(116.59,144.9) 117.65,143.83 117.65,143.37 117.86,143.17 120.57,143.17 121.82,141.92 v7(121.82,138.39)
  vias: v7(121.18,138.39) v7(121.18,137.63) v7(121.18,136.87) v7(121.82,137.63) v7(121.82,136.87)
+5VS: length 141
  TOP w0.203: C18.1 120.56,173.5 121.27,172.79 JUFC1.27
  TOP w0.356: C18.1 120.56,174.6 120.81,174.85 v7(128.02,174.85)
  TOP w0.508: R435.2 127.03,162.4 v8(128.02,163.39)
  IN1 w0.508: v8(151.97,140.36) 151.33,139.73 v10(151.33,137.96) ; v7(128.02,174.85) 128.02,174.41 126.29,172.68 126.29,170.55 128.02,168.82 v8(128.02,163.39) 128.02,156.91 126.92,155.82 126.92,148.07 127.23,147.77 127.23,143.54 127.67,143.09 130.34,143.09 131.98,141.45 v7(131.98,135.76)
  IN2 w0.508: v4(151.89,137.48) 151.82,137.48 v10(151.33,137.96)
  IN3 w0.762: 160.61,136.88 160.61,116.99 151.03,107.41 151.03,96.38 148.36,93.71 148.36,92.09 148.54,91.91
  IN3 w1.524: 160.61,136.88 158.37,139.13 156.08,139.13 154.81,140.4 153.8,140.4 151.89,138.5 v4(151.89,137.48) 151.17,136.76 146.5,136.76 145.4,135.66 143.47,135.66 142.29,134.48 137.54,134.48 135.5,136.53
  vias: v5(137.29,136.15) v5(142.04,134.77) v5(146.72,93.16) v5(149.02,92.11) v5(149.02,91.81) v5(149.43,91.94) v7(130.81,135.76) v7(131.39,135.76) v9(132.51,136.13)
+5VS_AUDIO: length 5.4
  IN4 w0.508: v1(33.58,146.85) 33.58,146.04 32.13,144.59 30.65,144.59 v1(29.87,143.82)
  vias: v9(33.96,139.35)
+5VS_R: length 1.9
  TOP w0.127: v2(125.76,136.6) 126.11,136.6 127.15,135.56 U2.8
+5VS_USH: length 13
  IN1 w0.508: 137.71,90.06 141.82,90.06 142.2,90.44 144.2,90.44 144.53,90.77 148.64,90.77
  BOTTOM w0.112: v2(149.66,88.06) 149.15,88.06 148.4,88.82 U4247.1
  vias: v4(149.02,90.11) v5(149.35,90.24) v5(149.48,90.01) v8(137.26,90.06) v8(137.25,89.79) v10(148.31,90.82) v10(148.62,90.84)
+AVDD1:
  vias: v2(29.45,149.01)
+DVDD: length 228
  TOP w0.254: CA1.1 13.23,173.8 13.03,174 13.03,175.53 RA41.1
  TOP w0.356: RA44.1 125.69,163.62 CA6.1 124.93,163.97 v3(124.74,163.78) ; v8(5.42,131.32) 5.5,131.24 RA42.1 ; v8(112.36,170.16) 111.91,169.71 CA2.1 111.3,169.71 111.15,169.86 v3(111.15,170.28)
  IN1 w0.508: v8(13.51,173.78) 15.81,171.48 15.81,157.48 17.65,155.64 ; 17.65,155.64 27.43,155.64 30.84,159.04 38.26,159.04 39.19,159.97 39.19,163.74 41.19,165.74 50.37,165.74 50.59,165.52 53.58,165.52 53.97,165.9 66.6,165.9 66.81,165.69 69.6,165.69 69.95,166.03 106.95,166.03 107.42,165.57 109.86,165.57 110.24,165.19 113.44,165.19 114.49,166.24 114.49,169.22 113.56,170.16 v8(112.36,170.16) ; 17.65,155.64 9.84,147.83 6.22,147.83 4.91,146.52 4.91,145.29 4.06,144.43 4.06,137.93 v7(5.27,136.72) 5.42,136.56 v8(5.42,131.32)
  IN2 w0.508: v3(124.74,163.78) 123.74,164.78 v4(122.07,164.78) ; v3(111.15,170.28) 110.17,170.28 109.66,170.79 109.66,172.24 v4(111.68,174.25)
  IN3 w0.508: v5(26.92,140.22) 26.48,140.22 25.58,141.12 17.23,141.12 14.48,138.37 14.48,137.24 13,135.76 12.06,135.76 11.32,136.51 5.47,136.51 v7(5.27,136.72) ; v4(111.68,174.25) 111.74,174.32 114.06,174.32 114.64,173.75 114.64,171.56 117.45,168.75 119.66,168.75 122.07,166.33 v4(122.07,164.78)
  BOTTOM w0.508: RA40.1 RA33.1 32.19,143.24 RA13.1 32.5,142.27 32.62,142.27 32.83,142.06 32.83,141.23 32.19,140.59 v2(31.53,140.59) 28.45,140.59
+DVDDIO: length 20.5
  IN3 w0.508: v5(21.21,142.34) 26.08,142.34 26.82,141.61 28.38,141.61 v6(28.73,141.95)
  IN4 w0.508: 28.37,129.65 28.37,135.3 28.22,135.45 28.22,141.54 28.63,141.95
  vias: v1(28.37,128.94) v1(28.37,128.67) v2(21.67,143.32) v5(20.45,142.38) v6(29.24,141.94)
+VBUS1_20V: length 9.3
  TOP w0.381: 14.4,37.89 13.96,37.44 13.96,36.67 13.97,36.66 13.97,36.61 PQ133.3 15.76,35.87 PR213.1
  IN1 w0.381: v8(13.08,44.31) 13.23,44.46 v10(13.69,44.46) 14.17,43.98 14.17,42.18 v8(14.5,41.85)
  IN2 w0.381: v10(13.69,44.46) v4(13.98,44.76)
  IN3 w0.381: v4(13.98,44.76) 14.07,44.85 14.48,44.85 v5(15.11,45.48)
  vias: v2(15.3,40.76)
+VBUS1_PD_20V: length 2.7
  TOP w0.305: v8(7.11,39.5) 5.85,39.5 JUSBC1.B4 ; JUSBC1.B9 5.85,42 v8(7.11,42)
  vias: v4(8.12,40.51) v4(8.18,41.09) v4(8.18,39.92) v4(8.72,41.1) v4(8.66,40.53) v4(8.72,39.93) v5(8.47,39.14) v5(9.09,41.55) v5(9.09,40.98) v5(9.09,40.41) v5(9.09,39.84) v5(9.2,39.14) v7(12.19,47.49) v7(12.19,46.9) v7(12.78,47.49) v7(12.8,46.9) v7(13.39,47.49) v7(13.39,46.93) v7(38.67,66.55) v7(38.67,65.98) v7(38.86,61.79) v7(38.86,61.22) v7(39.24,66.55) v7(39.24,65.98) v7(39.83,66.56) v7(39.8,65.98) v8(8.41,40.62) v8(8.42,40.3) v8(8.41,39.97) v8(8.41,39.65) v8(12.69,41.86) v8(12.66,41.38) v8(12.7,41.04) v8(12.69,40.69) v8(12.69,40.36) v8(13.13,41.37) v8(13.16,41.85) v8(13.16,40.98) v8(13.16,40.68) v8(13.16,40.35) v8(13.63,41.86) v8(13.6,41.38) v8(13.63,41) v8(13.63,40.69) v8(13.63,40.36) v9(7.99,40.63) v12(9.02,39.7) v12(9.15,40.57)
+VBUS2_20V: length 21.7
  TOP w0.127: PC118.1 21.16,28.3 21.54,28.68 v2(21.54,29.66)
  IN1 w0.381: v8(13.03,45.79) 13.21,45.61 13.79,45.61 15.11,44.29 15.11,41.09 14.3,40.27 14.3,37.56 13.69,36.95 13.36,36.95 13.02,36.6 13.02,34.8 15.08,32.74 15.08,31.63 14.68,31.23 14.68,29.83 v8(15.24,29.28)
  vias: v8(14.22,25.47) v8(14.48,25.47) v8(14.66,22.87) v8(14.94,22.87)
+VBUS2_PD_20V: length 7.3
  BOTTOM w0.254: v7(13.36,32.2) 13.61,32.45 PT102.1
  BOTTOM w1.016: 20.53,17.8 21.54,17.8 22.26,18.52 26.82,18.52
  vias: v3(8.09,25.26) v3(8.19,25.57) v3(8.15,24.94) v3(8.48,25.29) v3(8.52,24.84) v3(9.14,25.59) v4(7.96,27.05) v4(7.98,26.52) v4(8.14,25.99) v4(8.51,27.07) v4(8.48,26.53) v4(8.61,26) v5(8.28,25.16) v5(8.98,27.56) v5(8.98,26.93) v5(8.98,26.29) v5(8.98,25.66) v5(9.08,24.96) v5(19.79,18.02) v5(19.79,17.67) v5(27.69,18.52) v5(27.69,18.16) v7(12.22,32.25) v7(12.22,31.68) v7(12.79,32.25) v7(12.79,31.68) v7(13.36,31.59) v7(51.56,22.61) v7(51.56,22.04) v7(52.13,22.61) v7(52.13,22.04) v7(52.7,22.61) v7(52.7,22.04) v7(59.56,20.45) v7(60.01,20.89) v8(7.11,27.4) v8(7.11,24.9) v9(7.87,24.82)
+VCC_CORE: length 5
  IN1 w0.254: v8(71.48,135.19) 71.26,134.97 71.26,132.41 72.03,131.63 72.03,131.13 71.98,131.08
  IN2 w0.203: v4(74.02,136.03) 73.95,135.97 v3(73.95,135.64)
  vias: v3(71.73,130.34) v3(71.96,129.27) v3(72.19,130.8) v3(72.8,129.35) v3(73.03,120.36) v3(73.1,129.87) v3(73.3,120.36) v3(73.38,120.05) v3(73.56,130.34) v3(73.58,120.36) v3(73.66,120.05) v3(73.86,120.36) v3(73.91,120.05) v3(74.01,129.87) v3(74.14,120.36) v3(74.93,129.87) v3(75.39,130.34) v3(75.84,129.87) v3(76.76,129.87) v3(77.09,129.53) v3(77.21,130.34) v3(77.67,129.87) v4(71.55,129.46) v4(71.55,129.91) v4(71.78,130.72) v4(71.83,127.29) v4(71.81,126.1) v4(71.83,124.73) v4(71.81,123.59) v4(71.98,129.66) v4(72.14,130.39) v4(72.36,129.35) v4(72.39,127.29) v4(72.36,126.1) v4(72.39,124.73) v4(72.36,123.59) v4(72.42,122.16) v4(72.58,136.78) v4(72.58,136.34) v4(72.69,129.83) v4(72.9,127.29) v4(72.87,126.1) v4(72.87,123.59) v4(72.97,122.16) v4(73.23,124.75) v4(73.25,129.35) v4(73.46,130.7) v4(73.63,129.88) v4(73.69,127.47) v4(73.71,126.13) v4(73.66,124.75) v4(73.71,122.19) v4(73.76,123.61) v4(73.96,130.29) v4(74.12,127.47) v4(74.14,126.13) v4(74.09,124.75) v4(74.14,122.19) v4(74.19,123.61) v4(74.27,119.88) v4(74.47,129.88) v4(74.5,120.28) v4(74.7,119.88) v4(74.93,120.28) v4(74.96,130.24) v4(75.13,119.88) v4(75.41,131.15) v4(75.39,129.91) v4(75.36,120.28) v4(75.56,119.88) v4(75.79,130.24) v4(75.79,120.28) v4(76,119.88) v4(76.23,120.28) v4(76.28,129.86) v4(76.53,126.15) v4(76.63,127.29) v4(76.58,123.38) v4(76.56,122.09) v4(76.78,130.27) v4(76.78,124.83) v4(76.96,126.15) v4(77.04,123.38) v4(76.99,122.09) v4(77.09,127.29) v4(77.17,129.88) v4(77.29,124.83) v4(77.7,123.41) v4(77.67,122.09) v4(77.9,126.73) v4(77.88,126.2) v4(78.13,128.21) v4(78.16,123.41) v4(78.16,122.09) v5(71.35,128.34) v5(71.35,127.76) v5(71.35,127.19) v5(71.35,126.62) v5(71.36,126.05) v5(71.36,125.48) v5(71.36,124.91) v5(71.36,124.33) v5(71.37,123.71) v5(71.68,123.18) v5(71.68,122.61) v5(72.06,122.04) v5(72.06,121.46) v5(72.06,120.89) v5(72.82,125.16) v5(72.82,124.83) v5(72.82,124.5) v5(72.91,129.03) v5(73.18,130.95) v5(73.18,130.34) v5(73.18,129.76) v5(73.33,127.65) v5(73.33,127.32) v5(73.3,126.4) v5(73.3,126.07) v5(73.33,123.61) v5(73.33,123.28) v5(73.33,122.34) v5(73.33,122.01) v5(73.3,120.16) v5(73.56,131.48) v5(73.71,119.55) v5(74.35,137.53) v5(74.32,135.8) v5(74.35,119.55) v5(74.63,119.55) v5(74.73,137.53) v5(74.65,135.8) v5(75.44,119.55) v5(75.72,119.55) v5(76.15,119.55) v5(77.14,121.73) v5(77.34,122.26) v5(77.34,121.93) v5(77.37,126.48) v5(77.39,126.1) v5(77.37,123.56) v5(77.37,123.23) v5(77.5,127.62) v5(77.5,127.29) v5(77.7,132.53) v5(77.85,125.13) v5(77.85,124.8) v5(77.85,124.47) v5(78,137.58) v5(78.03,132.53) v5(78.16,131.48) v5(78.23,130.37) v5(78.23,129.78) v5(78.23,129.22) v5(78.18,128.72) v5(78.26,137.91) v5(78.26,130.94) v7(71.45,147.14) v7(71.46,146.57) v7(71.46,146) v7(72.02,147.14) v7(72.02,146.57) v7(72.02,146) v7(72.61,147.14) v7(72.61,146.58) v7(72.61,146.01) v7(73.16,147.14) v7(73.16,146.58) v7(73.16,146.01) v7(73.72,147.14) v7(73.72,146.58) v7(73.72,146.01) v7(73.79,129.35) v7(74.35,147.14) v7(74.36,129.35) v7(74.92,147.14) v7(74.93,129.35) v7(75.48,147.14) v7(75.5,129.35) v7(76.05,147.14) v7(76.07,129.35) v7(76.62,147.14) v7(76.64,129.35) v7(77.2,147.14) v7(77.77,147.14) v7(78.33,147.14) v7(78.91,147.14) v7(79.06,135.4) v7(79.48,147.14) v7(80.05,147.14) v7(80.64,147.13) v7(80.64,146.56) v7(80.66,145.99) v7(81.22,147.13) v7(81.22,146.56) v7(81.22,145.99) v7(81.8,147.12) v7(81.8,146.56) v7(81.8,146) v7(82.36,147.12) v7(82.36,146.56) v7(82.36,146) v7(82.92,147.12) v7(82.92,146.56) v7(82.92,146) v7(88.44,147.21) v7(88.44,146.55) v7(89.01,147.21) v7(89.01,146.55) v7(89.6,147.19) v7(89.57,146.55) v7(90.14,146.55) v7(90.16,147.19) v7(90.72,147.19) v7(90.72,146.55) v9(74.42,130.47)
+VCC_CORE_G0: length 8.7
  IN1 w0.254: 70.36,132.53 70.36,131.47 71.21,130.62 71.21,130.25 71.52,129.94 72.12,129.94 v8(72.19,129.87)
  IN1 w0.508: 70.36,132.53 69.85,133.03 69.85,135.83 v8(68.83,136.84)
+VCC_CORE_G1: length 2.1
  TOP w0.076: UCPU1.AK32 72.19,119.01 v3(72.14,118.96)
  IN2 w0.203: v4(72.15,117.93) 72.14,117.94 v3(72.14,118.96)
  IN3 w0.254: v4(72.15,117.93) 72.14,117.94 v5(72.14,118.43)
+VCC_GT: length 3.2
  TOP w0.203: UCPU1.A66 91.52,134.5 91.52,135.21 v7(91.47,135.26) ; UCPU1.A62 89.04,135.32 v7(89.11,135.38)
  TOP w0.254: UCPU1.BB57 86.81,112.6 v8(86.84,112.57) ; UCPU1.A58 86.58,134.51 86.58,135.1 86.74,135.27 v7(86.74,135.61)
  vias: v3(86.82,118.56) v3(86.82,115.31) v3(87.27,119.04) v3(88.94,128.22) v3(88.94,124.56) v3(89.41,128.68) v3(89.41,126.85) v3(89.56,115.31) v3(90.06,127.76) v3(90.06,126.85) v3(90.06,125.02) v3(90.06,124.1) v3(90.71,125.02) v3(91.36,126.85) v3(91.36,125.02) v3(91.36,124.1) v3(92.01,125.02) v3(92.01,124.1) v3(92.66,126.84) v3(92.66,125.02) v3(93.31,125.02) v3(93.31,124.1) v3(93.96,126.85) v3(93.96,125.02) v3(93.96,124.1) v3(94.28,119.68) v3(94.61,125.02) v4(84.33,121.73) v4(84.85,122.2) v4(84.84,121.72) v4(85.48,122.2) v4(85.47,121.72) v4(85.57,128.49) v4(85.57,128.01) v4(85.57,127.59) v4(85.57,126.77) v4(85.57,126.3) v4(86.08,128.49) v4(86.08,128.01) v4(86.08,127.59) v4(86.08,126.76) v4(86.08,126.3) v4(86.12,122.2) v4(86.11,121.72) v4(87.69,124.78) v4(87.69,124.33) v4(87.68,123.92) v4(87.71,121.74) v4(87.69,121.26) v4(87.93,120.08) v4(88.18,124.8) v4(88.18,124.33) v4(88.17,123.91) v4(88.21,121.74) v4(88.2,121.26) v4(88.62,124.8) v4(88.62,124.33) v4(88.62,123.91) v4(88.72,121.74) v4(88.71,121.26) v4(89.34,123.04) v4(89.34,122.56) v4(89.36,123.52) v4(89.61,127.71) v4(89.6,127.23) v4(89.6,120.97) v4(90.3,123.08) v4(90.68,129.07) v4(91.11,127.19) v4(91.16,129.07) v4(91.36,123.03) v4(91.62,129.07) v4(91.57,127.19) v4(92,122.72) v4(92.51,122.72) v4(93.04,126.89) v4(93.01,122.75) v4(93.71,124.5) v4(93.78,127.17) v4(94.2,124.51) v4(94.26,127.17) v4(95.01,124.98) v5(83.41,127.65) v5(83.41,127.32) v5(83.41,126.99) v5(83.41,121.43) v5(83.41,121.1) v5(83.41,120.77) v5(84.45,127.14) v5(84.48,121.32) v5(84.68,132.55) v5(84.66,131.59) v5(84.71,130.8) v5(84.71,129.81) v5(84.76,127.14) v5(84.79,121.32) v5(84.76,120.28) v5(84.76,119.95) v5(85.42,130.24) v5(85.67,127.14) v5(85.69,121.32) v5(86,130.24) v5(85.98,127.14) v5(86,121.32) v5(85.95,120.31) v5(85.95,119.98) v5(86.56,130.21) v5(86.86,127.14) v5(86.89,121.32) v5(87.15,130.27) v5(87.17,127.14) v5(87.2,121.32) v5(87.3,124.53) v5(87.3,124.19) v5(87.3,123.86) v5(87.38,120.28) v5(87.38,119.95) v5(87.71,130.24) v5(88.29,130.24) v5(88.29,120.13) v5(89.03,129.86) v5(89.22,122.24) v5(89.22,120.97) v5(90.03,128.69) v5(89.99,126.51) v5(90.37,128.69) v5(90.42,122.72) v5(90.7,128.69) v5(90.75,122.72) v5(91.1,127.67) v5(91.08,122.72) v5(91.44,127.67) v5(91.69,128.72) v5(91.77,127.67) v5(91.92,123.15) v5(92.2,123.15) v5(92.63,129.05) v5(92.68,127.27) v5(92.84,123.18) v5(92.96,129.05) v5(93.01,127.27) v5(93.14,123.18) v5(93.99,128.72) v5(94.04,127.65) v5(94.34,128.72) v5(94.39,127.65) v5(94.67,128.72) v5(94.72,127.65) v5(95.64,128.72) v5(95.67,127.62) v5(95.99,128.72) v5(96.01,127.62) v5(96.32,128.72) v5(96.34,127.62) v5(99.5,129.33) v5(99.73,125.39) v5(99.96,129.33) v5(100.19,125.39) v5(100.72,129.33) v5(100.93,125.44) v5(101.18,129.33) v5(101.38,125.44) v5(101.94,129.3) v5(102.17,125.44) v5(102.4,129.3) v5(102.46,125.41) v5(103.14,129.33) v5(103.37,125.41) v5(103.59,129.33) v5(103.66,125.39) v7(85.29,120.08) v7(85.5,129.17) v7(86.44,120.08) v7(86.77,129.38) v7(101.9,146.88) v7(101.9,146.31) v7(102.48,146.88) v7(102.48,146.31) v7(103.05,146.88) v7(103.05,146.31) v7(103.62,146.88) v7(103.62,146.31) v7(104.19,146.88) v7(104.19,146.31) v7(107.26,137.1) v7(107.7,136.59) v7(107.7,136.02) v7(107.7,135.45) v7(107.7,134.88) v7(107.7,134.3) v7(107.7,133.73) v7(107.7,133.16) v7(107.82,137.16) v7(108.27,136.59) v7(108.27,136.02) v7(108.27,135.45) v7(108.27,134.88) v7(108.27,134.3) v7(108.27,133.73) v7(108.27,133.16) v7(108.46,137.15) v7(108.84,134.91) v7(108.84,133.69) v7(108.89,136.62) v7(108.89,136.06) v7(108.86,135.47) v7(108.86,134.3) v7(108.86,133.11) v8(91.52,112.52) v9(86.77,132.64)
+VCC_SA: length 5.1
  IN4 w0.254: v1(63.42,131.83) 63.97,132.37 67.41,132.37 67.86,131.93 v1(67.86,131.64)
  vias: v3(57.48,146.53) v3(57.48,146.22) v3(57.49,145.92) v3(57.49,145.61) v3(57.77,146.53) v3(57.77,146.22) v3(57.78,145.92) v3(57.78,145.61) v3(58.06,146.53) v3(58.06,146.22) v3(58.08,145.92) v3(58.08,145.61) v3(58.36,146.53) v3(58.36,146.22) v3(58.37,145.92) v3(58.37,145.61) v3(58.67,146.53) v3(58.67,146.22) v3(58.67,145.92) v3(58.67,145.61) v3(58.97,146.53) v3(58.97,146.22) v3(58.97,145.92) v3(58.97,145.61) v3(68.07,130.34) v3(68.53,130.8) v3(68.53,129.87) v3(69.44,130.8) v3(69.44,129.87) v3(69.9,130.34) v4(59.39,146.8) v4(59.39,146.32) v4(59.37,145.87) v4(59.37,145.43) v4(59.87,146.8) v4(59.86,146.33) v4(59.86,145.87) v4(59.86,145.43) v4(60.34,146.33) v4(60.34,145.87) v4(60.34,145.43) v4(60.35,146.8) v4(68.12,130.77) v4(68.53,130.34) v4(68.96,126.02) v4(69.09,124.78) v4(69.09,121.76) v4(69.19,123.64) v4(69.47,130.32) v4(69.55,127.32) v4(69.47,126.02) v4(69.62,124.8) v4(69.6,121.76) v4(69.72,123.66) v4(69.93,129.88) v5(67.86,131.07) v5(67.86,130.49) v5(67.88,129.92) v5(68.3,123.83) v5(68.3,123.26) v5(68.35,122.72) v5(68.68,121.93) v5(68.68,121.6) v5(69.06,129.17) v5(69.06,128.84) v5(69.06,127.9) v5(69.06,127.57) v5(69.06,125.49) v5(69.06,125.16) v7(68.4,119.99) v7(68.96,131.13) v7(69.57,129.38) v7(70.15,129.38) v9(70.05,131.8)
+VCCCLK1: length 5.2
  TOP w0.127: v2(63.78,138.39) 63.42,138.04 RC16.2
  TOP w0.254: RC16.2 62.36,137.76 62.36,137.35 62.32,137.31 CC5.1 62.32,136.42 61.78,135.89 UCPU1.A14
+VCCCLK2: length 6.9
  TOP w0.254: v7(64.38,128.95) 64.38,129.06 64.71,129.38 UCPU1.K19
  IN4 w0.254: v7(64.38,128.95) 63.72,128.95 61.85,130.81 v1(59.94,130.81)
  BOTTOM w0.127: v7(64.38,128.95) 64.38,129.41 v2(64.49,129.52)
  BOTTOM w0.254: CC42.1 64.39,128.94 v7(64.38,128.95)
+VCCCLK3: length 8.6
  TOP w0.254: UCPU1.L21 66.01,128.57 65.63,128.94 v7(65.63,128.95)
  IN4 w0.254: v1(59.94,134.62) 65.15,129.41 65.18,129.41 65.63,128.97 v7(65.63,128.95)
+VCCCLK4: length 10.9
  TOP w0.254: UCPU1.N20 65.36,127.61 v7(65.68,127.29)
  IN4 w0.254: v7(65.68,127.29) 65.68,127.8 65.11,128.37 63.79,128.37 61.73,130.43 59.05,130.43 v1(58.67,130.81)
  BOTTOM w0.127: CC40.1 65.98,127.84 v2(66.48,128.35)
  BOTTOM w0.254: v7(65.68,127.29) 65.66,127.31 CC40.1
+VCCCLK5: length 10.2
  TOP w0.254: v7(65.01,128.95) 65.01,128.84 UCPU1.L19
  IN4 w0.254: v7(65.01,128.95) 65.01,128.97 64.49,129.48 63.81,129.48 62.66,130.62 62.66,131.4 59.44,134.62 v1(58.67,134.62)
  BOTTOM w0.254: v7(65.01,128.95) 65.02,128.93 CC41.1
+VCCCLK6: length 4.6
  TOP w0.254: RC15.2 61.09,137.81 v2(61.09,137) 60.86,136.77 60.55,136.77 59.99,136.21 59.99,136.16 59.76,135.92 59.71,135.92 59.31,135.52 UCPU1.A10
+VCCIA_GT: length 2.2
  TOP w0.254: 83.78,135.96 83.82,136 83.82,134.76 UCPU1.A53 ; UCPU1.A48 81.61,134.84 81.47,134.98
  vias: v2(81.05,131.48) v3(78.23,120.26) v3(78.23,119.98) v3(78.51,120.26) v3(78.51,119.98) v3(78.79,120.26) v3(78.79,119.98) v3(79.07,120.26) v3(79.07,119.98) v3(79.98,129.59) v3(79.96,129.31) v3(80.82,129.45) v3(81.76,129.99) v3(82.59,129.99) v3(82.6,129.65) v4(79.43,120.03) v4(79.78,128.92) v4(79.88,120.03) v4(80.31,120.03) v4(80.64,121.15) v4(80.85,123.76) v4(80.82,122.54) v4(80.77,120.03) v4(80.95,128.26) v4(80.87,124.65) v4(80.87,124.19) v4(81.1,121.15) v4(81.2,120.03) v4(81.41,127.04) v4(81.46,126.35) v4(81.46,125.9) v4(81.46,125.44) v4(81.58,122.7) v4(81.56,121.15) v4(81.71,129.63) v4(81.66,120.03) v4(82.09,120.03) v4(82.3,128.89) v4(82.3,122.7) v4(82.32,121.15) v4(82.55,120.03) v4(82.83,127.98) v4(82.83,126.33) v4(82.83,125.46) v4(82.83,124.47) v4(82.83,123.92) v4(82.75,122.7) v4(82.85,127.29) v5(78.87,119.57) v5(79.5,119.57) v5(80.02,129.8) v5(80.02,128.65) v5(80.01,119.57) v5(80.06,130.37) v5(80.09,129.25) v5(80.64,119.57) v5(81,125.87) v5(81,125.49) v5(81.23,122.9) v5(81.23,122.52) v5(81.15,119.57) v5(81.31,124.55) v5(81.31,124.19) v5(81.28,123.81) v5(81.34,121.55) v5(81.38,129.86) v5(81.46,130.38) v5(81.5,120.69) v5(81.74,132.93) v5(81.74,132.6) v5(81.67,121.53) v5(81.84,127.6) v5(81.84,127.27) v5(81.84,126.99) v5(81.92,125.92) v5(81.94,125.57) v5(81.92,124.65) v5(81.92,124.27) v5(81.92,123.89) v5(81.92,122.9) v5(81.92,122.52) v5(82.33,119.51) v5(82.45,130.9) v5(82.45,130.32) v5(82.45,129.76) v5(82.5,134.66) v5(82.5,134.3) v5(82.47,129.2) v5(82.47,128.59) v5(83.13,134.35) v5(83.06,119.83) v5(83.16,134.76) v7(80.9,128.82) v7(81.25,129.25)
+VCCPLL_OC: length 16.2
  TOP w0.508: v8(65.41,110.3) 65.43,110.33 67.03,110.33 67.81,109.54 69.06,109.54 69.4,109.2 v9(69.4,106.8) 69.62,106.57 CZ2.1 R48.2
  IN1 w0.508: 66.04,115.64 66.04,114.56 64.96,113.48 64.96,110.75 v8(65.41,110.3)
  GND1 w0.254: v12(67.16,119.04) 67.03,119.04 v4(66.8,118.81)
  GND3 w0.254: v4(66.8,118.81) 66.59,118.81 v13(66.42,118.64)
+VCCPLL_OC_R: length 2.9
  TOP w0.508: R48.1 67.89,104.46 v2(67.11,103.67) 67.11,103 67.34,102.77 UZ1.6
+VSS_PLL: length 2.4
  BOTTOM w0.305: CE48.2 25.27,107.24 25.27,108.55 UE3.G1
AGND: length 56.6
  VCC w0.203: 10.2,170.97 JP1.5 ; JP1.5 11.42,170.05 ; JP1.5 10.2,169.14 ; JP1.5 11.42,170.97 ; JP1.5 10.2,170.05 ; JP1.5 10.81,170.97 ; JP1.5 10.81,169.14 ; JP1.5 11.42,169.14 ; 8.9,167.24 JP1.8 ; JP1.8 9.82,167.24 ; JP1.8 8.9,168.46 ; JP1.8 7.99,167.85 ; JP1.8 7.99,167.24 ; JP1.8 9.82,168.46 ; JP1.8 9.82,167.85 ; JP1.8 7.99,168.46 ; JP1.7 5.12,173.74 ; JP1.7 4.2,173.74 ; JP1.7 3.29,173.74
  IN3 w0.508: v5(33.85,150.05) v4(33.22,150.05) ; v5(19.39,148.27) v4(18.8,148.27) ; v5(18.61,151.64) v4(17.78,151.64) ; v5(19.94,147.55) v4(20.66,147.55) ; v5(9.69,160.72) v5(10.63,160.72) v4(11.24,160.72) ; v5(28.63,151.96) v4(28.63,152.58) ; v5(13.93,161.36) v4(14.41,161.36) ; v5(33.85,151.32) v4(33.22,151.32) ; v5(13.12,161.36) v4(12.7,161.36) ; v5(34.59,153.1) v4(33.97,153.1) ; v5(11.3,155.97) v4(11.86,155.97) ; v5(35.05,150.5) v4(34.29,150.5) ; v5(31.62,150.34) v4(31,150.34) ; v4(18.28,147.77) v5(18.28,147.07) ; v5(31.62,151.61) v4(31,151.61) ; v4(16.94,145.81) v5(17.56,145.81)
  GND3 w0.203: JP1.5 11.42,170.97 ; JP1.5 10.81,169.14 ; JP1.5 10.2,170.05 ; JP1.5 10.2,169.14 ; JP1.5 11.42,170.05 ; JP1.5 11.42,169.14 ; JP1.5 10.81,170.97 ; JP1.5 10.2,170.97 ; JP1.8 9.82,167.85 ; JP1.8 8.9,167.24 ; JP1.8 7.99,167.85 ; JP1.8 7.99,167.24 ; JP1.8 9.82,167.24 ; JP1.8 9.82,168.46 ; JP1.8 7.99,168.46 ; JP1.8 8.9,168.46 ; JP1.7 5.12,173.74 ; JP1.7 3.29,173.74 ; JP1.7 4.2,173.74
  BOTTOM w0.127: v9(10.15,155.64) 10.48,155.97 v5(11.3,155.97) 11.98,155.97 v9(12.83,155.12) ; v5(31.62,150.34) v9(30.49,150.34)
  BOTTOM w0.203: UA1.18 20.8,147.18 20.59,147.4 ; UA1.37 27.96,149.58 28.07,149.7 v13(28.07,150.04)
  BOTTOM w0.356: v5(19.94,147.55) 20.43,147.55 20.59,147.4
  BOTTOM w0.381: CA16.2 28.79,151.79 v5(28.63,151.96)
  BOTTOM w0.508: CA29.2 17.74,145.99 v5(17.56,145.81) ; CA15.2 v13(23.75,152.85) ; v5(18.61,151.64) CA18.2
  vias: v13(19.23,152.34) v13(21.01,152.34)
