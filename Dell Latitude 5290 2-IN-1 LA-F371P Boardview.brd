# Allegro board Dell Latitude 5290 2-IN-1 LA-F371P Boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N45337950: length 1.1
  TOP w0.112: v2(137.67,135.05) 137.38,134.76 R473.2
N45337958: length 2.1
  TOP w0.254: QE13.3 135.57,138.71 R472.2 135.05,138.71 v2(134.67,138.33)
N45343408: length 1.5
  GND1 w0.076: v4(150.37,141.09) 150.63,141.35 v12(150.65,141.35)
  IN3 w0.076: v4(150.37,141.09) 150.1,141.35 150.1,141.71 v5(150.35,141.96)
N45343411: length 2.2
  TOP w0.112: v2(151.04,142.14) 151.27,141.91 R478.2
  GND1 w0.076: v4(151.01,141.12) 151.18,141.29 151.26,141.29 v12(151.31,141.35)
  IN3 w0.076: v5(150.35,141.56) 150.68,141.23 150.91,141.23 v4(151.01,141.12)
N46285260: length 1.2
  TOP w0.112: C231.1 v2(79.43,80.9)
N46285448: length 2.5
  TOP w0.127: R486.2 85.01,72.42 v2(84.59,72)
  TOP w0.254: R486.2 84.4,72.96 84.3,73.06 Q32.1
N46619932: length 10.9
  BOTTOM w0.203: PU900.44 57.11,154.77 56.92,154.57
  BOTTOM w0.254: PR950.2 54.7,147.78 54,147.78 53.34,148.44 53.34,149.98 53.85,150.48 v2(53.85,151.31) 53.85,152.67 54.41,153.23 55.2,153.23 PC902.1
  BOTTOM w0.508: PC902.1 56.55,154.57 56.92,154.57
N46621117: length 1.9
  BOTTOM w0.114: PU900.6 60.56,157.64 61.15,158.23 PR914.1
N46621120: length 4.1
  BOTTOM w0.112: PR953.1 60.74,160.24 60.77,160.22
  BOTTOM w0.114: 60.77,160.22 PR914.2 61.6,159.39 61.6,158.26 60.96,157.62 PU900.7
N46621397: length 0.8
  BOTTOM w0.112: PC931.1 PR953.2
N46621424: length 2
  BOTTOM w0.114: PR903.1 62.06,158.32 61.36,157.61 PU900.8
N46621427: length 2.2
  BOTTOM w0.114: PR904.1 62.93,158.79 61.76,157.62 PU900.9
N46621964: length 0.8
  BOTTOM w0.112: PC932.1 PR954.2
N46621983: length 3.5
  BOTTOM w0.114: PU900.10 62.16,157.62 62.99,158.46 63.25,158.46 63.37,158.59 63.37,159.39 PR915.1
N46621986: length 3.7
  BOTTOM w0.114: PR954.1 63.82,158.96 PR915.2 63.82,158.59 63.46,158.23 63.18,158.23 62.56,157.61 PU900.11
N46622191: length 2.6
  BOTTOM w0.114: PU900.12 62.96,157.61 63.29,157.94 63.65,157.94 PR906.1
N46622194: length 1.6
  BOTTOM w0.114: PU900.13 64.26,156.37 PR907.1
N46622340: length 4.2
  BOTTOM w0.254: PR916.2 PR920.2 PC900.2 56.17,150.97 v2(56.59,151.39) 57.17,151.97 PU900.37
N46622659: length 4.3
  BOTTOM w0.114: PU900.35 58.96,150.45 58.58,150.08 v2(57.63,150.08) 57.11,150.08 PR921.2 56.54,148.7 PR917.2
N46622666: length 6.3
  IN4 w0.066: v1(56.45,146.89) 56.45,147.26 57.38,148.19 v1(57.38,148.67)
  BOTTOM w0.127: PU900.33 59.76,150.45 58.98,149.67 v2(58.85,149.67) 57.76,149.67 57.58,149.5 57.58,148.87 v1(57.38,148.67)
N46622669: length 5.8
  IN4 w0.066: v1(58.24,148.67) 58.24,147.86 57.34,146.96 v1(57.34,146.89)
  BOTTOM w0.112: PU900.32 60.16,150.07 v2(60.09,150.01) 59.72,149.63 59.72,149.48 59.38,149.14 58.6,149.14 58.24,148.78 v1(58.24,148.67)
N46623252: length 1.7
  BOTTOM w0.127: PR925.2 PR929.2 PR928.1
N46623254: length 1.7
  BOTTOM w0.112: PR926.1 PR930.2 PR901.2
N46623256: length 1.7
  BOTTOM w0.112: PR900.2 PR924.2 PR927.1
N46623799: length 3.7
  BOTTOM w0.127: PU900.30 60.96,150 60.55,149.6 60.55,149.23 PR932.2 PR931.2
N46624101: length 2.6
  BOTTOM w0.127: PU900.27 62.16,149.87 62.37,149.66 62.37,149.24 62.56,149.05 PR927.2
N46624104: length 2.7
  BOTTOM w0.127: PU900.29 61.36,149.17 PR926.2
N46624128: length 2.7
  BOTTOM w0.127: PU900.28 v2(61.76,149.73) 61.97,149.52 61.97,149.29 61.7,149.02 PR928.2
N46624575: length 6.1
  IN4 w0.066: v1(60.56,150.1) 60.56,147.69 59.77,146.9 v1(59.11,146.9)
  BOTTOM w0.127: v1(60.56,150.1) PU900.31 ; PR934.2 PR933.2
N46625447: length 4
  BOTTOM w0.112: PR937.2 65.42,150.19 PR936.2
  BOTTOM w0.114: PU900.25 62.96,150.7 63.29,150.37 65.24,150.37 PR936.2
N46626304: length 5.1
  BOTTOM w0.112: PR949.2 PC1423.2 55.32,157.63 PR938.2 56.26,157.63 56.45,157.44 56.45,156.26 57.15,155.57 PU900.46
N46626546: length 6.5
  BOTTOM w0.112: PR939.2 55.73,150.42 58.27,150.42 58.56,150.71 PU900.36 ; PR940.2 53.94,148.63 v2(53.84,148.53)
  BOTTOM w0.114: PR940.2 54.81,148.7 PR939.2
N46626820: length 2
  BOTTOM w0.112: PR956.2 65.08,151.1 64.94,151.24
  BOTTOM w0.114: PU900.24 64.21,151.97 64.94,151.24
N46626937: length 5.2
  BOTTOM w0.114: PU900.21 64.27,153.17 64.91,153.81 64.91,154.18 65.19,154.46 66.74,154.46 PR941.2 PC904.2
N46627867: length 4.1
  BOTTOM w0.112: 64.31,152.77 64.41,152.77 PC905.2
  BOTTOM w0.114: PU900.22 64.31,152.77 ; PC905.2 65.85,154.21 66.99,154.21 PR944.2
N46628199: length 2.6
  BOTTOM w0.112: 64.77,152.1 64.89,151.98 PR945.2
  BOTTOM w0.114: 64.77,152.1 64.5,152.37 PU900.23 ; PR945.2 PC906.2
N46634435: length 5.3
  BOTTOM w0.203: v2(56.58,155.18) 56.59,155.17 PU900.45
  BOTTOM w0.254: PC907.1 55.04,156.92 PR946.1 ; PC907.1 55.8,155.96 v2(56.58,155.18) ; PC907.1 55.04,155.53 PR947.2
N46635062: length 3.3
  BOTTOM w0.114: PR948.1 65.79,157.64 65.79,156.99 65.37,156.57 64.84,156.57 64.23,155.97 PU900.14
N46635065: length 5.5
  BOTTOM w0.112: PR948.2 67.31,157.41 PR955.1
  BOTTOM w0.114: PR948.2 66.82,157.83 66.24,157.25 66.24,156.87 v2(66.21,156.84) 65.7,156.33 65.01,156.33 64.25,155.57 PU900.15
N46635193: length 2.1
  BOTTOM w0.112: v2(69.9,155.87) PC933.1 68.98,156 PR955.2
N46635895: length 1.9
  BOTTOM w0.112: 64.14,155.17 64.35,155.17 64.97,155.79 PR951.1
  BOTTOM w0.114: PU900.16 64.14,155.17
N46635936: length 1.7
  BOTTOM w0.112: PR952.1 64.67,154.91 64.53,154.77 64.21,154.77
  BOTTOM w0.114: PU900.17 64.21,154.77
N46642074: length 2.4
  TOP w0.203: PC327.1 81.1,158.87 81.22,158.98 PU1005.14
  TOP w0.254: PC327.1 PR1101.2
N46643804: length 2.4
  TOP w0.203: PU1005.15 81.6,158.58 81.46,158.43
  TOP w0.381: PC1110.1 80.95,157.93 81.46,158.43
N46645023: length 8.5
  TOP w0.112: PC1114.2 63.04,156.36 v2(61.43,154.75)
  TOP w0.635: PR1108.1 70.45,157.18 ; PC1114.2 63.89,155.54 66.4,155.54
N46645025:
  vias: v2(72.5,160.5)
N46645111: length 2.3
  TOP w0.203: PC328.1 64.78,158.93 64.86,159.01 PU1006.14
  TOP w0.254: PC328.1 PR1103.2
N46645235: length 4.9
  TOP w0.112: v2(61.32,156.06) 61.38,156.06 63.04,157.72 PC1114.1
  TOP w0.203: PU1006.15 64.71,158.61 64.57,158.46
  TOP w0.381: 64.57,158.46 63.89,157.79 PC1114.1
N46647978: length 8.2
  TOP w0.635: PC1120.2 v2(93.09,152.59) 93.88,151.8 95.58,151.8 ; PR1117.1 101.33,154.61 100.3,153.58 98.55,153.58
N46648066: length 3.9
  TOP w0.203: PU1107.14 93.41,156.26 PC337.1
  TOP w0.254: PC337.1 93.15,156.14 92.76,156.53 92.76,157.66 93.01,157.91 PR1118.2
N46648174: length 3.5
  TOP w0.112: PC1120.1 92.72,155.04 91.91,154.23 v2(91.91,154.17)
  TOP w0.203: 94.11,155.72 94.25,155.86 PU1107.15
  TOP w0.381: 94.11,155.72 93.43,155.04 PC1120.1
N46648285: length 4.2
  TOP w0.508: PR1125.1 56.69,152.19 56.71,152.2
  TOP w0.635: PC1126.2 53.1,152.68 53.59,152.19 PR1125.1
  vias: v2(59.17,155.72)
N46648306: length 2.4
  TOP w0.112: v2(52.64,151.75) 53.91,150.48 PR1125.2
N46648384: length 3.5
  TOP w0.112: v2(51.88,155.68) 52.18,155.37 PR1126.2
  TOP w0.203: PC338.1 54.36,155.37 54.46,155.47 PU1108.12
  TOP w0.254: PC338.1 PR1126.2
N46648510: length 3.9
  TOP w0.112: PC1126.1 52.79,154.17 52.46,154.17 v2(51.9,153.61)
  TOP w0.203: 54.5,154.73 54.75,154.98 54.85,155.08 PU1108.13
  TOP w0.381: 54.5,154.73 54.25,154.47 PC1126.1
N46677664: length 55.4
  TOP w0.112: JUFC1.29 v3(122.17,173.19)
  IN2 w0.066: v3(122.17,173.19) v4(122.53,173.19)
  IN3 w0.066: v5(153.8,146.46) 153.8,151.07 152.54,152.33 129.92,152.33 128.8,153.45 128.8,168.27 127.79,169.28 125.95,169.28 123.75,171.48 123.75,172.76 123.32,173.19 v4(122.53,173.19)
N46798093: length 2.1
  TOP w0.203: 124.68,163.34 JWFC1.34
  TOP w0.254: 124.68,163.34 125.27,163.34 125.58,163.03 RA44.2
N46884959: length 46.3
  TOP w0.112: v8(28.64,123.83) 24.98,123.83 24.26,123.11 23.74,123.11 23.63,123 JNGFF1.38 ; R489.1 52.02,129.27 v8(52.43,129.68) 52.43,129.91 v2(52.17,130.16)
  IN1 w0.066: v10(52.48,130.93) 52.48,129.73 v8(52.43,129.68) ; v8(28.64,123.83) 28.64,127 34.11,132.48 v7(34.11,133.67)
  IN2 w0.066: v10(52.48,130.93) v4(52.76,131.21)
  IN3 w0.066: v4(52.76,131.21) 51.51,131.21 50.95,131.76 50.29,131.76 49.87,132.19 49.87,135.06 47.48,137.45 44.11,137.45 39.63,132.97 37.96,132.97 37.58,133.35 34.43,133.35 v7(34.11,133.67)
N48002177: length 61.2
  TOP w0.112: JNGFF1.60 18.13,122.97 v8(18.86,123.7)
  IN1 w0.066: v10(22.04,78.17) 22.42,78.54 22.42,80.12 21.8,80.73 21.8,89.82 23.09,91.11 23.09,104.64 20.83,106.91 19.4,106.91 17.13,109.18 17.13,117.27 18.86,119 v8(18.86,123.7)
  IN2 w0.066: v10(22.04,78.17) 24.61,75.61 24.61,71.79 24.22,71.4 v4(24.22,70.96)
  GND3 w0.066: v13(24.22,70.5) v4(24.22,70.96)
N48002180: length 61.6
  TOP w0.112: v8(18.35,123.7) 17.63,122.98 JNGFF1.62
  IN1 w0.066: v10(21.78,78.49) 22.25,78.95 22.25,80.05 21.63,80.66 21.63,89.89 22.93,91.18 22.93,104.57 20.76,106.74 19.33,106.74 16.96,109.11 16.96,117.34 18.69,119.07 18.69,123.36 v8(18.35,123.7)
  IN2 w0.066: v10(21.78,78.49) 21.78,78.06 24.44,75.4 24.44,71.88 23.69,71.12 v4(23.69,70.94)
  GND3 w0.066: v4(23.69,70.94) 23.62,70.88 v13(23.62,70.5)
N48002183: length 59.5
  TOP w0.112: v8(18.41,121.1) 17.34,121.1 17.13,121.3 JNGFF1.64
  IN1 w0.066: v8(18.41,121.1) 18.41,119.3 18.42,119.03 16.79,117.41 16.79,109.04 19.27,106.57 20.69,106.57 22.76,104.51 22.76,91.25 21.47,89.96 21.47,80.59 22.08,79.98 22.08,79.39 v10(21.65,78.96)
  IN2 w0.066: v4(23.16,70.94) 24.27,72.05 24.27,75.33 21.52,78.09 21.52,78.83 v10(21.65,78.96)
  GND3 w0.066: v13(23.04,70.5) 23.04,70.82 v4(23.16,70.94)
N48798623: length 10.1
  TOP w0.112: v3(20.56,64.96) 22.1,64.96 25.72,61.34 JNGFF3.50
  IN2 w0.066: v3(20.56,64.96) v4(20.56,66.3)
  IN3 w0.066: v5(20.19,66.65) 20.2,66.65 v4(20.56,66.3)
  BOTTOM w0.112: R161.1 v5(20.19,66.65)
N48801679: length 3.3
  TOP w0.305: JDEG3.1 39.21,90.72 39.37,90.55 40.65,90.55 v2(40.82,90.39) 40.82,89.74 40.37,89.3 RE9.2
N48802004: length 1.1
  TOP w0.203: LED4.2 50.72,87.34 R411.2
N48802006: length 1.9
  TOP w0.203: Q16.1 52.26,87.37 LED4.1
N49010205: length 2.3
  TOP w0.112: YC3.3 50.97,130.92 50.77,131.11 CC97.2 50.77,131.43 50.36,131.85 RC374.2 RC377.1
N49010514: length 4.3
  TOP w0.112: YC3.1 50.29,130.17 50.29,131.23 CC96.2 50,131.52 50,132.28 50.3,132.59 RC374.1 50.36,132.84 50.28,132.91 RC378.1
N49018040: length 2.2
  TOP w0.112: v2(57.21,93.64) RE193.2 56.07,93.81 JESPI1.8
N49019257: length 2.3
  BOTTOM w0.112: RE50.1 27.47,125.27 27.05,125.69 26.05,125.69 Q12.1
N49054522: length 2
  BOTTOM w0.112: v2(24.54,101.94) 24.19,102.29 CE65.1 RE172.2
N49063593: length 2
  BOTTOM w0.112: RE219.1 RE222.2 20.28,120.65 20.47,120.84 QE15.3
N49063613: length 1.4
  BOTTOM w0.112: QE16.2 18.7,121.54 RE219.2
N49105313: length 3.1
  TOP w0.112: v2(22.2,32.68) 21.97,32.91 PR262.2
  TOP w0.381: PQ141.3 20,32.23 PR122.2 20.68,32.91 PR262.2
N49105729: length 2.5
  TOP w0.112: v2(22.34,30.79) 22.17,30.62 PR261.2
  TOP w0.381: PR261.2 20.22,30.62 PQ141.2
N49107876: length 2.3
  TOP w0.381: PQ142.3 18.43,19 19.23,19.8 PR264.2 19.1,20.13 PR132.2
N49107912: length 1.2
  TOP w0.508: PQ142.2 19.31,17.7 PR265.2
N49135368: length 10.8
  TOP w0.254: PR207.2 147.76,130.54 147.56,130.75 v12(147,130.75)
  GND1 w0.254: v12(147,130.75) v4(147,131.21)
  GND3 w0.254: v4(147,131.21) 146.93,131.13 v15(146.93,130.88)
  IN4 w0.254: v15(146.93,130.88) 146.93,130.52 147.21,130.24 147.21,127.16 147.42,126.95 v1(147.42,125.13)
  BOTTOM w0.112: PR206.2 145.71,125.83 v2(145.26,125.83)
  BOTTOM w0.254: v1(147.42,125.13) 147.13,124.84 PR206.2
N49135372: length 6.2
  TOP w0.254: PQ129.6 v7(147.64,131.4) 148.21,131.4 PR207.1
  BOTTOM w0.112: v2(145.16,129.12) 145.52,129.12 PR208.1
  BOTTOM w0.254: v7(147.64,131.4) 147.96,131.08 PR175.2 147.7,130.3 PR208.1
N49135382: length 3.2
  TOP w0.254: PQ127.6 139.73,129.04 v2(139.07,129.04) 138.87,129.24 138.87,129.86 PR124.2 139,129.99 PQ127.5
N49135384: length 8.1
  IN1 w0.254: v8(143.83,125.94) 142.63,127.13 v14(142.63,127.67) 142.63,129.92 v12(141.92,130.64)
  GND1 w0.254: v4(142.25,127.67) v14(142.63,127.67) ; v12(141.92,130.64) 141.98,130.7 v4(142.25,130.7)
  GND3 w0.254: v4(142.25,127.67) 142.11,127.54 v13(142.11,127.35) ; v13(141.86,130.7) v4(142.25,130.7)
  BOTTOM w0.112: v13(142.11,127.35) 142.28,127.18 v2(143.12,127.18)
N49135442: length 10.9
  TOP w0.112: v3(140.6,128.08) 140.6,127.36 v2(140.36,127.12)
  IN1 w0.254: v8(145.1,130.02) 145.1,129.75 146.19,128.65 v10(146.19,127.03)
  IN2 w0.254: v3(140.6,128.08) 140.6,127.89 141.31,127.19 143.47,127.19 143.78,127.5 144.32,127.5 144.79,127.03 v10(146.19,127.03)
N49135489: length 3.5
  TOP w0.254: PR201.2 142.72,131.81 142.47,131.56 142.47,130.27 142.19,129.99 v12(141.92,129.99)
  GND1 w0.254: v4(141.48,129.76) 141.69,129.76 v12(141.92,129.99)
  GND3 w0.254: v13(141.86,129.78) 141.5,129.78 v4(141.48,129.76)
N49135666: length 3.7
  TOP w0.112: PQ120.6 v2(144.01,134.49)
  TOP w0.254: PQ120.5 145.92,135.14 145.74,135.33 145.41,135.33 145.27,135.46 ; 145.27,135.46 PR127.2 ; 145.27,135.46 PQ120.6
N49135672: length 3.4
  TOP w0.254: v12(145.92,132.59) 145.92,132.16 145.75,131.98 144.41,131.98 PR144.2
  GND1 w0.254: v12(145.92,132.59) 145.92,132.36 v4(145.81,132.25)
  GND3 w0.254: v13(145.66,132.59) 145.66,132.4 v4(145.81,132.25)
N49135678: length 10.5
  TOP w0.112: v8(141.3,133.31) v2(141.3,134.28)
  TOP w0.254: PQ128.1 141.68,131.88 141.3,132.26 v8(141.3,133.31)
  IN1 w0.254: v12(146.57,132.59) 146.09,133.07 145.5,133.07 145,133.57 141.55,133.57 v8(141.3,133.31)
  GND1 w0.254: v12(146.57,132.59) v13(146.57,132.59) v4(146.57,132.22)
  GND3 w0.254: v13(146.57,132.59) v4(146.57,132.22)
  BOTTOM w0.254: PR143.2 146.32,133.55 146.57,133.3 v13(146.57,132.59)
N49135704: length 8.4
  TOP w0.254: v8(141.74,126.84) v2(141.74,126.46) PR200.1
  IN1 w0.254: v8(141.74,126.84) 141.74,127.19 142.01,127.46 142.01,129.37 141.47,129.92 141.47,130.58 140.17,131.88 v8(140.02,131.88)
N49135720: length 2.8
  TOP w0.254: PR145.2 143.89,133.62 v2(142.91,133.62) 142.49,133.2 142.49,132.78 142.24,132.53 PQ128.2
N49135818: length 5.9
  TOP w0.112: PQ122.6 v2(146.72,125.94)
  TOP w0.254: PR192.1 144.27,129.81 144.51,129.57 v8(144.51,129.27) ; v8(145.21,126.13) 145.4,125.94 PQ122.6
  IN1 w0.254: v8(145.21,126.13) 145.21,126.86 144.51,127.56 v8(144.51,129.27)
N49135824: length 5.4
  GND1 w0.254: v12(145.1,130.75) 145.1,130.75 v4(144.72,131.13)
  GND3 w0.254: v4(144.72,131.13) 144.7,131.14 144.7,131.46 v13(144.68,131.48)
  BOTTOM w0.112: PR202.2 141.85,132.21 v2(140.91,131.27)
  BOTTOM w0.254: v13(144.68,131.48) 144.46,131.7 142.38,131.7 PR202.2
N49135828: length 2.2
  GND1 w0.254: v12(145.73,125.29) v4(145.38,124.94)
  GND3 w0.254: v4(145.38,124.94) 145.48,124.84 v13(145.78,124.84)
  BOTTOM w0.112: v13(145.78,124.84) 145.02,124.84 v2(144.67,124.49)
N49135838: length 6.6
  TOP w0.112: v8(144.37,125.99) v2(144.37,126.99)
  TOP w0.254: PQ122.2 144.09,125.29 144.37,125.57 v8(144.37,125.99) ; PR138.2 v8(143,129.47)
  IN1 w0.254: v8(144.37,125.99) 144.37,126.18 143.66,126.89 143.66,128.16 143,128.82 v8(143,129.47)
N49140312: length 3.2
  TOP w0.381: PR271.1 16.51,43.37 17.06,43.92 17.06,45.12 16.71,45.47 PQ126.2
N49146615: length 6.4
  TOP w0.112: v2(150.67,127.22) 151.31,127.85 152.82,127.85 153.43,128.46 PR338.2
  TOP w0.254: PQ308.2 153.53,127.18 PR336.1 154.56,128.46 PR338.2
N49148321: length 2.3
  TOP w0.112: PD303.2 v2(156.47,120.7)
  TOP w0.254: PR343.2 155.28,120.69 PD303.2
N49148324: length 2.2
  TOP w0.112: PD302.2 v2(152.79,120.7)
  TOP w0.254: PR342.2 153.96,120.69 PD302.2
N49148345: length 5.3
  TOP w0.254: PR347.1 153.76,122.59 PD302.1 153.95,122.4 PD303.1 156.31,122.4 v2(156.62,122.71) PU301.2
N49148379: length 2.7
  TOP w0.112: v2(153.76,124.83) 154.09,124.5 PR345.2
  TOP w0.254: PR345.2 155.44,123.75 PU301.1
N49149484: length 2.9
  TOP w0.112: PU301.4 156.77,125.65 156.59,125.83 v2(156.59,126.39)
  TOP w0.254: PU301.4 157.27,126.03 157.52,126.28 PR351.1
N49570913: length 2.1
  BOTTOM w0.112: v2(129.87,144.31) 129.64,144.54 PC701.1
  BOTTOM w0.508: PR702.2 127.84,144.54 PC701.1
N49571039: length 1.4
  TOP w0.112: 125.35,143.58 124.08,143.58 v2(123.96,143.46)
N49601346: length 10
  TOP w0.254: MIC1.1 MIC1.2 19.13,175.46 19.75,176.09 19.75,176.85 19.56,177.04 v2(15.34,177.04) 13.63,177.04 RA41.2
N49601372: length 7.1
  TOP w0.254: RA42.2 v2(6.41,128.46) 3.94,125.99 MIC3.1 MIC3.2
N49601403: length 5.3
  TOP w0.254: MIC2.1 111.68,174.45 112.17,173.95 112.17,173.72 112.51,173.38 112.51,171.31 v2(112.66,171.16) 113.27,170.55 RA43.2
N49659209: length 2.9
  TOP w0.112: RS15.2 6.43,119.01 v2(5.92,118.51) 5.08,117.67 U3.1
N49659657: length 2.3
  TOP w0.112: U3.4 v2(3.26,118.75) 3.8,119.28 RS16.2
N49660582: length 3.3
  TOP w0.112: CS8.2 2.72,119.48 2.72,117.26 2.85,117.13 U3.5
N49667281: length 3.8
  BOTTOM w0.112: Q10.1 64.15,100.21 64.26,100.32 RE12.2 66.43,100.32 v2(67.03,99.72)
N49699324: length 7.2
  BOTTOM w0.112: C1134.1 52.76,102.85 53.06,102.54 Q352.2 ; C1134.1 R233.1 52.4,105.06 R234.2 ; C1134.1 52.4,102.55 52.24,102.39 51.13,102.39 v2(50.98,102.54)
N49699330: length 3
  BOTTOM w0.112: Q353.1 51.6,104.19 51.49,104.08 R233.2 50.27,103.7 v2(49.83,103.27)
N49815531: length 3.6
  TOP w0.112: v2(34.25,27.52) 34.47,27.52 35.49,26.5 PQ139.3
  TOP w0.508: PR110.2 36.38,27.48 PQ139.3
N49816160: length 1.1
  TOP w0.381: PQ112.1 38.48,27.56 PR250.2
N49816176:
  vias: v2(36.84,34.67)
N49817963:
  vias: v2(27.04,29.2)
N49822184: length 7
  TOP w0.508: PR267.2 PR102.1 33.91,18.48 PU105.1 34.86,19.12 v2(35.81,20.07) PC284.1 35.54,21.27 34.65,22.16 PR119.1
N49835416: length 3.1
  TOP w0.112: PR112.2 31.29,25.13 v2(32.24,26.07)
  TOP w0.381: PR112.2 30.85,24.64 30.61,24.64 PQ110.1
N50054694: length 16.1
  IN3 w0.066: v5(37.19,126.81) 36.74,127.26 34.71,127.26 34.34,127.63 33.4,127.63 32.46,126.69 v6(32.46,126.66)
  IN4 w0.066: v1(27.93,118.4) 27.93,118.67 28.26,119 28.37,119 29.15,119.78 29.15,121.46 29.52,121.83 30.12,121.83 30.72,122.43 30.72,122.59 30.84,122.71 30.84,122.93 30.72,123.05 30.72,123.37 31.42,124.07 31.42,124.26 32.24,125.08 32.24,126.01 32.46,126.23 v6(32.46,126.66)
N50054805: length 16.8
  IN3 w0.066: v6(32.13,126.53) 32.13,126.53 32.31,126.35 36.17,126.35 36.6,125.92 v5(37.19,125.92)
  IN4 w0.066: v6(32.13,126.53) 32.05,126.46 32.05,126.28 32.04,126.27 32.04,126.16 30.55,124.67 30.55,123.33 29.99,122.76 29.99,122.42 29.56,122 29.45,122 28.99,121.53 28.99,119.85 28.3,119.17 28.23,119.17 28.23,119.16 27.71,119.16 v1(27.31,118.76)
  BOTTOM w0.076: v1(27.31,118.76) 27.3,118.76 27.3,118.76 27.41,118.65 27.41,118.18 27.13,117.9 UE3.E12
N50084753: length 3.4
  BOTTOM w0.112: Q31.2 46.07,101.22 R480.1 R481.1 45.44,100.93 45.24,100.73 v2(43.84,100.73)
N50745785: length 4.3
  BOTTOM w0.076: RE265.2 19.18,108.75 19.18,110.09 20.29,111.2 UE3.N4
N51017534: length 9.4
  IN4 w0.066: v1(25.04,111.67) 25.04,111.11 24.71,110.78 24.71,109.29 24.31,108.88 24.31,108.12 23.83,107.63 21.95,107.63 21.41,108.17 v1(21.26,108.17)
  BOTTOM w0.076: v1(21.26,108.17) 20.71,108.17 20,107.46 T58.1 ; v1(25.04,111.67) 24.73,111.99 UE3.H5
N51017637: length 5.2
  IN3 w0.066: v5(20.19,112.21) 20.19,112.38 21.92,114.11 v5(22.02,114.11)
  BOTTOM w0.076: v5(22.02,114.11) 21.92,114.21 21.92,114.8 UE3.L9 ; T59.1 v5(20.19,112.21)
N51049452: length 3
  TOP w0.112: Q354.3 127.27,93.06 127.47,92.86 127.47,91.11 D114.1
N51049502: length 2.3
  TOP w0.112: Q354.6 124.85,92.06 124.02,92.89 D113.1
N51064237: length 1.2
  TOP w0.203: R5766.2 49.05,87.17 LED5.2
N51064241: length 1.8
  TOP w0.203: Q356.1 48.09,84.77 48.2,84.67 LED5.1
N51204121: length 1.1
  BOTTOM w0.254: R5751.2 147.35,92.83 147.45,92.72 U4247.5
N51204123: length 1.3
  BOTTOM w0.254: R5755.2 146.14,92.86 146.5,92.51 U4247.4
N51204155: length 1.2
  BOTTOM w0.254: U4248.5 151.38,88.97 151.55,88.8 R5752.2
N51204157: length 1.3
  BOTTOM w0.254: U4248.4 152.33,89.21 152.76,88.79 R5756.2
N51204189: length 1.1
  BOTTOM w0.254: R5753.2 144.25,88.84 144.15,88.94 U4249.5
N51204191: length 1.3
  BOTTOM w0.254: U4249.4 145.09,89.08 145.45,88.72 R5757.2
N51204271: length 1.3
  BOTTOM w0.254: U4250.4 139.26,92.48 138.84,92.9 R5758.2
N51204273: length 1.2
  BOTTOM w0.254: U4250.5 140.21,92.72 140.04,92.89 R5754.2
N51204761: length 1.9
  BOTTOM w0.254: U4251.1 127.15,88.91 126.96,88.72 R5767.2 R5759.2
N51263457: length 20.4
  IN4 w0.066: v1(16.64,82.35) 17.09,82.8 17.09,87.42 16.73,87.78 16.73,90.44 16.97,90.68 16.97,92.31 v1(16.8,92.47)
  BOTTOM w0.112: Q357.3 25.63,92.73 25.14,92.25 17.02,92.25 v1(16.8,92.47)
N51360660: length 9.4
  BOTTOM w0.112: R5769.2 26.99,97.23 R5779.1 27.67,97.23 28.19,97.75 D116.1 28.55,98.55 28.55,99.05 28.73,99.23 C1131.1 R2745.1 31.23,97.78 31.51,98.06 Q349.2
N51360785: length 1.8
  BOTTOM w0.112: Q348.1 29.39,93.36 R5768.2
N51362251: length 6
  IN1 w0.066: v10(49.4,74.23) 49.15,74.23 48.15,75.24 v8(47.75,75.24)
  IN2 w0.066: v10(49.4,74.23) v4(49.78,74.23)
  IN3 w0.066: v5(49.53,73.85) 49.78,74.11 v4(49.78,74.23)
  BOTTOM w0.112: v5(49.53,73.85) 47.14,73.85 T60.1
N52900707: length 2.7
  TOP w0.112: v2(128.7,133.15) C24.1 128.14,134.18 127.76,134.56 U2.6
N52929311: length 1.7
  BOTTOM w0.112: U21.10 48.83,87.04 C129.1
N52929327: length 1.7
  BOTTOM w0.112: U21.12 48.74,87.84 C127.1
N52930580: length 2.6
  BOTTOM w0.112: C118.1 22.5,86.7 v2(22.26,86.7) U17.10
N52930730: length 2.6
  BOTTOM w0.112: U17.12 21.88,85.9 v2(22.37,85.4) 22.78,84.99 C119.1
N52934547: length 2.7
  BOTTOM w0.112: v2(19.72,138) 20.26,138.55 C85.1 20.72,138.4 U14.10
N52934693: length 1.6
  BOTTOM w0.112: U14.12 21.52,138.49 C84.1
N54060987: length 1.5
  BOTTOM w0.112: C1137.1 65.22,84.31 U4255.6
N56035976: length 2.4
  BOTTOM w0.112: PR723.2 v2(136.41,144.34)
  BOTTOM w0.508: PC727.1 PR723.2
N56036060: length 4.7
  TOP w0.254: PU720.7 136.77,141.48 136.53,141.23 136.53,140.02 136.22,139.71 v2(135.75,139.71) 135.37,139.71 135.06,140.02 PR726.1
N57034346: length 3.8
  TOP w0.076: 52.32,123.41 52.43,123.41 52.83,123 55.3,123 UCPU1.AC3
  TOP w0.112: 52.32,123.41 T15.1
N57313074: length 4.7
  TOP w0.076: UCPU1.AU8 58.31,115.31 v7(57.96,114.96)
  BOTTOM w0.112: RC168.2 55.63,112.71 56.64,113.73 56.64,114.06 57.16,114.58 57.58,114.58 v7(57.96,114.96)
N57670088: length 5.1
  TOP w0.076: 61.7,112.03 61.7,112.64 61.96,112.9 62.11,112.9 62.3,113.09 62.3,113.6 62.57,113.87 UCPU1.AW15
  TOP w0.112: 61.7,112.03 61.51,111.84 61.51,111.02 61.95,110.58 T26.1
N58864976: length 2.6
  BOTTOM w0.112: U21.5 52.79,87.04 53.02,86.81 53.77,86.81 R150.2 54.84,87.01 R149.2
N64926554: length 0.7
  BOTTOM w0.112: CC49.1 R121.2
N118152590: length 0.9
  BOTTOM w0.112: PC818.1 v9(50.22,147.08)

## Copper pours and planes (outline as drawn)
3V_VIN on TOP (solid shape): 121.83,121.88 121.83,120.39 121.72,120.28 120.97,120.28 120.81,120.12 120.81,119.54 120.02,118.75 120.02,117.67 119.89,117.54 119.63,117.54 119.57,117.6 119.57,121.79 119.83,122.05 121.66,122.05
3V_VIN on BOTTOM (solid shape): 120.78,121.79 120.78,119.51 120.65,119.38 119.7,119.38 119.51,119.57 119.51,121.92 119.57,121.99 120.59,121.99
5VALW_VIN on TOP (solid shape): 45.53,154.14 45.53,152.32 46.11,151.74 46.11,149.37 45.9,149.16 44.52,149.16 44.06,149.62 44.06,151.76 45.09,152.78 45.09,154.1 45.24,154.25 45.42,154.25
5VALW_VIN on BOTTOM (solid shape): 45.59,153.74 45.59,152.15 45.9,151.84 45.9,150.88 46.13,150.65 46.13,149.19 46.06,149.12 45.03,149.12 44.83,149.33 44.83,150.28 44.07,151.04 44.07,153.23 44.64,153.8 45.53,153.8
5VD_VIN on TOP (solid shape): 122.27,148.7 122.27,147.26 120.52,145.51 120.52,144.62 120.4,144.49 120.27,144.49 120.14,144.62 120.14,145.12 120.02,145.25 120.02,148.74 120.08,148.81 122.17,148.81
5VD_VIN on BOTTOM (solid shape): 121.32,148.67 121.32,147.02 121.13,146.83 120.12,146.83 119.99,146.95 119.99,148.79 120.05,148.86 121.13,148.86
+0.6VS on TOP (solid shape): 86.59,107.13 86.59,106.64 86.64,106.59 87.04,106.59 87.09,106.59 87.42,106.26 90.85,106.26 90.93,106.19 90.93,105.75 90.7,105.53 89.82,105.53 88.8,104.5 88.8,103.27 88.45,102.92 88.42,102.92 88.42,102.9 88.35,102.83 88.35,97.2 88.8,96.76 88.8,95.7 88.35,95.26 88.35,91.32 88.31,91.28 87.73,91.28 87.26,91.75 87.26,95.39 88.08,95.39 88.08,96.15 87.37,96.15 87.37,95.39 87.26,95.39 87.26,96.16 87.26,96.19 87.17,96.27 87.17,96.34 88.08,96.34 88.08,97.11 87.37,97.11 87.37,96.34 87.17,96.34 87.17,97.11 87.33,97.28 87.33,103.69 87.17,103.85 87.17,104.55 86.6,105.12 81.84,105.12 81.53,105.42 81.53,106.24 81.58,106.29 82.69,106.29 83.11,106.71 85.32,106.71 85.43,106.59 85.74,106.59 86.28,106.59 86.33,106.59 86.39,106.64 86.39,107.13 86.41,107.15 86.56,107.15
+0.6VS on BOTTOM: 87.15,91.45 87.07,91.53 87.07,96.95 87.24,97.12 87.24,98.75 87.14,98.86 87.14,104.41 86.28,105.26 85.4,105.26 85.01,105.65 85.01,106.19 85.14,106.31 88.49,106.31 88.77,106.03 88.77,104.61 88.76,104.6 88.32,104.16 88.32,100.12 88.92,99.52 88.92,97.12 88.78,96.98 88.27,96.98 88.16,96.86 88.16,91.6 88.01,91.45
+0.6VSP on TOP (solid shape): 90.73,107.53 90.73,107.08 90.58,106.92 87.22,106.92 87,106.69 86.74,106.69 86.72,106.72 86.72,107.2 86.66,107.25 86.31,107.25 86.26,107.2 86.26,106.72 86.23,106.69 85.78,106.69 85.7,106.78 85.7,107.81 85.91,108.02 90.24,108.02
+0.6VSP on TOP (solid shape): 106.62,119.83 106.62,119.65 106.54,119.58 105.37,119.58 105.3,119.51 105.28,119.51 104.97,119.19 104.97,118.68 105.28,118.37 106.5,118.37 106.58,118.29 106.58,118.16 106.47,118.05 106.23,118.05 105.95,117.76 105.95,117.15 106.12,116.97 106.12,114.61 105.91,114.4 105.6,114.4 104.93,114.9 104.14,115.27 104.14,119.76 104.27,119.89 106.55,119.89
+0.6VSP on IN1 (solid shape): 106.12,114.98 106.12,114.1 105.93,113.92 102.77,113.92 102.63,114.05 102.63,115.02 102.74,115.13 105.97,115.13
+0.6VSP on IN1: 90.28,108.35 91.44,108.35 91.53,108.26 91.53,107.38 91.45,107.3 91.04,107.3 90.7,106.96 90.06,106.96 89.81,107.22 89.81,107.87
+1.0V_AMPHYPLL on BOTTOM (solid shape): 62.1,130.11 62.1,128.91 61.79,128.59 61.24,128.59 61.24,128.6 60.63,128.6 60.58,128.65 60.58,129.16 60.71,129.29 61.28,129.29 61.47,129.48 61.47,130.11 61.53,130.18 62.04,130.18
+1.0V_APLLEBB on IN4 (solid shape): 55.71,128.14 55.71,127.92 54.85,127.92 54.38,128.4 54.38,128.72 54.59,128.93 54.92,128.93
+1.0V_CLK on BOTTOM (solid shape): 57.91,135.19 57.91,134.05 58.29,133.67 61.79,133.67 61.79,133.61 62.67,133.61 62.74,133.54 62.74,132.91 61.08,132.91 60.99,133 60.55,133 60.24,132.68 60.24,132.24 60.39,132.09 60.39,131.89 58.29,131.89 57.18,133.01 57.18,135.26 57.84,135.26
+1.0V_CLK on IN3 (solid shape): 63.35,136.97 63.35,136.72 63.25,136.62 62.99,136.62 62.26,137.35 62.26,137.48 62.46,137.68 62.64,137.68
+1.0V_MPHYGT on TOP (solid shape): 63.64,128.09 63.64,127.74 63.31,127.42 63.31,127.13 63.2,127.02 63.16,126.94 63.16,126.93 63.03,126.8 63.02,126.8 62.9,126.76 62.81,126.68 62.7,126.68 62.5,126.8 62.26,126.77 61.66,126.77 61.57,126.86 61.57,128.19 61.63,128.25 63.48,128.25
+1.0V_MPHYGT on BOTTOM (solid shape): outline of 110 points within 54.67,125.16 63.31,131.76
+1.0V_PRIM_CORE on BOTTOM (solid shape): 43.88,148.66 43.88,146.49 43.39,146.49 43.39,146.03 43.88,146.03 43.88,145.69 43.39,145.69 43.39,145.23 43.88,145.23 43.88,144.78 43.69,144.59 41.91,144.59 41.78,144.72 41.78,148.59 41.97,148.78 43.75,148.78
+1.0V_PRIM_CORE on BOTTOM (solid shape): 66.61,124.89 66.61,123.9 66.87,123.65 66.87,122.81 66.8,122.75 65.6,122.75 65.28,122.43 65.28,121.35 65.02,121.1 64.43,121.1 64.34,121.18 64.34,121.76 64.2,121.91 64.2,122.43 65.47,123.7 65.47,124.97 65.53,125.03 66.47,125.03
+1.0V_PRIM_CORE on IN3 (solid shape): outline of 821 points within 55.5,121.86 66.93,126.24
+1.0V_PRIM_CORE on VCC: 53.95,119.32 51.18,122.09 51.18,132 47.1,136.08 43.36,136.08 42.49,136.95 42.49,147.72 42.92,148.15 48.49,148.15 48.85,148.5 50.21,148.5 51.15,149.44 51.56,149.44 51.56,138.39 57.4,132.55 57.4,119.32
+1.0V_PRIM_COREP on TOP (solid shape): 47.15,147.36 48.16,147.36 48.44,147.08 48.44,145.4 48.32,145.29 46.61,145.29 46.16,144.85 44.07,144.85 43.43,145.48 43.43,146.62 43.75,146.94 43.75,147.34 43.88,147.47 47.03,147.47
+1.0V_PRIM_COREP on BOTTOM (solid shape): 47.3,147.28 47.3,145.48 47.11,145.29 46.74,145.29 46.04,144.59 44.23,144.59 44.04,144.79 44.04,145.33 44.03,145.34 43.49,145.34 43.49,145.34 43.49,145.59 43.93,145.59 44.04,145.59 44.04,146.14 43.49,146.14 43.49,146.39 44.04,146.39 44.04,146.39 44.04,146.97 44.53,147.46 47.12,147.46
+1.0V_SRAM on IN1 (solid shape): outline of 177 points within 64.71,121.22 67.94,126.68
+1.0V_SRAM on IN4 (solid shape): outline of 533 points within 53.91,124.21 65.91,127
+1.0V_VCCST on TOP (solid shape): 64.69,138.06 64.69,137.5 64.31,137.12 64.31,135.85 64.52,135.65 64.52,134.43 64.41,134.33 64.11,134.33 63.96,134.48 63.96,135.07 63.65,135.37 63.65,137.58 64.26,138.19 64.57,138.19
+1.0V_VCCST on BOTTOM (solid shape): 52.63,138.8 52.63,138.09 52.5,137.96 50.67,137.96 50.6,138.04 50.6,138.3 50.84,138.54 50.84,138.93 52.5,138.93
+1.0V_VCCST on BOTTOM (solid shape): 19.31,120.94 19.31,120.2 19.06,119.95 18.41,119.95 18.31,119.85 18.31,118.91 18.29,118.89 17.88,118.89 17.86,118.9 17.86,119.39 17.83,119.43 17.83,119.99 18.06,120.22 18.29,120.38 18.38,120.65 18.38,120.76 18.62,121 19.25,121
+1.0V_VCCST on IN1 (solid shape): 64.39,145.28 64.39,144.79 64.35,144.76 64.35,142.09 64.52,141.92 64.52,140.25 65.81,138.95 65.81,137.63 65.58,137.4 64.44,137.4 64.29,137.56 64.29,137.94 64.44,138.09 64.82,138.09 65.07,138.34 65.07,138.77 63.8,140.04 63.8,141.37 63.5,141.67 63.5,145.33 63.75,145.58 64.08,145.58
+1.0V_VCCST on IN3 (solid shape): 52.55,138.29 52.35,138.09 51.51,138.09 50.34,139.26 50.34,139.97 50.42,140.04 50.8,140.04
+1.0V_VCCST on IN4 (solid shape): 20.98,135.73 20.98,134.65 20.79,134.46 20.29,134.46 20.07,134.69 20.07,135.55 20.32,135.8 20.9,135.8
+1.0V_VCCST on IN4 (solid shape): outline of 224 points within 16.7,120.18 19.2,126.18
+1.0V_VCCST_R on BOTTOM (solid shape): 51.82,137.23 51.82,136.21 51.31,135.7 51.31,135.57 51.12,135.38 49.72,135.38 49.55,135.56 49.55,135.85 49.72,136.02 50.1,136.02 50.5,136.42 50.5,137.26 51.78,137.26
+1.0V_VCCSTG_R26 on BOTTOM (solid shape): 65.15,138.83 65.15,137.48 64.39,136.72 63.37,136.72 63.25,136.84 63.25,138.18 63.44,138.37 63.74,138.37 64.34,138.98 65,138.98
+1.0VA on BOTTOM (solid shape): 129.35,148.08 129.35,147.7 128.78,147.7 128.78,146.31 129.35,146.31 129.35,145.67 129.03,145.35 125.6,145.35 125.48,145.48 125.48,148.02 125.73,148.27 129.16,148.27
+1.0VA on BOTTOM (solid shape): 65.34,124.33 65.34,123.76 64.39,122.81 63.88,122.81 63.82,122.87 63.82,123.45 63.5,123.76 63.5,123.94 64.05,123.94 64.05,123.88 64.06,123.83 64.08,123.78 64.1,123.74 64.13,123.69 64.17,123.66 64.21,123.63 64.25,123.6 64.3,123.59 64.36,123.58 64.41,123.58 64.46,123.59 64.51,123.6 64.55,123.63 64.6,123.66 64.63,123.69 64.66,123.74 64.69,123.78 64.7,123.83 64.71,123.88 64.71,123.94 64.7,123.99 64.69,124.04 64.66,124.08 64.63,124.12 64.6,124.16 64.55,124.19 64.51,124.22 64.46,124.23 64.41,124.24 64.36,124.24 64.3,124.23 64.25,124.22 64.21,124.19 64.17,124.16 64.13,124.12 64.1,124.08 64.08,124.04 64.06,123.99 64.05,123.94 63.5,123.94 63.5,124.33 63.62,124.46 63.68,124.44 63.74,124.44 63.8,124.45 63.83,124.46 65.21,124.46
+1.0VA on BOTTOM (solid shape): outline of 100 points within 48.81,130.75 62.99,139.05
+1.0VA on IN3 (solid shape): 59.03,138.04 59.03,136.87 58.64,136.48 57.36,136.48 57.03,136.81 57.03,137.91 57.59,138.47 58.6,138.47
+1.0VA on IN4 (solid shape): outline of 579 points within 52.76,121.6 65.28,124.96
+1.0VA on VCC: 57.91,119.32 57.91,132.76 52.07,138.6 52.07,149.44 53.15,149.44 54.74,151.03 54.74,154.9 55.22,155.39 103.17,155.39 123.67,148.07 124.87,147.64 126.64,147.64 126.87,147.41 126.87,143.68 125.88,142.69 109.6,142.69 106.54,142.69 106.2,143.02 106.2,147.5 105.69,148.02 56.98,148.02 55.63,146.66 55.63,141.06 65.91,130.77 65.91,119.32
+1.0VA_XDP on BOTTOM (solid shape): 157.6,131.31 157.6,130.8 157.72,130.68 158.32,130.68 158.43,130.57 158.43,129.06 158.75,128.74 158.75,128.07 158.7,128.02 157.36,128.02 157.27,128.11 157.27,129.66 156.93,130 156.93,130.77 156.72,130.99 155.68,130.99 155.42,130.74 152.82,130.74 152.77,130.78 152.77,131.08 152.81,131.12 153.8,131.12 154.13,131.45 157.47,131.45
+1.0VA_XDP1 on BOTTOM (solid shape): 56.01,139.79 56.01,139.51 55.91,139.41 54.13,139.41 54.08,139.36 54.08,138.06 54.51,137.63 54.51,137.2 54.43,137.12 53.62,137.12 53.14,137.61 53.14,139.46 53.59,139.92 55.88,139.92
+1.0VAP on TOP (solid shape): 132.08,148.27 132.08,145.86 131.7,145.48 128.08,145.48 127.64,145.92 127.64,148.27 127.89,148.53 131.83,148.53
+1.0VAP on BOTTOM (solid shape): 132.08,148.4 132.08,145.67 131.89,145.48 129.6,145.48 129.54,145.54 129.54,148.27 129.79,148.53 131.95,148.53
+1.0VS_VCCIO on TOP (solid shape): 117.41,132.72 117.41,131.83 116.84,131.83 116.84,130.43 117.41,130.43 117.41,129.99 117.28,129.86 116.2,129.86 115.95,130.11 115.95,132.78 116.14,132.97 117.16,132.97
+1.0VS_VCCIO on TOP (solid shape): 71.48,120.56 71.48,118.83 71.96,118.35 71.96,118.1 71.86,118 71.63,118 71.44,118.19 71.11,118.19 70.93,118.01 70.69,118.01 70.19,118.5 70.19,119.84 70.19,119.84 70.19,120.57 70.26,120.64 71.4,120.64
+1.0VS_VCCIO on TOP (solid shape): 77.88,120.33 77.88,119.96 77.72,119.81 77.58,119.81 77.39,119.62 77.39,119.61 77.39,119.06 77.39,119.05 77.85,118.59 77.85,118.47 77.75,118.36 77.57,118.36 77.01,118.92 77.01,119.75 76.76,120 76.76,120.32 76.95,120.51 77.7,120.51
+1.0VS_VCCIO on BOTTOM (solid shape): 78.49,120.21 78.49,119.41 78.4,119.32 77.74,119.32 77.6,119.18 76.63,119.18 76.55,119.26 76.55,120.09 76.8,120.33 78.36,120.33
+1.0VS_VCCIO on BOTTOM (solid shape): 72.26,119.48 72.26,118.94 72.16,118.84 71.97,118.84 71.2,118.06 69.43,118.06 69.37,118.12 69.37,118.49 69.22,118.64 68.28,118.64 68.11,118.81 68.11,119.45 68.2,119.53 72.21,119.53
+1.0VS_VCCIO on IN1 (solid shape): outline of 3049 points within 70.23,117.93 117.09,134.19
+1.0VS_VCCIO on IN3 (solid shape): 71.35,120.14 71.35,119.19 71.17,119.01 69.93,119.01 69.85,119.09 69.85,119.39 70.03,119.57 70.03,120.28 70.24,120.5 70.99,120.5
+1.0VS_VCCIO on IN4 (solid shape): outline of 127 points within 24.37,139.59 25.5,143.86
+1.0VS_VCCIOP on TOP (solid shape): 119.95,133.79 119.95,133.23 120.4,132.78 120.4,129.1 120.52,128.97 122.17,128.97 122.68,128.46 122.68,128.21 122.56,128.08 117.98,128.08 117.6,128.46 117.6,133.56 117.96,133.92 119.82,133.92
+1.2V_DDR on TOP (solid shape): outline of 8837 points within 65.2,89.88 110.72,114.2
+1.2V_DDR on IN1 (solid shape): 71.68,79.86 71.68,79.44 71.55,79.31 71.35,79.31 71.35,79.31 70.87,79.31 69.72,80.46 69.72,80.84 69.88,80.99 70.55,80.99
+1.2V_DDR on IN1 (solid shape): outline of 3366 points within 66.55,109.29 83.06,116.02
+1.2V_DDR on IN3 (solid shape): 18.72,34.39 18.72,33.87 18.59,33.75 18.22,33.75 17.54,34.43 17.54,34.81 17.64,34.91 18.19,34.91
+1.2V_DDR on IN3 (solid shape): 69.6,80.81 69.6,80.53 69.09,80.02 68.2,80.02 68.05,80.18 68.05,80.35 68.3,80.61 68.86,80.61 69.19,80.94 69.47,80.94
+1.2V_DDR on BOTTOM: outline of 638 points within 65.53,89.84 110.11,121.47 ; 6 cut-outs
+1.2V_DDRP on TOP (solid shape): 111.76,110.81 111.76,108.9 111,108.14 111,105.79 111.44,105.35 111.44,104.4 111.38,104.33 110.12,104.33 110.12,103.75 109.89,103.75 109.89,104.31 109.32,104.31 109.32,103.75 109.08,103.75 109.08,104.33 108.58,104.33 108.46,104.46 108.46,108.27 108.33,108.4 108.33,110.94 108.46,111.06 111.51,111.06
+1.2V_UF_DVDD on BOTTOM (solid shape): 146.75,142.81 145.26,142.81 145.19,142.88 145.19,143.78 145.28,143.87 146.75,143.87
+1.5VS_AUDIO on BOTTOM (solid shape): 18.26,128.84 18.26,127.01 18.21,126.96 17.5,126.96 17.37,127.09 17.37,127.73 16.87,128.23 16.21,128.23 16.13,128.31 16.13,129.02 16.23,129.12 17.98,129.12
+1.5VS_AUDIO_R on BOTTOM (solid shape): 20.51,128.72 20.51,128.21 20.26,127.95 18.54,127.95 18.48,128.02 18.48,128.91 18.54,128.97 20.26,128.97
+1.8V_PGPP on BOTTOM (solid shape): 70.5,85.64 70.5,84.66 70.41,84.57 68.35,84.57 68.17,84.75 68.17,85.6 68.53,85.96 70.18,85.96
+1.8V_PGPP on IN3 (solid shape): 15.23,144.91 15.23,144.39 15.1,144.25 13.96,144.25 13.72,144.49 13.72,144.96 13.84,145.08 15.07,145.08
+1.8V_PGPP on IN3 (solid shape): 52.49,129.58 52.57,129.54 52.59,129.45 52.62,129.21 52.81,129.07 52.85,129.06 52.89,129.06 52.93,129.06 52.98,129.07 53.1,128.96 53.1,128.93 53.18,128.76 53.38,128.71 53.55,128.65 53.71,128.74 53.79,128.78 53.86,128.75 54.58,128.03 54.58,127.95 54.28,127.64 53.1,127.64 51.71,129.03 51.71,129.48 51.82,129.58
+1.8V_PGPP on IN4 (solid shape): 57.35,110.53 57.35,110 57.17,109.82 57.17,109.09 57.08,109 56.71,109 56.59,109.12 56.59,110.3 56.97,110.68 57.2,110.68
+1.8V_PGPP on IN4 (solid shape): 54.86,127.65 54.86,126.62 54.36,126.12 53.02,126.12 52.88,126.26 52.88,126.97 53.49,127.58 53.53,127.6 53.86,127.93 53.88,127.97 54.02,128.1 54.41,128.1
+1.8V_UF_VDD on BOTTOM (solid shape): 149.77,148.65 149.77,146.71 149.6,146.55 149.55,146.55 149.55,146.56 148.7,146.56 148.61,146.65 148.61,147.33 148.67,147.38 149,147.38 149.19,147.57 149.19,148.6 149.29,148.7 149.71,148.7
+1.8V_WF_DOVDD on BOTTOM (solid shape): 146.75,141.51 145.23,141.51 145.19,141.56 145.19,142.51 145.25,142.58 146.75,142.58
+1.8VA on TOP (solid shape): 134.87,147.39 134.87,146.18 134.75,146.05 133.86,146.05 133.6,146.31 133.6,147.32 133.79,147.51 134.75,147.51
+1.8VA on TOP (solid shape): 54.48,124.14 54.48,123.89 54.29,123.7 53.78,123.7 53.58,123.5 53.08,123.5 52.9,123.68 52.9,124.07 53.09,124.27 54.36,124.27
+1.8VA on TOP (solid shape): 45.52,122.43 45.72,122.23 45.72,121.92 45.66,121.86 43.37,121.86 43.31,121.8 43.28,121.8 43.28,121.77 42.42,120.91 42.04,120.91 41.97,120.84 41.95,120.84 41.95,120.82 41.72,120.59 41.72,117.03 41.66,116.97 41.21,116.97 41.08,117.1 41.08,121.1 41.75,121.76 42.13,121.76 42.8,122.43 44.33,122.43
+1.8VA on BOTTOM (solid shape): 20.43,135.23 20.43,133.21 20.26,133.03 18.8,133.03 18.48,133.35 18.48,135 18.54,135.07 19.43,135.07 19.66,135.29 20.37,135.29
+1.8VA on BOTTOM (solid shape): 16.81,101.89 16.81,100.83 16.63,100.64 16.08,100.64 16.07,100.66 16.07,101.94 16.17,102.05 16.66,102.05
+1.8VA on BOTTOM (solid shape): 52.32,125.99 52.32,124.84 52.64,124.53 53.85,124.53 53.98,124.4 53.98,123.83 53.72,123.57 53.47,123.57 52.2,122.3 51.44,122.3 51.44,125.99 51.5,126.05 52.26,126.05
+1.8VA on BOTTOM (solid shape): 17.09,111.19 17.09,110.71 17.2,110.61 17.35,110.61 17.4,110.56 17.4,109.56 17.3,109.46 16.66,109.46 16.54,109.34 16.54,108.84 16.51,108.82 16.09,108.82 16.03,108.88 16.03,111.04 16.23,111.24 17.04,111.24
+1.8VA on IN1 (solid shape): 20.13,134.37 20.13,133.48 19.88,133.22 18.99,133.22 18.8,133.42 18.8,134.37 19.11,134.69 19.81,134.69
+1.8VA on IN1 (solid shape): 110.74,154.12 110.74,153.86 110.11,153.23 109.86,153.23 108.84,154.24 108.84,154.88 108.97,155.01 109.86,155.01
+1.8VA on IN2 (solid shape): 48.69,125.06 48.69,124.19 48.54,124.04 48.52,124.04 48.35,123.98 48.28,123.81 48.29,123.79 47.85,123.35 47.84,123.35 47.76,123.29 47.71,123.21 47.7,123.21 47.24,122.75 46.91,122.75 46.61,122.77 46.43,122.52 46.43,122.5 45.78,121.86 45.47,121.86 45.38,121.95 45.37,121.96 45.32,122.09 45.21,122.18 45.21,122.63 45.75,123.17 46.07,123.17 46.36,123.27 46.42,123.57 46.42,123.81 46.92,124.32 47.41,124.32 47.87,124.24 47.88,124.7 47.9,124.87 47.79,125.01 47.74,125.08 47.77,125.17 47.92,125.31 48.44,125.31
+1.8VA on IN3 (solid shape): 117.9,173.96 117.9,172.11 117.77,171.97 116.9,171.97 116.82,172.05 116.82,173.88 117.07,174.13 117.74,174.13
+1.8VA on IN3 (solid shape): 134.56,148.15 134.56,146.44 134.3,146.18 133.74,146.18 133.53,146.39 133.53,148.14 133.67,148.27 134.43,148.27
+1.8VA on IN3 (solid shape): 150.85,138.61 150.85,137.86 150.61,137.62 148.56,137.62 148.5,137.67 148.5,138.68 148.58,138.76 150.7,138.76
+1.8VA on IN3 (solid shape): 137.16,149.94 137.16,149.05 137.1,148.99 134.73,148.99 134.43,149.29 134.43,149.79 134.65,150 137.1,150
+1.8VA on IN3 (solid shape): 20.76,133.1 20.76,132.97 20.13,132.34 20,132.34 19.56,132.78 18.99,132.78 18.83,132.94 18.83,133.7 18.99,133.86 20,133.86
+1.8VA on IN3 (solid shape): 112.2,152.62 112.2,152.24 111.73,151.78 111.37,151.78 109.67,153.47 109.67,153.58 110.35,154.26 110.56,154.26
+1.8VA on IN3 (solid shape): 123.67,161.49 123.67,158.75 123.68,158.74 124.21,158.22 124.21,158.13 123.79,157.71 123.25,157.71 122.49,158.47 122.49,161.66 122.58,161.75 123.42,161.75
+1.8VA on IN3 (solid shape): 16.61,111.29 16.97,111.29 17.12,111.14 17.12,110.71 17.02,110.61 16,110.61 13.54,113.07 11.22,113.07 11.02,113.28 11.02,113.8 11.12,113.91 14,113.91
+1.8VA on IN3 (solid shape): 48.53,126.38 48.53,125.8 49.19,125.14 53.52,125.14 54.04,124.62 54.04,123.97 53.66,123.59 52.83,123.59 52.57,123.85 50.11,123.85 50.06,123.89 50.06,124.19 50.13,124.72 49.65,124.51 49.64,124.49 49.57,124.42 49.57,124.09 49.5,124.02 48.21,124.02 48.01,124.22 48.01,124.65 47.83,124.83 47.73,124.83 47.4,125.15 47.4,126.42 47.51,126.53 48.38,126.53
+1.8VAP on TOP (solid shape): 137.6,147.26 137.6,144.78 137.29,144.46 135.64,144.46 135.06,145.04 135.06,146.5 135.64,146.5 135.64,147 135.06,147 135.06,147.39 135.19,147.51 137.35,147.51
+1.8VS on TOP (solid shape): 34.96,112.55 34.96,110.95 34.86,110.85 34.06,110.85 33.97,110.94 33.97,111.9 34.05,111.98 34.05,112.57 34.15,112.68 34.84,112.68
+1.8VS on BOTTOM (solid shape): 29.41,138.49 29.41,137.17 29.23,137 28.69,137 28.4,137.28 28.4,138.7 28.51,138.81 29.08,138.81
+1.8VS on IN3 (solid shape): 31.6,125.85 31.6,125.62 31.37,125.39 31.17,125.39 30.86,125.69 30.48,125.69 30.48,125.69 30.36,125.69 30,126.05 30,126.22 30.18,126.4 31.04,126.4
+1.8VS on IN4 (solid shape): 30.56,126.13 30.56,125.77 30.48,125.69 30.09,125.69 29.12,126.66 29.12,127.2 29.24,127.32 29.36,127.32
+1.8VS_AUDIO_R on BOTTOM (solid shape): 20.43,137.44 20.43,136.61 20.37,136.55 19.85,136.55 19.73,136.68 18.1,136.68 18.03,136.74 18.03,137.48 18.09,137.54 20.33,137.54
+1.8VS_CR_R on BOTTOM (solid shape): 66.78,85.54 66.78,84.71 66.73,84.66 64.82,84.66 64.77,84.71 64.77,85.62 64.8,85.65 66.66,85.65
+1.8VU on TOP (solid shape): 97.8,105.42 97.8,104.37 97.83,104.34 97.83,104.3 98.4,103.73 98.4,102.71 98.22,102.53 97.94,102.53 97.33,103.14 95.69,103.14 95.06,102.52 92.69,102.52 92.69,102.52 92.35,102.52 92.23,102.64 92.23,103.43 92.68,103.87 93.03,103.87 93.47,104.3 93.99,104.3 94.17,104.48 94.17,105.31 94.32,105.46 97.76,105.46
+1.8VU on TOP (solid shape): 80.89,103.87 83.12,103.87 83.68,103.31 83.68,103.08 83.2,102.6 83.18,102.59 83.16,102.61 80.59,102.61 80.57,102.63 80.49,102.71 80.48,102.72 79.63,103.57 79.63,103.57 79.55,103.64 78.35,103.64 78.08,103.38 78.08,103.12 77.87,102.91 77.86,102.91 77.57,102.62 77.51,102.62 77.49,102.62 77.44,102.61 77.36,102.62 77.22,102.62 77.16,102.68 77.16,103.65 77.57,104.07 77.57,104.65 77.57,105.14 77.65,105.22 79.54,105.22
+1.8VU on TOP (solid shape): outline of 138 points within 77.04,87.6 107.76,93.07
+1.8VU on BOTTOM (solid shape): 93.47,103 94.93,103 95.06,102.87 95.06,102.68 94.93,102.55 92.33,102.55 92.27,102.62 92.27,102.87 92.77,103.38 93.09,103.38
+1.8VU on BOTTOM (solid shape): 82.17,103.32 82.17,103.19 82.3,103.06 83.06,103.06 83.25,102.87 83.25,102.74 83.12,102.62 80.52,102.62 80.46,102.68 80.46,103.32 80.58,103.44 82.04,103.44
+1.8VU on BOTTOM (solid shape): 82.24,92.63 83.03,92.63 83.21,92.45 83.21,92.04 82.56,91.39 82.05,91.39 81.4,90.74 79.36,90.74 79.24,90.62 79.24,89.98 79.19,89.94 78.32,89.94 78.16,90.09 78.16,90.89 77.24,91.82 77.24,92.48 77.36,92.6 77.54,92.6 77.69,92.45 77.69,92.15 77.92,91.92 79.75,91.92 80.46,92.63 81.41,92.63 81.59,92.8 81.63,92.84 81.67,92.89 81.72,92.94 81.93,92.94
+1.8VU on BOTTOM (solid shape): 98.3,92.4 98.3,90.11 98.15,89.95 97.33,89.95 96.53,90.75 94.55,90.75 93.78,91.52 93,91.52 92.29,92.23 92.29,92.43 92.36,92.5 92.99,92.5 92.99,92.5 94.95,92.5 95.02,92.47 95.05,92.41 95.13,92.2 95.31,92.09 95.39,92.08 95.46,92.09 95.48,92.1 95.94,91.64 97.62,91.64 97.82,91.84 97.82,92.43 97.92,92.53 98.18,92.53
+1.8VU on IN1 (solid shape): 79.39,103.94 79.39,103.47 79.33,103.41 78.75,103.41 78.63,103.43 78.52,103.41 78.44,103.41 78.24,103.21 78.24,103.02 78.07,102.85 76.78,102.85 76.7,102.94 76.7,103.46 76.87,103.63 77.23,103.63 77.8,104.21 79.12,104.21
+1.8VUP on TOP (solid shape): 110.19,91.64 110.29,91.64 110.45,91.48 110.45,89.3 110.29,89.15 108.07,89.15 107.81,88.89 106.41,88.89 106.38,88.92 106.38,89.23 106.88,89.23 106.88,89.62 106.38,89.62 106.38,90.67 106.49,90.78 107.71,90.78 107.88,90.95 107.88,91.53 108,91.64 110.18,91.64
+2.8V_UF_AVDD on BOTTOM (solid shape): 143.41,136.42 143.41,136.39 143.45,136.36 144.35,136.36 144.4,136.31 144.4,134.18 144.15,133.92 143.64,133.92 143.57,133.99 143.57,135.38 142.7,136.26 141.58,136.26 141.57,136.27 141.57,136.76 141.59,136.78 143.05,136.78
+2.8V_VCM_OUT on BOTTOM (solid shape): 157.06,141.05 157.06,138.45 156.37,137.76 152.52,137.76 152.45,137.83 152.45,138.42 152.53,138.49 153.42,138.49 153.42,138.52 154.2,138.52 154.43,138.74 156.04,138.74 156.42,139.12 156.42,141.17 156.46,141.21 156.9,141.21
+2.8V_WF_AVDD on BOTTOM (solid shape): 146.82,145.12 146.83,145.07 146.78,145.04 146.75,145.04 146.75,144.06 145.24,144.06 145.18,144.12 145.18,145.04 145.28,145.14 146.8,145.14
+3.3V_ALW_DSW on BOTTOM (solid shape): 52.58,121.54 59.94,121.54 60.13,121.35 60.13,120.59 60.01,120.46 59,120.46 58.8,120.26 58.8,119.39 58.48,119.08 57.21,119.08 56.72,119.57 52.65,119.57 51.74,118.66 51.62,118.66 50.8,117.84 50.8,116.78 50.67,116.65 49.78,116.65 49.53,116.91 49.53,119.25 49.72,119.45 50.73,119.45 51.37,120.09 51.37,121.92 51.44,121.99 52.13,121.99
+3.3V_ALW_DSW on IN3 (solid shape): 63.4,122.44 63.4,122.39 63.4,122.38 63.43,122.09 63.68,121.94 63.7,121.94 64.06,121.58 64.06,120.49 63.69,120.12 63.68,120.12 63.51,120.03 63.42,119.86 63.42,119.85 63.37,119.8 63.37,119.67 63.2,119.5 62.99,119.5 62.87,119.62 62.87,120.08 63.21,120.42 63.33,120.42 63.6,120.69 63.6,120.99 63.39,121.2 63.27,121.2 62.79,121.68 62.79,122.12 62.85,122.25 62.84,122.4 62.83,122.43 62.94,122.54 63.3,122.54
+3.3V_EC_PLL on BOTTOM (solid shape): 26.97,106.82 26.97,105.25 26.85,105.13 26.85,104.56 26.78,104.5 26.3,104.5 26.29,104.51 26.29,105.37 26.16,105.5 26.16,107.1 26.7,107.1
+3.3V_LDO_PD1 on BOTTOM (solid shape): 26.08,69.97 26.08,69.39 25.78,69.09 25.78,68.81 25.73,68.76 25.73,67.87 25.63,67.77 24.97,67.77 24.72,68.02 24.72,70.13 24.75,70.16 25.89,70.16
+3.3V_LDO_PD1 on BOTTOM (solid shape): 28.57,64.84 28.57,63.44 28.51,63.37 28,63.37 27.94,63.31 27.94,62.74 28.07,62.61 28.7,62.61 28.83,62.49 28.83,60.64 28.64,60.45 27.3,60.45 27.24,60.52 27.24,64.39 27.75,64.9 28.51,64.9
+3.3V_PGPP on BOTTOM (solid shape): 63.22,126.68 63.27,126.64 63.33,126.62 63.37,126.61 63.37,126.05 63.06,126.05 63.06,125.16 62.8,125.16 62.67,125.03 62.67,124.46 62.48,124.27 61.98,124.27 61.91,124.21 61.91,123.45 62.1,123.26 62.61,123.26 62.67,123.19 62.67,122.68 62.61,122.62 62.17,122.62 62.04,122.49 62.04,120.21 61.28,120.21 61.28,125.67 61.4,125.8 62.04,125.8 62.29,126.05 62.67,126.05 62.8,126.18 62.8,126.56 62.93,126.68
+3.3VDX_SSD on TOP (solid shape): 65.79,75.95 65.79,74.74 65.51,74.46 63.19,74.46 63.1,74.55 63.1,76.01 63.17,76.09 65.65,76.09
+3.3VDX_SSD on TOP (solid shape): 50.41,78.03 50.41,74.54 50.32,74.45 48.69,74.45 48.6,74.54 48.6,76.08 48.4,76.27 47.11,76.27 46.9,76.06 46.9,74.56 46.81,74.46 46.16,74.46 46.04,74.58 46.04,77.29 47.25,78.5 49.93,78.5
+3.3VDX_SSD on BOTTOM (solid shape): 47.74,86.3 47.74,84.49 47.69,84.44 46.73,84.44 46.65,84.53 46.65,85.46 46.43,85.68 45.87,85.68 45.78,85.77 45.78,86.28 45.9,86.4 47.64,86.4
+3.3VDX_SSD on BOTTOM (solid shape): 64.65,76.2 65.53,76.2 65.6,76.14 65.6,74.89 65.45,74.75 64.47,74.75 64.22,75 62.67,75 62.4,75.27 62.4,75.93 63.27,76.8 64.05,76.8
+3.3VDX_SSD on BOTTOM (solid shape): 50.25,77.54 50.25,76.64 50.26,76.63 50.26,75.53 50,75.27 44.05,75.27 43.94,75.38 43.94,77.15 44.06,77.26 44.36,77.26 44.92,76.7 45.6,76.7 46.66,77.76 50.03,77.76
+3.3VDX_SSD on IN3 (solid shape): 64.12,75.82 66.02,75.82 66.08,75.75 66.13,75.72 66.17,75.69 66.23,75.67 66.23,73.66 65.98,73.41 61.59,73.41 61.22,73.78 61.24,73.8 61.26,73.84 61.28,73.89 61.29,73.94 61.29,73.99 61.29,74.04 61.27,74.09 61.25,74.14 61.22,74.18 61.19,74.22 61.15,74.25 61.11,74.28 61.06,74.29 61.01,74.31 60.96,74.31 60.91,74.31 60.86,74.3 60.81,74.28 60.76,74.24 60.3,74.7 61.77,74.7 61.77,74.65 61.78,74.6 61.8,74.55 61.82,74.5 61.85,74.46 61.89,74.43 61.93,74.4 61.98,74.37 62.03,74.36 62.08,74.35 62.13,74.35 62.18,74.36 62.23,74.37 62.28,74.4 62.32,74.43 62.35,74.46 62.39,74.5 62.41,74.55 62.43,74.6 62.43,74.65 62.43,74.7 62.43,74.75 62.41,74.8 62.39,74.85 62.35,74.89 62.32,74.93 62.28,74.96 62.23,74.98 62.18,75 62.13,75.01 62.08,75.01 62.03,75 61.98,74.98 61.93,74.96 61.89,74.93 61.85,74.89 61.82,74.85 61.8,74.8 61.78,74.75 61.77,74.7 60.3,74.7 59.85,75.15 49.17,75.15 48.92,75.4 48.92,77.62 49.13,77.82 62.12,77.82
+3.3VDX_SSD on IN4 (solid shape): outline of 93 points within 45.83,75.59 51.28,86.24
+3.3VDX_SSD_R on BOTTOM (solid shape): 50.8,86.69 50.8,85.2 50.29,84.69 48.61,84.69 48.51,84.79 48.51,86.24 48.61,86.33 49.57,86.33 49.99,86.75 50.74,86.75
+3V_5105 on TOP (solid shape): 40.77,88.63 40.77,87.65 40.54,87.42 33.13,87.42 32.94,87.61 32.94,88.38 33.03,88.46 34.09,88.46 34.15,88.4 34.15,88 34.19,87.96 34.81,87.96 34.86,88.01 34.86,88.4 34.93,88.47 35.29,88.47 35.67,88.09 36.29,88.09 36.55,88.35 39.27,88.35 39.62,88.71 40.7,88.71
+3V_5105 on BOTTOM (solid shape): 17.7,107.18 17.7,106.11 17.73,106.08 17.73,105.4 17.22,105.4 17.14,105.48 17.14,107.13 17.2,107.18 17.7,107.18
+3V_5105 on BOTTOM (solid shape): 25.02,134.94 25.02,133.16 24.26,132.4 20.83,132.4 20.83,133.16 20.95,133.29 23.62,133.29 23.96,133.63 23.96,134.95 24.08,135.07 24.89,135.07
+3V_5105 on BOTTOM (solid shape): 33.4,116.3 33.4,115.46 33.12,115.18 33.12,114.55 33.27,114.41 33.27,113.9 33.48,113.69 33.48,113.3 33.58,113.2 34.06,113.2 34.09,113.17 34.09,112.76 33.1,112.76 33.02,112.84 33.02,113.74 32.9,113.86 32.51,113.86 32.38,113.98 32.38,115.13 32.51,115.25 32.65,115.25 32.79,115.4 32.79,116.32 32.97,116.5 33.2,116.5
