# Allegro board Dell Latitude 5290 2-IN-1 LA-F371P Boardview.brd (continued)
## Via types (continued)
v12: diameter 0.254, hole 0.102, TOP to GND1, 2439 vias
v13: diameter 0.254, hole 0.102, GND3 to BOTTOM, 2202 vias
v14: diameter 0.254, hole 0.102, IN1 to GND1, 267 vias
v15: diameter 0.254, hole 0.102, GND3 to IN4, 402 vias
v16: diameter 0.254, hole 0.102, GND1 to IN2, 597 vias
v17: diameter 0.254, hole 0.102, IN3 to GND3, 284 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.0V_PRIM_CORE_PG: length 5.1
  TOP w0.112: PR735.1 46.43,142.34 46.07,141.97 45.03,141.97 44.62,142.39 v2(44.62,142.51)
  TOP w0.254: PR735.1 46.86,142.43 47.31,142.88 47.31,143.83 47.45,143.97 PU801.4
1.0VA_PG: length 4.6
  TOP w0.112: 128.6,137.1 128.57,137.1 128.02,137.66 126.82,137.66 v2(126.7,137.53)
  TOP w0.254: 128.6,137.1 PR705.1 129.46,137.75 129.23,137.98 PU700.9
1.2V_DDR_OT: length 2.4
  TOP w0.254: v7(109.98,118.56) 109.63,118.2 PU600.11
  BOTTOM w0.254: v7(109.98,118.56) 109.3,119.24 PR600.2
1.2V_DDR_PG: length 13.3
  TOP w0.112: 102.68,121.59 v2(101.64,121.59)
  TOP w0.254: v3(103.56,121.6) 103.54,121.59 102.68,121.59
  IN2 w0.254: v3(109.23,118.7) 109.22,118.69 109.22,116.91 108.46,116.14 106.71,116.14 103.56,119.29 v3(103.56,121.6)
1.8VA_PG: length 167.8
  TOP w0.112: v2(133.91,143.59) 134.11,143.38 v8(134.11,142.99)
  TOP w0.254: PR725.1 v8(134.11,142.99)
  IN1 w0.254: v8(138.28,143.21) 138.16,143.33 v10(136.7,143.33) 134.45,143.33 v8(134.11,142.99)
  IN2 w0.066: v10(136.7,143.33) v4(136.7,143.68)
  IN3 w0.066: v4(136.7,143.68) 136.7,143.93 v6(136.6,144.03)
  IN4 w0.066: v6(136.6,144.03) 136.6,149.45 136.01,150.04 129.15,150.04 123.83,155.36 123.83,157.21 123.97,157.36 123.97,160.81 118.46,166.32 106.53,166.32 106.43,166.22 38.72,166.22 36.21,163.72 35.91,163.72 31.96,159.77 31.96,159.05 36.81,154.2 36.81,147.42 36.03,146.65 35.94,146.65 32.18,142.88 32.18,140.92 30.7,139.43 v1(30.7,129.01)
  BOTTOM w0.112: RE253.1 RE252.2 32.08,128.77 31.72,129.12 30.81,129.12 30.71,129.02 30.71,129.01 v1(30.7,129.01)
1.8VU_PG: length 3.1
  TOP w0.254: PU721.4 108.99,94.46 109.22,94.24 110.05,94.24 110.62,93.66 PR732.1
3.3V_CAM_EN: length 178.9
  IN2 w0.066: v4(57.78,113.86) 57.74,113.82 v3(57.74,113.5)
  IN3 w0.066: v4(57.78,113.86) 57.78,113.88 57.28,114.39 56.98,114.39 56.07,115.3 56.07,116.57 55.35,117.3 55.35,117.86 54.55,118.67 50.01,118.67 49.76,118.92 46.68,118.92 45.83,119.77 45.83,119.84 43.73,121.94 43.73,122.09 43.73,125.06 43.73,126.51 43.73,127.13 42.6,128.25 37.8,128.25 v6(37.74,128.31)
  IN4 w0.066: v6(37.74,128.31) 37.68,128.38 37.68,131.93 38.43,132.68 38.43,134.43 38.23,134.62 38.23,140.88 38.22,140.89 38.22,141.46 40.34,143.57 40.34,145.03 40.85,145.55 40.85,147.99 41.85,148.99 41.85,155.75 40.96,156.64 40.96,163.59 41.66,164.29 106.68,164.29 106.95,164.56 107.93,164.56 108.53,165.15 117.97,165.15 121.94,161.18 121.94,161.04 121.94,161.04 121.94,155.44 128.69,148.69 135.05,148.69 v1(135.15,148.59)
  BOTTOM w0.112: v1(135.15,148.59) 135.23,148.52 v2(135.79,148.52) 136.56,148.52 137.59,149.54 R442.1 138.26,149.03 U11.3
3.3V_IRCAM_EN#: length 57.6
  TOP w0.076: v7(61.72,115.64) 62.05,115.96 UCPU1.AT15
  IN3 w0.066: v5(36.28,101.18) 36.28,101.68 36.92,102.31 42.76,102.31 45.29,99.78 45.73,99.78 47.85,97.66 50.85,97.66 51.52,97 53.11,97 54.24,95.86 54.36,95.86 57.68,95.86 60.12,93.43 61.49,93.43 v6(61.69,93.63)
  IN4 w0.066: v6(61.69,93.63) 61.78,93.72 61.78,96.81 61.86,96.89 61.86,99.36 62.75,100.25 62.75,100.46 62.75,104.48 61.11,106.12 61.11,107.12 60.43,107.81 60.43,110.39 60.91,110.87 60.91,113.85 61.03,113.98 61.03,114.82 61.72,115.51 v7(61.72,115.64)
  BOTTOM w0.112: v5(36.28,101.18) 36.28,100.36 v2(36.06,100.13) 35.12,100.13 R5778.2
3.3V_TS_EN: length 133.6
  IN3 w0.066: v6(41.67,80.76) 43.15,80.76 44.55,79.36 50.72,79.36 51.38,78.7 60.76,78.7 v6(61.32,78.14)
  IN4 w0.066: v1(23.42,113.07) 23.47,113.02 24.6,113.02 24.76,113.18 24.94,113.18 25.83,113.18 26.08,113.18 26.14,113.23 28.51,113.23 29.2,112.54 29.2,111.69 29.54,111.35 29.54,108.28 31.22,106.6 31.44,106.6 31.71,106.33 31.88,106.33 32.49,105.73 32.49,105.68 32.89,105.28 32.89,100.96 33.59,100.26 33.59,99.35 35.28,97.65 35.28,96.65 36.62,95.32 36.62,91.68 36.56,91.62 36.56,90.17 37.32,89.41 37.32,89.15 37.06,88.89 37.06,87.34 41.58,82.82 41.58,80.85 v6(41.67,80.76) ; v6(61.32,78.14) 61.42,78.04 61.42,74.15 61.98,73.6 61.98,70.3 65.7,66.57 65.7,44.78 72.42,38.06 72.42,34.83 72.6,34.66 72.6,25.78 70.71,23.89 70.71,21.02 70.36,20.67 70.36,19.5 71.25,18.61 72.64,18.61 73.03,18.99 v1(73.03,19.12)
  BOTTOM w0.076: 23.93,113.6 23.93,113.58 v1(23.42,113.07)
  BOTTOM w0.112: v1(73.03,19.12) 73.03,18.31 v2(72.9,18.19)
3.3V_TS_EN_R: length 2.7
  BOTTOM w0.112: UZ4.3 73.84,20.64 73.91,20.56 R5764.2 R5765.2
3.3V_WWAN_EN: length 55.7
  IN2 w0.066: v4(10.83,117.03) 11.98,115.88 11.98,110.92 12.04,110.86 12.04,100.29 14.61,97.73 14.61,93.61 15.94,92.28 v4(15.94,88.44)
  IN3 w0.066: v5(28.33,112.8) 28.04,113.1 26.47,113.1 26.07,113.49 26.07,115.46 v6(26.69,116.09) ; v5(15.53,88.1) 15.53,88.16 15.81,88.44 v4(15.94,88.44) ; v4(10.83,117.03) 11.21,116.65 15.95,116.65 16.89,117.59 17.81,117.59 17.88,117.66 20.86,117.66 21.41,117.11 v6(21.41,117.06)
  IN4 w0.066: v6(21.41,117.06) 21.46,117.06 21.7,116.82 22.26,116.82 22.89,117.45 24.8,117.45 25.44,116.81 25.86,116.81 25.87,116.8 25.88,116.8 26.31,116.37 26.42,116.37 v6(26.69,116.09)
  BOTTOM w0.076: UE3.C6 v5(28.33,112.8)
  BOTTOM w0.112: v5(15.53,88.1) 15.61,88.18 D61.2
3V_EN: length 2.9
  TOP w0.254: PR504.2 PR516.1 122.19,118.95 121.28,118.04 PU500.11
3V_VIN: length 0.7
  BOTTOM w0.112: v7(120.52,119.64) v2(121.18,119.64)
  vias: v7(119.89,119.64)
3VALW_PG: length 337.3
  TOP w0.112: PR151.1 28.18,42.83 28.37,43.02 28.37,43.73 28.12,43.98 27.48,43.98 v3(26.97,44.49) ; PR271.2 17.09,43.32 18.03,44.26 18.5,44.26 v3(18.95,44.71) ; v2(83.41,49.32) 82.69,50.04 v7(82.34,50.04)
  TOP w0.254: PU500.3 117.23,118.54 116.9,118.87 116.9,118.99 PR503.1 116.33,119.43 v7(116.33,118.87)
  IN1 w0.066: v7(82.34,50.04) 82.34,52.64 81.66,53.32 81.66,64.58 79.96,66.28 77.75,66.28 76.43,67.6 v7(76.43,67.78) 78.36,69.71 78.36,74.47 79.78,75.9 79.78,81.6 81.01,82.83 81.01,86.03 82.83,87.85 94.06,87.85 95.91,87.24 v10(103.26,87.24)
  IN2 w0.066: v10(103.26,87.24) 103.65,87.24 106.9,90.49 106.9,93.91 106.18,94.62 106.18,96.93 108.12,98.87 111.22,98.87 112.96,100.61 112.96,104.26 115.51,106.81 115.51,118.05 v7(116.33,118.87) ; v7(82.34,50.04) 82.95,49.43 82.95,44.89 84.16,43.67 84.16,38.33 82.87,37.03 82.87,31.15 79.63,27.92 74.46,27.92 74.1,28.28 58.38,28.28 55.82,25.72 51.44,25.72 48.87,23.15 45.95,23.15 45.44,23.66 v4(43.92,23.66) ; v4(19.32,44.71) v3(18.95,44.71) ; v3(26.97,44.49) v4(26.59,44.49)
  IN3 w0.066: v6(27,44.52) v3(26.97,44.49) v4(26.59,44.49) 26.57,44.46 24.23,44.46 22.56,42.79 20.65,42.79 19.32,44.12 v4(19.32,44.71) ; v4(43.92,23.66) v6(43.28,23.66) ; v6(11.66,109.95) 12.47,109.95 14.28,108.14 18.82,108.14 19.54,107.42 20.05,107.42 20.28,107.65 v5(20.92,107.65) ; v7(76.43,67.78) 76.27,67.94 47.69,67.94 42.63,73 21.83,73 v6(21.74,73.1)
  IN4 w0.066: v6(27,44.52) 27,44.67 28.98,46.65 31.8,46.65 32.18,47.03 35.97,47.03 36.68,46.32 41.38,46.32 41.5,46.19 41.5,36.98 43.28,35.2 v6(43.28,23.66) ; v6(11.66,109.95) 11.66,109.62 11.96,109.32 11.96,104.59 12.37,104.17 12.37,95.13 15.93,91.57 15.93,90.92 16.18,90.67 16.18,81.82 21.65,76.36 21.65,73.19 v6(21.74,73.1)
  BOTTOM w0.112: RE121.2 20.02,106.03 20.31,106.33 20.31,106.97 20.92,107.57 20.92,107.65 v5(20.92,107.65)
3VALW_PG_EC: length 6.2
  BOTTOM w0.076: 20.7,107.91 21.46,107.91 21.54,107.99 21.54,108.32 21.24,108.62 21.24,108.92 21.45,109.13 21.67,109.13 22.04,109.5 22.04,109.72 22.21,109.89 22.43,109.89 22.86,110.32 22.86,110.38 22.89,110.4 UE3.K3
  BOTTOM w0.112: 20.7,107.91 20.49,107.7 20.49,107.41 20.02,106.93 20.02,106.69 RE121.1
5VALW_EN: length 3.1
  TOP w0.254: PR510.2 PR517.1 43.95,153.79 PU501.11
5VALW_PG: length 2.7
  TOP w0.112: v2(50.05,153.46) 50,153.4 PR509.1
  TOP w0.254: PR509.1 48.49,153.4 48.37,153.29 PU501.3
5VALW_VIN:
  vias: v7(44.39,151.51) v7(44.89,151.83) v7(44.89,151.26)
5VD_EN: length 3.8
  TOP w0.112: PR515.2 124.27,145.37 v2(124.79,145.89)
  TOP w0.254: PR515.2 PR518.1 122.62,144.98 PU502.11
5VD_PG: length 2.5
  TOP w0.254: PU502.3 117.73,145.48 117.35,145.86 PR514.1
5VD_VIN: length 1
  BOTTOM w0.112: v2(120.32,146.18) 120.32,147.21
  vias: v7(121.08,148.38) v7(121.08,147.79)
+0.6VS:
  vias: v2(86.77,105.11) v7(86.49,105.9) v7(87.28,105.55) v7(87.95,105.07)
+0.6VSP: length 15.1
  IN1 w1.016: 91.14,107.81 95.68,107.81 98.55,110.68 98.55,111.7 101.47,114.62 102.82,114.62
  vias: v2(105.07,117.58) v8(90.14,107.46) v8(90.14,107.15) v8(90.45,107.46) v8(90.47,107.15) v8(105.31,115) v8(105.51,114.7) v8(105.74,115) v8(105.89,114.7)
+1.0V_AMPHYPLL:
  vias: v7(61.77,128.93)
+1.0V_APLL: length 4.6
  TOP w0.254: v7(60.95,125.29) 61.04,125.19 UCPU1.V15
  BOTTOM w0.127: v2(59.51,125.97) 59.31,125.77 L30.2
  BOTTOM w0.381: R121.1 60.91,125.33 v7(60.95,125.29)
  BOTTOM w0.508: R121.1 60.02,125.33 L30.2
+1.0V_APLLEBB: length 11.2
  TOP w0.254: UCPU1.N18 63.71,127.36 v7(63.71,127.3)
  IN4 w0.508: v7(63.71,127.3) 63.71,127.51 63.2,128.02 60.77,128.02 60.2,127.45 55.84,127.45 55.28,128.01
  BOTTOM w0.127: v7(63.71,127.3) 63.4,126.99 v2(63.4,126.86)
  BOTTOM w0.508: v7(63.71,127.3) 63.71,127.55 63.63,127.64 CC38.1
  vias: v1(54.6,128.69) v1(54.75,128.47)
+1.0V_CLK: length 29.2
  TOP w0.254: RC31.2 80.49,138.06 79.96,137.53 v3(79.96,136.53)
  TOP w0.508: RC15.1 v7(60.86,139.66)
  IN2 w0.508: v4(79.6,136.18) 79.71,136.29 79.72,136.29 v3(79.96,136.53) ; v7(60.86,139.66) 60.91,139.71 61.87,139.71 v3(62.61,138.98) 62.61,137.48 v4(62.55,137.42)
  IN3 w0.508: v6(78.97,136.23) 79.55,136.23 v4(79.6,136.18)
  IN4 w0.508: v6(78.97,136.23) 78.74,136.23 76.61,134.11 69.67,134.11 67.39,136.39 66.42,136.39 65.94,135.9 v5(64.11,135.9) 64.06,135.9 63.26,136.7
  BOTTOM w0.508: v5(64.11,135.9) 64.11,134.57 v2(63.7,134.16) 62.76,133.22 RC103.2
  vias: v6(62.84,137.05) v6(63.07,136.84)
+1.0V_DTS: length 3.2
  TOP w0.254: UCPU1.T1 53.3,126.67
  TOP w0.508: 53.3,126.67 53,126.37 v2(52.27,126.37) RC47.2
+1.0V_MPHYAON: length 16.1
  TOP w0.254: UCPU1.K17 63.24,129.56 v3(63.12,129.56) ; v7(53.58,129.37) 53.62,129.32 UCPU1.L1
  IN2 w0.254: v3(63.12,129.56) v4(63.5,129.56)
  IN3 w0.508: v4(63.5,129.56) 63.5,130.29 v5(63.17,130.62) 61.34,130.62 59.75,129.03 57.43,129.03 56.76,128.37 54.93,128.37 53.93,129.37 v7(53.58,129.37)
  BOTTOM w0.127: v2(62.42,131.54) 63.17,130.79 v5(63.17,130.62)
  BOTTOM w0.508: RC125.2 52.92,129.71 53.24,129.71 v7(53.58,129.37)
+1.0V_MPHYGT:
  vias: v2(57.1,127.23) v7(61.77,127.31) v7(62.43,127.31) v7(63.09,127.29)
+1.0V_PRIM_CORE: length 4.5
  TOP w0.254: UCPU1.V20 65.36,125.12 v7(65.68,124.8) 66.01,125.13 UCPU1.V21 66.1,125.19 66.36,124.94 v7(66.36,124.77) ; UCPU1.AF19 65.04,122.18 v7(65.04,122.28) ; UCPU1.AF18 64.06,121.92 v7(64.42,122.28)
  BOTTOM w0.127: 64.38,121.85 62.83,121.85 v9(62.79,121.81)
  vias: v4(55.8,125.35) v4(56.33,124.84) v4(56.82,125.35) v4(56.84,124.84) v4(57.28,125.35) v7(42.82,147.63) v7(42.8,147.07) v7(42.8,146.43) v7(42.8,145.8) v7(43.37,147.77) v7(43.36,147.19)
+1.0V_PRIM_COREP: length 7.2
  TOP w0.254: PR824.2 47.21,141.45 v2(46.55,141.45) 45.02,141.45 43.69,142.79 43.69,145.48
  vias: v7(44.57,145.35) v7(45.13,145.35) v7(45.69,145.35) v7(46.24,145.35) v7(46.99,146.69) v7(46.99,146.12) v7(46.99,145.54)
+1.0V_SRAM: length 2.3
  TOP w0.254: UCPU1.T19 65.03,126.36 v7(65.03,126.45) 65.36,126.13 UCPU1.T20
  BOTTOM w0.127: v2(64.68,126.85) 65.03,126.5 v7(65.03,126.45)
  BOTTOM w0.508: CC44.1 65.05,126.43 v7(65.03,126.45)
  vias: v1(54.17,125.86) v1(54.17,125.54) v8(65.36,121.84) v8(66.01,121.84)
+1.0V_VCCST: length 231.9
  TOP w0.254: UCPU1.K20 UCPU1.K21 66.24,129.39 66.61,129.01 66.61,128.95 v7(66.66,128.9)
  TOP w0.508: RC7.1 87.98,139.98 87.98,139.57 88.01,139.54 v8(88.01,139) ; RC25.1 v8(91.95,138.1)
  IN1 w0.381: v3(64.44,137.61) 65.09,137.61 65.44,137.26 65.75,137.26 66.29,136.72 66.29,136.17 66.99,135.47 66.99,133.99 67.18,133.8 67.18,133.12 68.03,132.27 68.03,131.92 67.55,131.43 67.55,129.82 66.66,128.93 v7(66.66,128.9)
  IN1 w0.508: v8(88.01,139) 91.05,139 v8(91.95,138.1) 92.01,138.04 93.29,138.04 v10(93.9,138.65)
  IN2 w0.508: v4(93.53,138.24) 93.9,138.62 v10(93.9,138.65)
  IN3 w0.508: v5(52.3,138.29) 50.8,139.79 43.24,139.79 42.43,138.97 41.2,138.97 41.19,138.96 36.48,138.96 36.09,139.35 35.05,139.35 33.44,139.35 33.01,138.91 30.2,136.1 30.09,136.1 28.79,134.8 24.6,134.8 23.9,135.5 20.93,135.5 v6(20.83,135.4) ; v6(139.64,147.66) 136.79,147.66 134.75,145.62 134.75,144.85 133.9,143.99 132.23,143.99 131.76,144.46 131.76,147.8 130.94,148.63 127.44,148.63 126.95,148.13 126.95,145.73 126.44,145.22 123.44,145.22 122.66,146.01 118.24,146.01 117.48,146.76 111.77,146.76 107.67,142.66 v6(107.67,139.97) ; v6(94.05,138.24) v4(93.53,138.24)
  IN4 w0.508: 20.73,134.82 20.4,134.49 20.4,133.22 19.53,132.35 19.53,131.31 18.59,130.37 18.59,129.1 18.01,128.51 18.01,126.33 17.51,125.83 ; v5(52.3,138.29) 53.08,138.29 54.75,136.63 56.35,136.63 57.29,137.57 58.65,137.57 58.76,137.47 60.47,137.47 60.57,137.57 63.28,137.57 63.65,137.2 65.38,137.2 ; v6(139.64,147.66) 140.44,147.66 140.74,147.36 140.74,146.44 141.56,145.63 141.56,143.22 142.05,142.73 142.05,140.55 144.72,137.89 144.72,137.83 145.55,137 146.34,137 148.78,134.56 148.78,133.77 149.39,133.16 v1(150.19,133.16) ; v5(89.18,136.56) 92.66,136.56 94.05,137.95 v6(94.05,138.24) 95.77,139.97 v6(107.67,139.97) ; v1(54.76,151.8) 55.24,151.32 55.24,149.81 55.15,149.71 55.15,146.82 56.57,145.4 v1(59.11,145.4)
  BOTTOM w0.127: v5(89.18,136.56) v9(88.1,136.56)
  BOTTOM w0.508: RC95.1 87.07,138.04 86.06,139.05 74.64,139.05 73.32,140.37 52.63,140.37 51.82,139.56 51.82,138.75 ; RC95.1 89.14,136.83 89.18,136.79 v5(89.18,136.56) ; RC95.1 RC94.1 RC93.1 ; v7(64.06,145.18) 64.05,145.16 PC903.1 ; 62.37,145.16 62.56,145.35 PR925.1 PR900.1 PC903.1 ; 62.37,145.16 61.88,144.67 60.36,144.67 59.97,145.07 PR901.1 PR934.1 v1(59.11,145.4) ; 62.37,145.16 PC903.1 ; CC35.1 66.61,129.43 66.61,128.95 v7(66.66,128.9)
  vias: v1(18.77,120.61) v1(19.08,120.51) v3(64.47,137.99) v4(65.14,137.86) v5(51.51,138.29) v6(20.45,135.42) v6(65.57,137.44) v6(65.84,137.61)
+1.0V_VCCST_R: length 1.9
  BOTTOM w0.112: v2(48.96,136.54) 49.84,135.65 UZ3.6
+1.0V_VCCSTG: length 73.6
  TOP w0.254: CC4.1 66.78,136.87 66.78,135.87 66.74,135.83 UCPU1.A22 ; RC18.1 v8(86.11,139.94)
  TOP w0.508: v8(67.01,139.77) R26.2 CZ1.1 CC4.1 ; v9(99.35,139.56) 96.77,139.56 96.39,139.19 v8(96.39,138.95)
  IN1 w0.508: v8(67.01,139.77) 66.42,139.77 65.15,141.04 65.15,142.05 64.77,142.43 64.77,148.15 66.01,149.39 73.79,149.39 74.8,150.41 81.15,150.41 82.22,149.34 90.27,149.34 91.92,147.69 91.92,141.37 92.63,140.65 94.69,140.65 v8(96.39,138.95) 95.81,138.37 95.17,138.37 93.92,139.61 87.66,139.61 v8(87,138.95) 87,139.82 86.87,139.94 v8(86.11,139.94) v8(85.09,139.94)
+1.0V_VCCSTG_R: length 17.4
  TOP w0.127: v2(63.91,140.06) 63.91,139.28 64.09,139.1 v8(64.3,139.1)
  TOP w0.254: UCPU1.G20 64.51,130.44 64.51,130 64.72,129.79 65.02,129.79 65.03,129.8 65.13,129.8 v8(65.38,130.05)
  TOP w0.508: v8(64.3,139.1) 64.97,139.77 RC1.1
  IN1 w0.254: v8(65.38,130.05) 65.46,129.97 66.42,129.97 67.05,130.61 67.05,132.59 66.67,132.97 66.67,133.67 66.55,133.8 66.55,135.32 65.79,136.08 65.38,136.08 65.14,136.32 64.02,137.44 64.02,138.82 v8(64.3,139.1)
+1.0V_VCCSTG_R26: length 1.5
  TOP w0.508: R26.1 65.03,138.88 v7(64.71,138.56)
  vias: v2(64.77,137.34)
+1.0VA: length 82.7
  TOP w0.254: v7(65.38,118.83) 65.38,118.83 65.36,118.86 UCPU1.AK20 ; UCPU1.AB17 63.72,123.83 v7(63.72,123.94) 64.06,124.27 UCPU1.Y18 ; UCPU1.P18 64.38,127.19 v7(64.38,127.29) ; UCPU1.AB20 65.36,123.64 v7(65.07,123.94) 64.71,123.58 UCPU1.AB19
  TOP w0.508: v7(126.36,147.39) 126.36,148.46 126.94,149.04 140.34,149.04 142.37,147 142.37,144.91 144.97,142.31 144.97,140.02 147.96,137.03 147.96,134.05 152.15,129.86 158.12,129.86 159.13,128.84 v7(159.13,127.31)
  GND1 w0.381: v12(50.34,126.25) 50.34,126.86 50.65,127.17 50.67,127.17 v4(50.77,127.27)
  IN3 w0.508: v4(50.77,127.27) 54.46,127.27 54.53,127.35 54.53,127.37 54.86,127.7 57.22,127.7 57.91,127.01 59.12,127.01 59.62,127.52 59.95,127.52 60.52,128.08 63.88,128.08 64.38,127.58 64.38,127.48 ; 64.38,127.48 v7(64.38,127.29) ; 64.38,127.48 64.98,128.08 67.18,128.08 67.56,127.7 67.56,122.16 66.93,121.53 66.51,121.53 65.12,120.14 65.12,119.09 v7(65.38,118.83)
  BOTTOM w0.508: v7(159.13,127.31) 158.8,126.98 RC130.1
  vias: v1(58.29,123.79) v1(59.31,123.42) v4(57.28,137.61) v4(57.66,138.24) v4(57.78,137.61) v4(58.04,137.99) v4(58.29,137.61) v4(58.55,137.99) v4(58.8,137.61) v5(57.4,136.69) v5(57.47,137.03) v5(57.78,137.03) v5(57.78,136.72) v5(58.1,137.03) v5(58.1,136.72) v5(58.42,136.72) v7(125.73,147.39) v7(125.73,146.75) v7(125.73,146.12) v7(126.36,146.75) v7(126.36,146.12) v9(59.39,136.46)
+1.0VA_XDP: length 15
  IN4 w0.508: v5(149.4,117.92) 150.8,119.32 150.8,120.31 150.42,120.69 150.42,121.49 151.51,122.58 151.51,129.43 152.98,130.9 v1(153.21,130.9)
+1.0VA_XDP1: length 1.1
  IN2 w0.254: v4(56.13,139.51) 56.39,139.26 v3(56.39,138.95)
  IN3 w0.254: v4(56.13,139.51) 55.88,139.51 v5(55.75,139.64)
+1.0VAP: length 6.3
  BOTTOM w0.508: PC708.1 131.76,143.89 v2(132.11,143.55) 133.05,142.61 133.05,141.99 PR704.1 PC707.1
  vias: v7(129.81,145.65) v7(130.49,145.79) v7(131.06,147.64) v7(131.06,147.06) v7(131.06,146.37) v7(131.06,145.79)
+1.0VS_VCCIO: length 238.2
  IN1 w0.508: v7(116.59,142.31) 115.44,142.31 115.06,141.92 114.68,141.92 112.52,139.77 112.52,133.16
  IN3 w0.508: v6(144.01,137.36) 142.51,138.86 131.98,138.86 129.62,141.23 124.52,141.23 120.44,145.31 v6(120.24,145.31) ; v6(25.22,143.65) 25.53,143.96 27.84,143.96 28.54,144.66 37.5,144.66 37.62,144.54 38,144.54 38.16,144.38 38.45,144.38 38.56,144.49 38.6,144.49 39.25,145.14 39.25,151.53 34.91,155.87 33.73,155.87 29.76,159.84 29.76,160.33 32.44,163.01 39.4,163.01 42.06,165.67 109.22,165.67 111.38,167.83 114.94,167.83 118.49,164.28 118.49,157.67 119.89,156.28 119.89,153.68 v6(119.48,153.28)
  IN4 w0.508: v1(82.88,131.64) 82.42,131.64 81.94,131.15 81.94,128.87 80.16,127.09 80.16,121.76 79.32,120.92 78.87,120.92 78.03,120.08 v7(77.5,120.08) ; v6(144.01,137.36) 144.01,136.66 146.52,134.15 147.23,134.15 149.28,132.11 v1(149.28,131.38) ; v7(116.59,142.31) 115.95,142.31 115.82,142.43 115.82,143.45 116.71,144.34 117.09,144.34 118.07,145.31 v6(120.24,145.31) 120.24,149.39 121.34,150.48 121.34,151.4 120.83,151.91 120.27,151.91 119.48,152.69 v6(119.48,153.28) ; 21.49,123.18 21.42,123.25 21.42,124.48 21.45,124.51 21.45,124.52 21.5,124.57 21.5,124.97 23.6,127.07 23.6,127.96 24,128.36 24,130.66 23.69,130.98 23.69,133.09 23.86,133.27 23.86,138.22 24.84,139.19 24.84,139.83
  BOTTOM w0.127: v9(67.58,120.33) 67.58,120.05 68.4,119.23 RC147.1
  vias: v1(21.59,122.74) v1(21.62,122.47) v3(70.33,119.94) v3(70.61,119.94) v3(70.64,118.29) v3(70.9,119.94) v3(70.97,118.29) v3(71.55,118.31) v4(70.42,120.27) v4(70.85,120.27) v5(70,119.15) v5(70.32,119.15) v5(70.9,119.22) v5(71.16,119.22) v7(76.91,120.09) v8(116.08,131.76) v8(116.08,131.38) v8(116.08,131) v8(116.46,132.15) v8(116.46,131.76) v8(116.46,131.38) v8(116.46,131)
+1.0VS_VCCIO_PG: length 4.6
  TOP w0.254: PR734.1 119.55,125.15 121.07,125.15 121.65,125.73 121.65,126.58 121.84,126.77 PU800.4
+1.0VS_VCCIOP: length 10.4
  TOP w0.254: v7(119.65,123.83) 119.79,123.69 PR807.1
  IN3 w0.254: v7(119.65,123.83) 116.9,126.57 116.9,127.83 118.36,129.29 v7(120.14,129.29)
  BOTTOM w0.112: v7(120.14,129.29) 120.71,129.29 v9(120.87,129.44)
+1.2V_DDR: length 152.6
  TOP w0.254: UCPU1.AU35 73.6,115.73 v7(73.53,115.73) ; UCPU1.AU28 70.05,115 v7(69.88,115) ; v7(77.22,115) 77.53,115.31 UCPU1.AU42 ; v7(67.16,114.99) 67.3,114.99 UCPU1.AU23
  TOP w0.381: UC1.5 100.6,119.21 100.87,119.48 100.87,119.94 CC15.1
  TOP w0.508: v7(100.47,120.98) CC15.1
  IN1 w0.508: v7(77.17,31.25) 77.17,31.29 75.64,32.82 75.64,40.12 77.34,41.82 77.34,47.54 81.18,51.37 81.18,64.43 79.81,65.8 76.76,65.8 75.67,66.89 75.67,69.92 77.9,72.15 77.9,77.29 76.82,78.37 72.01,78.37 71.26,79.12 71.26,79.57
  IN3 w0.508: v7(77.17,31.25) 75.69,29.78 75.01,29.78 74.3,29.07 73.13,29.07 71.36,30.84 69.62,30.84 68.63,29.85 62.06,29.85 60.07,31.84 51.97,31.84 48.71,28.58 37.38,28.58 35.07,30.89 28.36,30.89 27.3,31.95 23.68,31.95 22.86,31.13 21.97,31.13 20.8,32.3 19.63,32.3 18.72,33.21 18.72,33.67 18.14,34.25
  IN4 w0.508: 68.52,80.58 67.23,81.87 66.86,81.87 66.65,82.08 66.65,86.02 66.97,86.34 74.16,86.34 v1(77.83,90.01)
  vias: v4(69.38,80.72) v5(17.73,34.76) v5(18.06,34.76) v6(68.52,80.34) v6(68.86,80.38) v7(66.8,111.57) v7(71.88,111.76) v7(71.88,111.19) v7(73.4,101.97) v7(73.54,100.84) v7(74.01,109.56) v7(76.78,112.09) v7(77.09,109.54) v7(77.2,104.43) v7(78.63,103.1) v7(78.64,100.5) v7(79.57,95.32) v7(80.35,111.66) v7(80.39,109.67) v7(81.05,94.01) v7(81.84,101.14) v7(81.85,94.01) v7(82.68,111.63) v7(83.44,99.2) v7(84.31,95.98) v7(91.21,95.8) v7(92.86,105.03) v7(92.86,104.4) v7(92.86,93.94) v7(94.45,97.84) v7(94.45,97.19) v7(94.45,96.55) v7(94.46,93.96) v7(95.41,93.59) v7(96.86,101.1) v7(96.86,99.78) v7(96.86,95.25) v7(96.86,92.64) v7(100.14,104.14) v7(101.02,92.45) v7(101.36,94.81) v7(101.98,95.32) v7(102.11,104.33) v7(102.11,103.57) v7(108.84,102.24) v7(109.16,102.74) v7(109.41,102.24) v7(109.73,102.74) v9(71.95,107.25) v10(69.94,80.72) v10(70.26,80.74) v12(82.88,112.52)
+1.2V_DDRP: length 31.5
  TOP w0.254: PC602.1 v12(111.84,119.19)
  GND1 w0.254: v12(111.84,119.19) v4(111.51,119.19) ; v4(106.55,119.2) v12(106.13,119.2)
  IN3 w0.254: v4(111.51,119.19) 112.9,117.79 112.9,107.06 v7(110.74,104.9) ; v7(108.71,108.4) 108.58,108.4 107.44,109.54 107.44,113.86 105.79,115.51 105.79,118.68 106.31,119.2 v4(106.55,119.2)
  BOTTOM w0.127: v2(107.47,109.08) 108.03,109.08 v7(108.71,108.4)
+1.2V_MEM_CPUCLK: length 3.4
  TOP w0.254: v7(77.18,118.25) 76.87,118.56 UCPU1.AM40
  BOTTOM w0.381: CC83.1 78.03,118.15 CC76.1 77.19,118.24 v7(77.18,118.25)
  BOTTOM w0.508: CC83.1 78.03,116.22 RC156.2
+1.2V_MUX: length 69
  IN2 w0.508: v4(18.29,47.18) 20.62,44.85 20.62,36.31 18.62,34.3 16.64,34.3 15.62,33.29 15.62,32.56 v4(15.86,32.32) 18.73,32.32 19.3,31.75 19.3,28.41 19.89,27.83 19.89,23.13 v4(20.24,22.77)
  IN3 w0.508: v5(19.01,21.4) 19.01,21.54 v4(20.24,22.77) 20.32,22.85 24.08,22.85 v5(24.13,22.8) ; v5(15.86,31.82) v4(15.86,32.32) 16.61,33.07 16.61,35.19 v5(16.89,35.47) 19.84,35.47 19.92,35.55 19.92,35.55 21,36.63 24.13,36.63 v5(24.41,36.91) ; v5(17.78,47.18) v4(18.29,47.18)
  BOTTOM w0.127: v2(25.39,36.81) 25.29,36.91 v5(24.41,36.91)
  BOTTOM w0.203: v5(24.13,22.8) 24.28,22.94 UV2.20 ; UV1.28 20.7,36.84 20.49,36.64 19.68,36.64 19.47,36.43 CV39.1 ; v5(19.01,21.4) 19.01,21.7 19.22,21.9 20.33,21.9 20.82,22.4 UV2.28 ; v5(24.41,36.91) 24.89,37.39 24.89,37.78 24.68,38 UV1.20
  BOTTOM w0.356: RV42.1 18.29,20.39 18.8,20.89 18.8,21.19 v5(19.01,21.4) ; CV39.1 18.69,36.32 RV26.2
  BOTTOM w0.508: RV26.2 17.36,36.32 16.89,35.86 v5(16.89,35.47) ; RV61.1 16,46.38 16.8,47.18 v5(17.78,47.18) ; v5(15.86,31.82) 15.86,31.35 16.13,31.08 17.6,31.08 RV62.1
+1.2V_UF_DVDD: length 51.9
  TOP w0.203: JUFC1.1 121.72,167.59 121.92,167.39 121.92,167.07
  TOP w0.508: 121.92,167.07 121.92,166.37 122.81,165.48 124.76,165.48 125.02,165.74 C5.1 125.73,165.74 126.07,165.39 C6.1 126.3,165.03 v7(126.82,165.03)
  IN2 w0.508: v4(143.03,143) 143.03,147.55 141.72,148.86 126.79,148.86 122.78,152.86 122.78,158.48 125.11,160.81 125.95,160.81 126.82,161.69 v7(126.82,165.03)
  IN3 w0.508: v5(145.45,143) v4(143.03,143)
  BOTTOM w0.127: v7(126.82,165.03) v2(126.82,165.99)
+1.2V_WF_DVDD: length 43.1
  TOP w0.203: v3(124.11,158.14) 124.47,158.14 124.47,158.14 125.2,158.14 125.29,158.05 C7.1
  TOP w0.356: C10.1 125.69,158.78 C7.1
  IN2 w0.508: v3(124.11,158.14) 123.9,158.14 123.39,157.63 123.39,153.11 127.04,149.47 142.03,149.47 144.2,147.3 144.2,143.12 143.43,142.36 143.43,139.4 145.24,137.59 v7(145.79,137.59)
  BOTTOM w0.508: R116.2 145.9,137.48 v7(145.79,137.59)
+1.5VS_AUDIO: length 79.1
  IN3 w0.508: v5(17.28,142.43) 18.03,142.43 18.73,141.73 25.83,141.73 26.57,141 30.77,141 32.35,142.58 37.25,142.58 37.41,142.42 v6(40.98,142.42)
  IN4 w0.508: v6(40.98,142.42) 40.02,141.45 40.02,139.56 39.89,139.4 39.5,139.01 39.5,136.1 39.89,135.71 39.89,134.99 39.74,134.84 39.74,132.14 39.73,132.14 39.73,131.24 39.71,131.21 39.71,129.13 40.81,128.02 40.81,126.77 v1(42.17,125.41) ; v1(17.67,132.7) 17.88,132.48 17.88,129.78 v1(16.51,128.41)
  BOTTOM w0.508: v5(17.28,142.43) RA18.1 18.34,141.04 16.51,139.21 16.51,133.85 v1(17.67,132.7) ; RC185.1 47.88,121.48 47.24,120.84 v9(47.24,117.16) 46.61,116.52 43.18,116.52 42.67,117.03 42.67,124.91 v1(42.17,125.41)
+1.8V_IO_OUT: length 7
  IN4 w0.508: v1(144.87,141.04) 147.38,141.04 v1(148.34,141.99)
  BOTTOM w0.254: v1(148.34,141.99) 148.71,142.36 U12.E7
  BOTTOM w0.381: v1(144.87,141.04) C78.1 RH24.2 RH27.2
+1.8V_PGPP: length 166.7
  TOP w0.254: UCPU1.AF16 62.76,121.75 62.42,121.42 v7(62.39,121.42) ; v7(61.61,119.84) 62.11,119.34 UCPU1.AK15
  TOP w0.381: v8(59.31,107) 58.47,107 57.91,107.56 RC192.2
  IN1 w0.381: v8(60.71,107.94) 59.77,107 v8(59.31,107)
  IN1 w0.508: v8(61.85,107.94) v8(60.71,107.94)
  IN3 w0.254: v5(7.18,137.01) 11.5,137.01 12.27,136.25 12.8,136.25 13.23,136.68 13.23,137.63 v5(12.97,137.9)
  IN3 w0.508: v5(69.91,85.69) 68.17,85.69 67.04,86.82 v6(62.33,86.82) ; 60.3,107.1 58.08,109.31 ; v6(50.5,133.8) 50.57,133.87 50.57,136.53 49.26,137.84 43.95,137.84 39.65,133.54 38.33,133.54 v5(38.15,133.36) ; 38.2,145.28 28.24,145.28 27.56,144.6 19.61,144.6 19.44,144.77 15.2,144.77 15.03,144.6 ; v7(62.39,121.42) 62.4,121.43 62.4,121.61 61.96,122.05 60.96,122.05 60.15,121.24 60.15,121.24 59.73,120.82 58.57,120.82 57.76,121.63 56.31,121.63 55.59,122.35 50.75,122.35 v5(50.54,122.56)
  IN4 w0.381: v7(62.39,121.42) 62.32,121.34 62.32,120.65 61.61,119.94 v7(61.61,119.84)
  IN4 w0.508: 51.02,134.15 53.02,134.15 53.75,133.42 53.75,132.61 51.89,130.74 51.89,130.33 ; 60.31,105.91 60.31,105.29 61.09,104.51 61.67,104.51 62.01,104.17 62.01,100.76 61.56,100.31 60.99,100.31 60.65,99.97 60.65,93.95 61.52,93.08 61.52,91.35 61.39,91.22 61.39,89.94 61.77,89.56 61.77,89.12 62.33,88.57 v6(62.33,86.82) ; 55.39,121.25 56.62,121.25 57.11,120.75 61.23,120.75 61.61,120.37 61.61,119.94 ; 55.39,121.25 54.94,121.71 53.3,121.71 52.38,122.62 52.35,122.62 52,122.97 52,125.01 52.76,125.76 52.76,125.78 53.36,126.39 ; 55.39,121.25 55.52,121.12 55.52,119.16 55.05,118.69 55.05,116.46 54.87,116.28 54.87,113.78 56.5,112.14 v1(56.77,112.14) 57.07,111.84 57.07,110.25 ; v5(12.97,137.9) 13.37,137.9 13.82,138.34 13.82,144.45 v6(13.95,144.59)
  BOTTOM w0.102: v5(12.97,137.9) v2(12.97,139.13)
  BOTTOM w0.381: v1(56.77,112.14) 56.77,112.51 56.97,112.71 58.5,112.71 58.85,112.36 58.85,111.29 59.26,110.89 59.92,110.89 60.52,111.48 RC392.2
  BOTTOM w0.508: v5(38.15,133.36) 38.05,133.47 38.05,137.3 38.15,137.4 38.15,144.96
  vias: v3(57.9,109.32) v4(57.25,109.31) v5(38.07,145.04) v5(38.29,145.28) v6(13.97,144.96) v6(50.37,134.18) v6(51.83,129.4) v6(51.83,129.09) v6(54.09,127.83) v6(54.33,127.99) v6(56.85,109.44) v6(56.84,109.16) v6(60.3,106.82) v6(60.31,106.53)
+1.8V_UF_VDD: length 44.7
  TOP w0.203: JUFC1.5 121.99,168.39 122.63,168.39 123.32,167.71 v3(123.32,167.32)
  IN2 w0.508: v4(149.39,148.78) 148.08,148.78 144.64,152.22 129.04,152.22 127.5,153.76 127.5,161.15 127.43,161.22 127.43,166.35 v3(125.44,168.34) 124.97,168.34 123.95,167.32 v3(123.32,167.32)
  IN3 w0.508: v5(149.39,148.4) v4(149.39,148.78)
+1.8V_WF_DOVDD: length 35.7
  TOP w0.203: C16.1 125.16,157.7 124.86,157.7 v3(124.85,157.69) 124.8,157.74 124.47,157.74 124.47,157.74 JWFC1.20
  IN2 w0.508: v3(124.85,157.69) 124,156.84 124,153.37 127.29,150.08 142.28,150.08 144.81,147.55 144.81,142.74 v4(144.44,142.37)
  IN3 w0.508: v5(145.45,142.37) v4(144.44,142.37)
+1.8VA: length 280.4
  IN1 w0.508: v8(136.49,138.71) 136.5,138.7 143.27,138.7 v14(143.64,139.07)
  IN1 w1.016: 19.68,134.54 22,136.86 24.23,136.86 26.19,138.82 29.55,138.82 34.73,144 34.73,148.72 38.99,152.97 38.99,154.24 40.86,156.11 40.86,163.1 41.94,164.17 49.5,164.17 49.78,163.9 54.46,163.9 54.91,164.35 65.93,164.35 66.04,164.24 71.07,164.24 71.18,164.35 100,164.35 101.37,162.98 101.37,161.33 101.93,160.77 101.93,158.09 102.82,157.2 102.82,155.18 103.5,154.5 108.97,154.5
  GND1 w0.508: v14(143.64,139.07) 143.64,139.07 v4(144.12,139.55)
  IN2 w0.254: v3(117.69,173.1) v4(117.28,173.1) ; v3(117.69,173.74) v4(117.28,173.74)
  IN3 w0.508: v6(12.94,104.75) 12.99,104.75 15.83,101.91 v5(16.29,101.91) ; v7(10.31,133.67) 10.36,133.62 19.43,133.62
  IN3 w1.016: 134.86,149.49 134.05,148.68 ; 134.05,148.68 134.05,147.7 ; 134.05,148.68 133.23,149.49 126.51,149.49 126.5,149.5 126.49,149.5 125.2,150.79 125.2,152.26 ; 20.38,132.72 21.08,132.02 28.96,132.02 29.27,132.33 39.9,132.33 44.37,136.8 47.21,136.8 49.22,134.79 49.22,131.95 47.57,130.3 47.57,128.28 47.93,127.93 47.93,125.59 ; 125.2,152.26 111.65,152.26 110.87,153.04 ; 125.2,152.26 125.2,156.51 123,158.71 ; 149.01,138.13 146.8,138.13 146.42,138.51 145.16,138.51 v4(144.12,139.55) 142.16,141.5 142.16,144.13 142.62,144.59 142.62,147.89 141.02,149.49 137.1,149.49 ; 123,161.45 123,166.63 117.35,172.28
  IN4 w0.508: v7(10.31,133.67) 10.31,127.09 10.6,126.8 10.6,115.5 11.2,114.9 11.2,114.15 ; v6(12.57,113.22) 12.57,111.99 12.9,111.65 12.9,105.28
  BOTTOM w0.254: C501.1 v5(123.55,159.39) ; C500.1 v5(123.55,160.34)
  vias: v3(45.47,122.09) v4(48.35,124.83) v4(48.35,124.32) v5(16.61,101.92) v5(16.74,111.01) v5(16.99,111.01) v5(136,149.44) v5(149.92,138.14) v5(150.56,138.14) v6(11.21,113.77) v6(11.2,113.45) v6(12.56,113.76) v6(12.93,105.06) v7(19.11,133.54) v7(19.81,133.54) v7(53.3,123.84) v7(53.8,124.1) v7(109.98,153.48) v7(110.46,153.96) v7(134.11,147.07) v7(134.11,146.43) v9(52.96,123.38)
+1.8VA_EC: length 34.4
  IN2 w0.381: v4(17.01,110.05) 17.01,109.89 17,109.89 17,107.33 v4(19.77,104.56)
  IN3 w0.381: v5(34.18,101.96) 34.18,101.85 33.46,101.13 29.39,101.13 26.95,103.56 24.96,103.56 23.93,104.59 22.49,104.59 22.25,104.83 20.04,104.83 v4(19.77,104.56)
  GND3 w0.381: v4(17.01,110.05) v13(17.73,110.05) ; v15(19.69,104.23) 19.69,104.48 v4(19.77,104.56)
  IN4 w0.381: v1(19.8,101.11) 19.65,101.26 19.65,104.19 v15(19.69,104.23)
  BOTTOM w0.254: CE55.1 19.43,110.94 20.5,112 UE3.N5
  BOTTOM w0.381: RE259.2 33.76,104.08 v2(34.14,103.7) 34.29,103.54 34.29,102.07 v5(34.18,101.96) ; CE55.1 18.67,110.67 18.41,110.42 RE195.2 v13(17.73,110.05)
+1.8VA_LDO_PD1: length 2.2
  BOTTOM w0.254: CT10.1 31.62,67.57 32.35,66.84 UT1.K1
+1.8VA_LDO_PD2: length 2.4
  BOTTOM w0.254: CT32.1 54.13,15.41 UT2.K1
+1.8VAP: length 12.1
  TOP w0.254: PC722.1 135.05,144.07 PC721.1 PR722.1 135.06,142.42 v8(135.06,141.56)
  IN1 w0.254: v8(135.06,141.56) 135.06,140.98 136.46,139.59 140.26,139.59 140.52,139.84 v8(140.52,141.48)
+1.8VD_LDO_PD1: length 15.6
  IN3 w0.508: v5(33.6,61.9) 33.87,61.63 34.72,61.63 36.14,63.06 36.14,64.81 37.9,66.57 37.9,66.61 39.45,68.16 40.34,68.16 41.88,66.61 43.07,66.61 v5(43.24,66.79)
  BOTTOM w0.254: v5(33.6,61.9) 33.69,62 UT1.A2
  BOTTOM w0.508: RT19.2 43.26,66.78 v5(43.24,66.79)
+1.8VD_LDO_PD2: length 24.3
  IN3 w0.508: v5(60.13,16.1) 60.74,16.7 61.85,16.7 62.29,17.15 64.2,17.15 64.98,17.93 64.98,20.87 64.22,21.63 59.49,21.63 58.69,22.43 58.69,23.77 57.6,24.86 55.8,24.86 v5(55.37,25.29)
  BOTTOM w0.127: v2(54.18,26.24) 54.43,25.99 CT20.1
  BOTTOM w0.254: UT2.A2 v5(60.13,16.1)
  BOTTOM w0.508: CT20.1 55.36,25.27 v5(55.37,25.29)
+1.8VS: length 46.7
  IN1 w0.508: v10(34.32,116.49) 34.46,116.35 34.46,112.58 v8(34.29,112.41) ; v8(27.52,112.33) 28.19,113 28.19,115.95 33.21,120.97 v10(34.75,120.97)
  IN2 w0.508: v10(34.32,116.49) 34.32,118.96 34.77,119.41 34.77,120.95 v10(34.75,120.97) 34.75,121.05 34.79,121.09 34.79,121.46 35.88,122.54 35.88,123.7 v4(36.42,124.25)
  IN3 w0.508: 31.34,125.67 31.55,125.46 31.57,125.46 31.67,125.36 v6(33.25,125.36) 35.51,125.36 36.42,124.45 v4(36.42,124.25)
  IN4 w0.508: v1(31.94,122.61) 33.17,123.84 33.17,125.29 v6(33.25,125.36) ; v1(29.18,137.42) 29.34,137.27 29.34,130.68 29.01,130.35 29.01,129.17 29.37,128.81 29.37,126.93 29.84,126.46
  BOTTOM w0.127: v1(28.93,137.78) 28.71,137.57 28.71,137.24 v2(28.78,137.17)
  vias: v6(30.23,126.18) v6(30.4,125.87)
+1.8VS_AUDIO: length 18
  IN3 w0.508: v5(26.86,138.37) 26.2,138.37 25.64,138.93 19.32,138.93 v5(18.78,139.46)
  IN4 w0.508: v5(18.78,139.46) 18.78,143.74 18.97,143.93 v1(18.97,144.85)
  BOTTOM w0.127: v9(27.22,137.4) 26.86,137.76 v5(26.86,138.37)
  BOTTOM w0.508: RA36.1 26.86,139.24 v5(26.86,138.37) 27.73,138.37 R455.1 ; v5(18.78,139.46) 18.54,139.22 R112.2
+1.8VS_CR: length 73.9
  IN4 w0.508: v1(72.14,19.17) 73.1,20.13 73.28,20.13 74.02,20.87 74.02,22.01 74.78,22.77 74.78,28.03 74.42,28.39 74.42,29.3 74.78,29.66 74.78,30.81 73.23,32.35 73.23,35.08 72.99,35.32 72.99,38.45 72.34,39.1 72.34,44.41 66.78,49.98 66.78,67.1 63.65,70.22 63.65,74.36 62.3,75.72 62.3,84.84 v1(62.64,85.18)
  BOTTOM w0.508: v1(62.64,85.18) 62.66,85.16 R5781.2
+1.8VU: length 169.1
  IN1 w0.508: v7(81.85,103.19) 85.48,103.19 86.16,103.86 89.13,103.86 89.34,104.08 91.91,104.08 v7(92.86,103.13) 98.02,103.13 v7(98.15,103.25)
  IN1 w0.762: 79.02,103.75 79.58,103.19 v7(81.85,103.19) ; v7(81.84,92.72) 80.75,91.63 73.77,91.63 72.72,92.69 72.72,98.92 74.37,100.57 74.37,101.56 76.03,103.23 77.11,103.23 ; v7(137.35,124.46) 137.35,130.31 134.07,133.59 134.07,133.64 134.05,133.67 134.05,134.18 133.56,134.66 130.26,134.66 130.14,134.79 127,134.79 125.76,136.03 125.76,137.69 127.14,139.08 127.14,141.53 125.79,142.88 125.79,144.34 123.33,146.8 120.64,146.8 120.37,147.07 120.37,150.97 117.97,153.37 v7(117.97,154.83)
  IN2 w0.762: v4(107.51,93.91) v3(107.51,88.51)
  IN3 w0.762: v7(117.97,154.83) v5(117.97,156.07) ; v4(107.51,93.91) 107.52,93.92 108.2,93.92 v6(108.9,94.62)
  IN4 w0.762: v6(108.9,94.62) 110.03,95.75 110.03,98.16 111.76,99.89 113.87,99.89 115.89,97.87 129.49,97.87 130.94,99.32 142.11,99.32 143.83,101.03 143.83,110.2 141.83,112.2 141.83,114.14 137.35,118.62 v7(137.35,124.46)
  BOTTOM w0.127: CD48.1 80.52,107.23 v9(81.04,107.75)
  BOTTOM w0.305: UD1.U10 77.83,103.17 v7(77.83,103.19) ; UD2.A10 98.15,102.81 v7(98.15,103.25)
  BOTTOM w0.508: 80.77,103.32 80.77,104.12 80.52,104.38 CD49.1 CD48.1
  vias: v7(93.6,91.91) v8(77.81,103.93)
+1.8VUP: length 18.1
  TOP w0.254: v3(112.2,95.45) 112.2,96.32 PR729.1 PR733.2
  IN2 w0.254: v3(108.32,89.74) 108.12,89.94 108.12,91.87 108.93,92.69 110.67,92.69 111.26,93.28 111.26,94.51 v3(112.2,95.45) 112.2,97.09 111.51,97.79 107.91,97.79 v3(106.76,96.64)
+2.8V_UF_AVDD: length 57.7
  TOP w0.203: 122.3,167.83 122.14,167.99 JUFC1.3
  TOP w0.508: 122.3,167.83 122.68,167.45 122.68,166.94 123.23,166.4 C3.1 126.07,166.4 v3(126.11,166.36) 126.76,166.36 C208.1 C209.1
  IN2 w0.508: v3(126.11,166.36) 126.11,161.84 125.7,161.42 124.86,161.42 122.17,158.74 122.17,152.61 126.53,148.25 141.44,148.25 142.42,147.27 142.42,138.74 142.75,138.41 v4(142.75,137.76)
  IN3 w0.508: v5(142.75,136.51) v4(142.75,137.76)
  BOTTOM w0.127: C44.1 145.06,134.94 v9(145.1,134.98)
+2.8V_VCM_OUT: length 57.5
  TOP w0.203: JWFC1.18 124.37,156.94 125.16,156.15 C1.1
  TOP w0.356: v3(128.11,154.12) 125.94,154.12 125.44,154.62 R15.1 C14.1 C1.1
  IN2 w0.508: v7(156.72,140.91) 156.72,141.16 156.36,141.52 154.91,141.52 154.55,141.88 154.55,144.98 150.14,149.39 148.34,149.39 144.9,152.83 129.4,152.83 v3(128.11,154.12) 128.11,161.4 128.04,161.48 128.04,166.6 127,167.64 v3(127,169.06)
  vias: v2(156.64,140.01)
+2.8V_WF_AVDD: length 46.1
  TOP w0.203: JWFC1.19 124.68,157.34 v3(125.03,156.99) 125.23,156.78 C15.1
  IN2 w0.508: v3(125.03,156.99) 124.61,156.57 124.61,153.62 v4(127.15,151.09)
  IN3 w0.508: v5(124.59,162.07) 124.59,159.36 126.79,157.16 126.79,151.45 v4(127.15,151.09) 127.15,151.08 141.96,151.08 145.63,147.42 145.63,145.08 v5(145.45,144.91)
  BOTTOM w0.127: C212.1 v2(127.38,162.07)
  BOTTOM w0.508: v5(124.59,162.07) C210.1 C212.1
+3.3V_ALW_DSW: length 37.9
  TOP w0.254: UCPU1.AJ17 63.41,120.12 63.23,119.94 63.23,119.91 v7(63.09,119.78) ; v7(63.11,122.29) 63.41,122.59 UCPU1.AD17 63.47,122.75 63.99,122.75 UCPU1.AD18
  TOP w0.508: RC91.2 RC90.1 RC127.1 57.94,100.32 55.99,102.26 55.99,105.93 v12(56.41,106.35)
  GND1 w0.381: v12(56.41,106.35) 56.41,106.48 56.74,106.81 v4(56.74,107.09) v12(57.23,107.09)
  GND3 w0.381: v4(56.74,107.09) 56.21,107.09 v13(56.01,106.88)
  IN4 w0.508: v13(56.01,106.88) 55.63,107.27 55.63,110.53 55.45,110.71 55.45,112.33 54.15,113.63 54.15,115.99 54.25,116.09 54.25,119.22 v1(54.79,119.75) ; v1(57.63,119.29) 60.5,119.29 60.51,119.31 61,119.31 61.01,119.29 61.37,119.29 v1(61.42,119.24)
  BOTTOM w0.508: RC394.1 v13(56.01,106.88) ; v7(63.09,119.78) 63.09,119.45 62.84,119.19 61.47,119.19 v1(61.42,119.24)
  vias: v9(53.56,120.91)
+3.3V_ALW_DSW_Q352: length 2.5
  BOTTOM w0.508: RC395.2 56.01,103.66 Q352.1
+3.3V_EC_PLL: length 2.1
  IN4 w0.305: v1(26.42,106.75) 26.33,106.83 v1(26.33,108.8)
+3.3V_LDO_PD1: length 98.2
  TOP w0.508: v7(36.02,41.52) 36.31,41.23 PR185.1 PC151.1 35.45,41.06 34.66,41.85 PU104.5
  IN3 w0.508: v7(36.02,41.52) 36.02,40.76 36.63,40.15 37.24,40.15 37.97,40.88 40.21,40.88 41.07,40.02 v6(48.79,40.02) ; v5(28.24,64.63) 29.08,65.47 v5(31.19,65.47) ; v6(40.87,61.13) 40.84,61.15 39.63,61.15 38.15,59.68 v5(37.97,59.68) 37.52,59.68 37.45,59.62 36.97,59.62 36.62,59.26 34.98,59.26 34.23,60.01 30.05,60.01 29.29,60.77 v5(27.47,60.77)
  IN4 w0.381: v1(29.08,70.3) 29.07,70.31 v1(27.23,70.31)
  IN4 w0.508: v1(23.65,69.35) 25.33,69.35 v1(25.88,69.9) 26.29,70.31 v1(27.23,70.31) 27.23,69.75 27.53,69.45 27.53,66 28.24,65.29 v5(28.24,64.63) ; v6(48.79,40.02) 48.62,40.2 48.62,47.35 43.17,52.8 43.17,59.96 42.63,60.5 41.45,60.5 40.87,61.08 v6(40.87,61.13) 40.87,66.09 40.89,66.12 40.89,66.24 v1(42.35,67.71) 42.35,68.9 41.33,69.93 v1(41.1,69.93)
  BOTTOM w0.127: v5(27.47,60.77) 27.47,59.96 v2(27.17,59.65)
  BOTTOM w0.254: v5(31.19,65.47) 32.36,65.47 32.49,65.34 UT1.G1
  BOTTOM w0.356: RT6.1 v1(27.23,70.31)
  BOTTOM w0.508: RT119.1 17.46,67.83 19.45,69.82 21.89,69.82 22.36,69.35 v1(23.65,69.35) ; RT44.1 RT43.1 36.76,59.68 36.89,59.55 37.6,59.55 37.73,59.68 v5(37.97,59.68)
+3.3V_LDO_PD2: length 120.8
  TOP w0.508: PU103.5 29.14,48.47 29.54,48.07 v3(30.3,48.07)
  IN2 w0.508: v4(30.81,47.62) 30.35,48.07 v3(30.3,48.07) ; v7(48.83,14.04) 48.64,14.23 v7(48.64,15.94) ; v7(43.88,22.86) 44.64,22.86 45.16,22.34 49.5,22.34 51.55,24.39 v7(52.83,24.39) 55.12,22.1 56.13,22.1 v7(60.01,18.23) 60.01,18.05 63.68,14.38 63.68,12.19 v7(63.79,12.08)
  IN3 w0.508: v5(58.1,13.86) v5(55.12,13.86) 55.03,13.86 54.37,14.52 49.31,14.52 v7(48.83,14.04) ; v5(62.53,16.19) 62.53,16.08 63.58,15.04 63.58,13.6 63.45,13.48 63.45,12.42 v7(63.79,12.08) ; v5(30.1,47.36) 30.55,47.36 v4(30.81,47.62)
  IN4 w0.508: v7(63.79,12.08) 61.18,9.46 52.22,9.46 50.91,10.77 50.91,11.66 v1(50.48,12.09) 48.83,13.74 v7(48.83,14.04) ; v5(30.1,47.36) 31.66,48.92 34.84,48.92 36.63,47.13 41.53,47.13 41.89,46.76 41.89,37.14 43.76,35.27 43.76,22.98 v7(43.88,22.86)
  BOTTOM w0.127: v7(52.83,24.39) 52.83,25.08 v2(52.1,25.82)
  BOTTOM w0.254: v5(55.12,13.86) 55.63,14.37 UT2.G1
  BOTTOM w0.356: RT94.1 63.08,11.62 63.54,12.08 v7(63.79,12.08) RT83.1 RT79.1 ; v7(48.83,14.04) RT81.1 RT90.1
  BOTTOM w0.381: RT81.1 49.38,14.05 RT126.1
  BOTTOM w0.508: RT55.2 v7(52.83,24.39) ; RT62.1 RT64.1 RT67.1 v7(60.01,18.23) ; v7(48.64,15.94) 48.64,17.15 48.84,17.35 RT105.1 ; RT86.1 v5(58.1,13.86)
+3.3V_PGPP: length 2.8
  TOP w0.254: v7(61.74,121.42) 61.74,121.37 UCPU1.AG15 ; UCPU1.Y16 62.76,124.45 v7(62.43,124.77) ; v7(63.08,126.45) 62.76,126.13 UCPU1.T16 ; UCPU1.Y15 61.96,124.21 v7(61.61,124.21)
  TOP w0.305: UCPU1.AD15 61.78,123 v7(61.66,123)
  vias: v2(61.42,123.59)
+3.3V_SPI: length 98.6
  TOP w0.254: v7(62.45,119.78) 62.76,120.1 UCPU1.AJ16
  IN3 w0.508: v5(54.38,100.98) 54.38,100.88 54.6,100.66 54.67,100.66 56.15,99.19 58.9,99.19 61.44,96.65 v6(61.47,96.65)
  IN4 w0.254: v6(61.47,96.65) 61.47,96.87 61.6,97 61.6,99.46 62.49,100.36 62.49,104.37 60.82,106.05 60.82,107.05 60.16,107.7 60.16,110.5 60.64,110.98 60.64,114.88 61.19,115.42 61.19,118.32 62.45,119.58 v7(62.45,119.78)
  IN4 w0.508: v5(54.38,100.98) 54.38,99.28 55.37,98.29 v1(55.37,97.36) 55.12,97.11 55.12,96.11 56.67,94.55 56.67,91.72 57.12,91.26 57.12,89.69 56.86,89.43 56.86,88.75 57.04,88.58 57.04,84.14 58.04,83.14 58.04,76.71 v1(58.29,76.46)
  BOTTOM w0.305: 50.06,96.31 JSPI2.8
  BOTTOM w0.381: 50.06,96.31 v2(50.5,96.31) 51.16,96.31 52.21,97.36 v1(55.37,97.36)
  BOTTOM w0.508: RC170.1 35.7,79.77 37.2,81.27 48.02,81.27 52.83,76.46 v1(58.29,76.46) ; v5(54.38,100.98) 56.44,100.98 CC90.1 56.9,99.86 56.64,99.61 UH1.8
+3.3V_TBAT_LDO: length 39.3
  TOP w0.508: v7(144.59,104.4) 153.06,104.4 v7(155.25,102.21) ; v3(140.84,104.02) 140.86,104.04 PR157.2 ; v8(147.84,122.1) PD280.2
  IN1 w0.508: v7(144.59,104.4) 145.75,105.55 145.75,118.94 147.84,121.04 v8(147.84,122.1)
  IN2 w0.508: v7(144.59,104.4) 144.21,104.02 v3(140.84,104.02)
  BOTTOM w0.127: RTCD2.2 157.42,101.77 v9(157.76,102.11)
  BOTTOM w0.508: RTCD2.2 155.69,101.77 v7(155.25,102.21)
+3.3V_VOUT_PD1: length 2.9
  IN3 w0.508: v5(31.22,66.82) 31.86,66.82 32.85,65.84 v5(33.69,65.84)
+3.3V_VOUT_PD2: length 2.5
  IN4 w0.508: v1(54.23,13.95) 54.23,14.48 55.13,15.38 v1(55.13,16.1)
+3.3VDX_SSD: length 10.7
  IN1 w0.508: v8(61.16,84.82) 63.68,82.31 63.68,76.85 64.77,75.76 v7(64.77,75.6)
  vias: v1(46.1,86.02) v1(46.86,84.62) v1(47.28,86.04) v1(47.28,85.54) v1(47.28,85.03) v7(49.34,77.54) v7(49.34,76.95) v7(49.34,76.37) v7(49.92,77.54) v7(49.92,76.95) v7(64.77,75.02) v7(65.35,75.6) v7(65.35,75.02) v9(44.2,76.96)
+3V_5105: length 97.1
  TOP w0.112: v2(32.38,88.48) 32.61,88.25 RE1.1
  TOP w0.254: v8(28.96,108.65) 28.96,108.14 v8(28.83,108.02)
  TOP w0.381: RE269.2 v8(28.78,110.3)
  IN1 w0.254: v8(28.83,108.02) 28.98,107.86 28.98,107.08 v10(27.08,105.17)
  IN1 w0.381: v8(28.96,108.65) 28.78,108.83 v8(28.78,110.3)
  IN2 w0.254: v10(27.08,105.17) 26.92,105.02 v4(26.92,104.81)
  IN2 w0.508: v4(35.94,103.6) 36.02,103.6 36.83,102.78 36.83,101.45 39.37,98.91 39.37,90.87 36.5,88 v3(36.5,87.95) 36.5,81.32 35.67,80.5 35.67,77.81 36.09,77.39 v4(36.09,74.69)
  IN3 w0.254: v5(21.53,115.2) 22.06,114.67 22.38,114.67 v6(22.4,114.64)
  IN3 w0.305: v5(17.75,116.65) 18.08,116.65 18.41,116.98 18.82,116.98 19.63,116.17 20.55,116.17 v5(21.53,115.2)
  IN3 w0.381: v6(44.17,102.4) 43.66,102.91 39.73,102.91 39.04,103.6 37.57,103.6 36.72,104.45 35.98,104.45 35.13,103.6
  IN3 w0.508: v4(36.09,74.69) 25.83,74.69 v5(25.32,75.2)
  IN4 w0.254: v6(22.4,114.64) 22.43,114.67 22.71,114.67 22.9,114.48 24.25,114.48 24.25,114.48 24.92,114.48 25,114.48 25.46,114.48 v1(25.51,114.43) ; v1(17.4,111.57) 17.25,111.72 17.25,112.61 16.89,112.97
  IN4 w0.305: v13(23.17,109.58) 23.17,109.22 23.22,109.18 23.22,109.18 23.44,108.96 23.44,108.95 23.5,108.9 23.5,108.12 v1(23.62,107.99)
  IN4 w0.381: v5(27.29,104.34) 27.99,103.64 28.49,103.64 v1(29.08,103.05)
  IN4 w0.508: 19.54,124.74 19.54,124.89 19.54,124.9 19.54,125.3 19.54,125.3 19.54,125.42 20.45,126.33 20.45,130.75 21.08,131.38 21.08,132.63
  BOTTOM w0.254: 29.53,113.6 29.8,113.6 30.17,113.23 30.87,113.23 31.88,114.24 32.69,114.24
  BOTTOM w0.305: v1(24.43,106.62) CE49.1 24.5,106.73 24.51,106.75 24.51,108.59 UE3.H1 ; v1(23.62,106.62) v1(23.62,107.99)
  BOTTOM w0.381: v5(27.29,104.34) 27.29,104.81 27.28,104.81 RE262.2 ; v1(29.08,103.05) 29.07,103.06 RE40.1 29.16,103.56 RE64.2 29.18,104.1 RE250.1 RE32.2 RE30.2 ; R474.1 44.59,104.79 v1(44.13,104.33) ; RE123.1 25.16,75.36 v5(25.32,75.2)
  vias: v1(17.73,116.35) v1(18.06,113.67) v1(19.95,124.34) v1(19.96,124.05) v1(21.08,133.16) v1(21.08,132.78) v1(22.99,106.03) v1(32.94,116.09) v1(33.07,116.35) v5(16.33,119.95) v5(16.33,119.67) v5(16.33,119.39) v5(17.51,105.72) v5(17.56,106.39) v5(22.34,106.02) v5(23.67,121.85) v5(23.66,121.52) v5(25.53,104.84) v5(25.55,104.56) v5(26.97,121.13) v5(28.32,120.92) v5(31.19,121.43) v6(14.5,106.34) v6(14.48,106.06) v6(19.28,121.45) v6(19.56,121.45) v6(21.87,105.98) v6(30.91,119.48) v6(31.22,119.55)
+3V_FAN: length 2.7
  TOP w0.508: R27.2 R444.2 151.84,138.61 R443.2 R28.2
+3V_LDO: length 363.6
  TOP w0.381: PR252.1 32.98,24.74 v8(33.15,24.58) ; v3(146.01,123.6) PD280.3 ; PU301.5 155.81,125.49 v8(154.72,125.49) ; PR160.1 29.84,17.59 v3(29.84,18.06)
  IN1 w0.381: v8(20.57,21.15) v8(20.57,22.42) 20.57,23.33 18.03,25.87 18.03,32.92 v3(17.83,33.12) ; v8(20.57,21.15) 20.32,21.15 18.16,18.99 15.7,18.99 v8(15.44,19.24) ; v8(20.57,21.15) 20.75,20.97 23.55,20.97 24.66,19.85 26.42,19.85 28.21,18.06 v3(29.84,18.06) 30.06,18.06 30.89,18.89 30.89,21.68 33.15,23.94 v8(33.15,24.58) ; v10(77.53,86.68) 81.19,86.68 82.69,88.18 94.18,88.18 95.53,87.73 103.81,87.73 104.19,87.35 111.36,87.35 116.83,92.82 118.92,92.82 120.17,92.82 123.19,89.8 127.42,89.8 128.37,88.85 130.81,88.85 132.39,90.44 135.29,90.44 135.88,91.02 143.79,91.02 144.93,92.17 146.84,92.17 157.91,103.24 v7(157.91,103.57) ; v10(154.56,120.72) 154.72,120.88 v8(154.72,125.49) ; v8(23.94,43.03) 23.65,42.74 22.35,42.74 v10(22.23,42.86) 21.97,43.12 21.97,44.26 22.99,45.28 24,45.28 v3(24.64,45.91)
  IN2 w0.381: v3(146.01,123.6) 147.61,123.6 148.46,122.75 152.59,122.75 154.56,120.78 v10(154.56,120.72) 154.53,120.69 154.53,106.95 v7(157.91,103.57) ; v3(29.84,18.06) 30.06,18.06 32.04,20.04 36.32,20.04 38.01,21.73 43.97,21.73 44.25,21.45 54.95,21.45 59.4,17 59.4,16.19 59.91,15.69 59.94,15.69 62.66,12.97 62.66,12.11 62.3,11.75 61.72,11.75 61.21,12.25 v7(61.21,12.32) ; 21.72,42.38 21.46,42.13 21.46,35.55 v3(20.45,34.53) 19.04,33.12 v3(17.83,33.12) ; v4(76.67,84.73) 76.67,85.82 v10(77.53,86.68)
  IN3 w0.381: v4(76.67,84.73) 74.12,84.73 72.27,86.59 68.52,86.59 67.15,87.96 61.71,87.96 61.57,88.1 58.08,88.1 57.52,88.66 49.79,88.66 v6(49.57,88.44) ; v7(51.7,61.3) 41.8,61.3 40.48,62.62 38.46,62.62 36.87,61.03 34.42,61.03 34.16,60.77 v5(30.15,60.77) ; v6(56.04,47.44) 49.63,47.44 49.02,48.05 40.72,48.05 39.98,47.31 32.89,47.31 32.03,48.18 30.13,48.18 28.57,46.62 28.57,46.29 27.28,45 23.98,45 v4(22.23,43.25)
  IN4 w0.381: v6(49.57,88.44) 50.2,87.81 50.2,83.36 51.66,81.91 51.66,81.37 53.25,79.78 53.25,67.76 51.7,66.2 v7(51.7,61.3) 51.7,54.51 56.04,50.17 v6(56.04,47.44)
  BOTTOM w0.127: v7(157.91,103.57) 158.18,103.84 v9(158.43,103.84)
  BOTTOM w0.381: RTCD1.2 157.4,103.57 v7(157.91,103.57) ; RT85.1 v7(61.21,12.32)
+3V_PRIM: length 497.2
  TOP w0.254: v7(64.36,124.8) 64.71,125.15 UCPU1.V19 ; v8(49.23,120.52) RC64.2 RC65.1 ; v7(63.53,118.84) 63.41,118.96 UCPU1.AK17 ; UCPU1.AJ21 65.7,119.86 v7(65.7,119.74)
  TOP w0.381: R5775.1 42.43,128.06 41.52,127.14 41.52,124.53 41.97,124.07 42.39,124.07 42.69,123.77 RC206.2 ; RC206.2 43.37,123.5 R5777.1 43.56,122.98 43.81,122.72 45.68,122.72 RC60.2 ; RC206.2 RC205.2
  TOP w0.508: 60.1,140.35 61.23,140.35 61.75,139.84 ; 60.1,140.35 59.97,140.48 59.41,140.48 59.05,140.12 RC11.2 RC13.2 ; 60.1,140.35 60.1,139.1 RC14.2 ; v3(46.28,120.72) 46.28,121.46 RC60.2 ; v7(77.29,140.35) 76.43,141.21 76.43,142.13 75.9,142.66 71.35,142.66 70.46,141.77 70.46,141.29 ; RC204.1 61.75,139.84 ; 61.75,139.84 61.75,140.7 62.61,141.57 66.27,141.57 ; RC8.1 54.25,138.98 54.25,139.76 54.9,140.41 57.86,140.41 58.17,140.11 RC13.2 ; RH19.1 RH20.1 v3(55.42,108.8) ; RC13.2 RC12.2 ; v3(62.7,99.36) 62.81,99.25 65.9,99.25 66.47,99.82 66.47,103.9 66.8,104.23 RC81.1
  IN1 w0.254: v3(46.28,120.72) 46.66,121.1 47.85,121.1 48.43,120.52 v8(49.23,120.52)
  IN1 w0.508: v8(70.36,141.24) 70.18,141.06 66.77,141.06 v8(66.6,141.24)
  IN1 w0.635: 48.56,102.06 54.97,108.46
  IN2 w0.508: v3(62.7,99.36) 62.62,99.28 62.61,99.28 62.11,99.28 62.08,99.25 v4(62.05,99.25) ; v3(46.28,120.72) 46.22,120.65 46.22,120.1 46.54,119.77 47.54,119.77 47.91,120.14 v4(48.55,120.14) 49.71,121.3 49.71,123.41 v3(49.53,123.59) 49.53,124.06 v4(49.95,124.47) ; v4(56.08,109.31) 55.93,109.31 v3(55.42,108.8)
  IN2 w0.762: 46.89,89.12 46.22,88.44 46.22,86.25 46.52,85.94 v4(46.52,80.68)
  IN3 w0.254: v4(49.95,124.47) 49.8,124.33 v5(49.8,123.96) ; v5(47.94,120.21) 48.49,120.21 v4(48.55,120.14)
  IN3 w0.508: 34.99,140.27 35.19,140.48 36.38,140.48 36.88,139.98 37.53,139.98 42.01,139.98 42.97,140.95 46.58,140.95 ; v5(45.47,80.64) 46.28,80.64 46.33,80.68 v4(46.52,80.68) ; v4(62.05,99.25) 62.97,100.17 62.97,102.65 62.02,103.59 57.18,103.59 v5(56.52,104.26) ; v4(56.08,109.31) 55.13,109.31 53.34,111.1 v5(53.34,111.83) ; 149.99,143.89 149.9,143.98 145.01,143.98 144.34,144.65 v5(144.31,144.65) ; v6(63.25,120.84) 63.18,120.78 60.79,120.78 60.68,120.67 60.44,120.67 59.92,120.14 v6(59.18,120.14)
  IN3 w0.762: v5(49.91,90.49) 48.62,89.19 48.29,89.19
  IN4 w0.457: 47.8,141.04 47.54,141.04 v6(47.45,140.95) ; 48.95,101.66 48.95,102.85 46.29,105.5 46.29,107.48 42.82,110.96 42.82,117.49 42.89,117.57 42.89,122.35 43.46,122.92 43.46,128.81 43.69,129.03 43.69,129.41 43.51,129.59 43.51,130.97 42.37,132.11 42.37,136.25 42.37,136.25 42.37,136.63 43.96,138.22 45.27,138.22 45.72,138.67 45.72,139.64 v1(45.9,139.82)
  IN4 w0.508: 47.8,141.04 53.64,141.04 53.92,140.76 ; 47.69,138.94 47.69,138.14 48.27,137.56 50.04,137.56 52.17,135.42 52.9,135.42 54.02,134.3 56.49,134.3 57.3,135.12 61.06,135.12 62.79,133.39 67.67,133.39 69.72,131.33 69.72,130.72 68.17,129.17 68.17,127.22 66.8,125.85 66.8,125.72 ; v7(147.28,133.21) 145.88,133.21 v1(144.96,134.14) 143.4,135.7 143.4,138.34 140.72,141.02 140.72,142.75 140.95,142.98 140.95,145.37 140.13,146.19 v1(140.13,147) ; v1(68,20.51) 64.67,20.51 63.86,21.32 63.86,22.74 59.24,27.37 55.25,27.37 54.12,28.5 54.12,31.98 54.52,32.38 54.52,44.91 54.12,45.32 54.12,49.06 49.53,53.65 49.53,72.68 46.66,75.55 46.66,78.1 45.69,79.06 45.69,80.41 v5(45.47,80.64) ; v1(57.95,113.22) 57.95,110.03 58.04,109.95 58.04,109.55 57.95,109.46 57.95,107.06 56.52,105.63 v5(56.52,104.26) ; v1(57.95,113.22) 57.95,114.1 v1(57.96,114.11) ; v1(57.95,113.22) 56.34,113.22 55.67,113.89 55.67,114.43 56.03,114.8 56.03,117.02 55.65,117.4 55.65,118.43 v1(56.31,119.09) 57.37,120.14 v6(59.18,120.14) ; v1(70.93,139.76) 71.24,140.07 77.01,140.07 v7(77.29,140.35) 77.64,140 87.26,140 87.73,139.53 91.3,139.53 95.19,143.42 107.62,143.42 115.33,151.13 v1(120.65,151.13) ; v6(30.23,131.15) 30.23,130.66 30.22,130.65 30.22,130.33 30.22,130.33 30.22,129.21 30.21,129.21 30.21,128.88 30.19,128.85 30.19,128.45 ; v7(38.26,160.28) 38.42,160.11 38.42,155.83 38.88,155.37 38.88,146.73 35.94,143.79 35.94,143.4 34.44,141.9 34.44,140.96 34.65,140.76 ; v1(46.1,88.71) 45.95,88.86 44.68,88.86 v1(43.48,90.06) ; v6(33.25,131.21) 33.25,131.23 33.27,131.26 33.27,134.22 32.8,134.69 32.8,135.24 33.07,135.51 33.07,138.38 34.33,139.63 34.33,140.15 v6(34.44,140.26)
  IN4 w0.762: 48.79,100.65 48.79,99.8 49.26,99.33 49.26,97.18 ; v5(49.91,90.49) 49.26,91.14 49.26,96.17
  BOTTOM w0.305: v7(38.26,160.28) 37.45,160.28 37.14,160.58 JAPS1.18
  BOTTOM w0.356: RC195.2 v5(49.91,90.49) ; 54.41,119.09 54.28,118.96 RC396.1
  BOTTOM w0.381: U44.5 144.41,133.6 v1(144.96,134.14)
  BOTTOM w0.508: RC199.1 49.29,123.2 49.8,123.72 v5(49.8,123.96) ; v5(45.47,80.64) 45.12,80.64 45.11,80.65 37.68,80.65 v9(36.36,79.33) 35.89,78.86 RC170.2 ; v5(53.34,111.83) 53.21,111.83 52.7,112.33 52.7,114.25 51.7,115.25 50.8,115.25 50.47,115.58 RC158.1 50.04,115.89 47.94,117.98 v5(47.94,120.21) ; v1(120.65,151.13) 121.41,150.37 132.68,150.37 135.07,147.98 139.11,147.98 139.39,148.26 ; 54.41,119.09 v1(56.31,119.09) ; R448.1 141.1,146.22 141.46,145.86 143,145.86 143.31,146.17 144.03,146.17 144.31,145.89 v5(144.31,144.65) ; RC107.1 v7(147.28,133.21) ; v7(65.7,119.74) 65.7,120.21 65.46,120.46 CC56.1 CC57.1 ; v1(70.93,139.76) 70.93,137.58 70.56,137.21 U4252.5
  vias: v1(30.71,126.94) v1(30.99,126.94) v1(45.69,139.56) v1(48.61,139.65) v1(48.65,96.81) v1(48.88,139.66) v3(54.18,140.63) v3(54.48,140.6) v4(47.56,89.38) v4(47.56,88.89) v4(53.85,140.66) v5(47.16,89.46) v5(47.16,89.16) v5(150.35,143.56) v6(30.25,130.82) v6(33.22,130.82) v6(34.88,140.27) v6(47.08,140.96) v6(54.18,140.81) v6(54.43,140.78) v7(48.01,100.75) v7(48.41,101.16) v8(66.34,141.49) v8(70.87,141.21)
