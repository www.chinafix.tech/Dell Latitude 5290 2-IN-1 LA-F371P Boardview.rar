# Allegro board Dell Latitude 5290 2-IN-1 LA-F371P Boardview.brd (continued)
## Nets (continued)
DDR_A_D10: UCPU1.AU71 UD2.N10
DDR_A_D11: UCPU1.AU68 UD2.M11
DDR_A_D12: UCPU1.AR71 UD2.P9
DDR_A_D13: UCPU1.AR69 UD2.M8
DDR_A_D14: UCPU1.AU70 UD2.N11
DDR_A_D15: UCPU1.AU69 UD2.M10
DDR_A_D16: UCPU1.AF65 UD4.E10
DDR_A_D17: UCPU1.AF64 UD4.F10
DDR_A_D18: UCPU1.AK65 UD4.F8
DDR_A_D19: UCPU1.AK64 UD4.D9
DDR_A_D20: UCPU1.AF66 UD4.F11
DDR_A_D21: UCPU1.AF67 UD4.E11
DDR_A_D22: UCPU1.AK67 UD4.F9
DDR_A_D23: UCPU1.AK66 UD4.E9
DDR_A_D24: UCPU1.AF70 UD4.M9
DDR_A_D25: UCPU1.AF68 UD4.N10
DDR_A_D26: UCPU1.AH71 UD4.M11
DDR_A_D27: UCPU1.AH68 UD4.P9
DDR_A_D28: UCPU1.AF71 UD4.M8
DDR_A_D29: UCPU1.AF69 UD4.N9
DDR_A_D30: UCPU1.AH70 UD4.M10
DDR_A_D31: UCPU1.AH69 UD4.N11
DDR_A_D32: UCPU1.BB65 UD2.B10
DDR_A_D33: UCPU1.AW65 UD2.C11
DDR_A_D34: UCPU1.AW63 UD2.C9
DDR_A_D35: UCPU1.AY63 UD2.B9
DDR_A_D36: UCPU1.BA65 UD2.B11
DDR_A_D37: UCPU1.AY65 UD2.C10
DDR_A_D38: UCPU1.BA63 UD2.B8
DDR_A_D39: UCPU1.BB63 UD2.C8
DDR_A_D40: UCPU1.BA61 UD2.T8
DDR_A_D41: UCPU1.AW61 UD2.R9
DDR_A_D42: UCPU1.BB59 UD2.R11
DDR_A_D43: UCPU1.AW59 UD2.T10
DDR_A_D44: UCPU1.BB61 UD2.R8
DDR_A_D45: UCPU1.AY61 UD2.T9
DDR_A_D46: UCPU1.BA59 UD2.R10
DDR_A_D47: UCPU1.AY59 UD2.T11
DDR_A_D48: UCPU1.AT66 UD4.R10
DDR_A_D49: UCPU1.AU66 UD4.T10
DDR_A_D50: UCPU1.AP65 UD4.R8
DDR_A_D51: UCPU1.AN65 UD4.T8
DDR_A_D52: UCPU1.AN66 UD4.R11
DDR_A_D53: UCPU1.AP66 UD4.T11
DDR_A_D54: UCPU1.AT65 UD4.R9
DDR_A_D55: UCPU1.AU65 UD4.T9
DDR_A_D56: UCPU1.AT61 UD4.C11
DDR_A_D57: UCPU1.AU61 UD4.B10
DDR_A_D58: UCPU1.AP60 UD4.B8
DDR_A_D59: UCPU1.AN60 UD4.C8
DDR_A_D60: UCPU1.AN61 UD4.B11
DDR_A_D61: UCPU1.AP61 UD4.C10
DDR_A_D62: UCPU1.AT60 UD4.C9
DDR_A_D63: UCPU1.AU60 UD4.B9
DDR_A_DQS0: UCPU1.AM69 UD2.G10
DDR_A_DQS1: UCPU1.AT70 UD2.L10
DDR_A_DQS2: UCPU1.AH65 UD4.G10
DDR_A_DQS3: UCPU1.AG70 UD4.L10
DDR_A_DQS4: UCPU1.AY64 UD2.D10
DDR_A_DQS5: UCPU1.BA60 UD2.P10
DDR_A_DQS6: UCPU1.AR65 UD4.P10
DDR_A_DQS7: UCPU1.AR60 UD4.D10
DDR_A_DQS#0: UCPU1.AM70 UD2.G11
DDR_A_DQS#1: UCPU1.AT69 UD2.L11
DDR_A_DQS#2: UCPU1.AH66 UD4.G11
DDR_A_DQS#3: UCPU1.AG69 UD4.L11
DDR_A_DQS#4: UCPU1.BA64 UD2.D11
DDR_A_DQS#5: UCPU1.AY60 UD2.P11
DDR_A_DQS#6: UCPU1.AR66 UD4.P11
DDR_A_DQS#7: UCPU1.AR61 UD4.D11
DDR_A_ODT0: RD73.1 UCPU1.AT45 UD2.J8 UD4.J8
DDR_B0_ZQ0: RD13.1 UD3.B3
DDR_B0_ZQ1: RD14.1 UD3.B4
DDR_B1_ZQ0: RD8.1 UD1.B3
DDR_B1_ZQ1: RD7.1 UD1.B4
DDR_B_CA1_0: RD22.1 UCPU1.AY48 UD3.R2
DDR_B_CA1_1: RD24.1 UCPU1.AP50 UD3.P2
DDR_B_CA1_2: RD26.1 UCPU1.BA48 UD3.N2
DDR_B_CA1_3: RD28.1 UCPU1.BB48 UD3.N3
DDR_B_CA1_4: RD30.1 UCPU1.AP48 UD3.M3
DDR_B_CA1_5: RD32.1 UCPU1.AP52 UD3.F3
DDR_B_CA1_6: RD34.1 UCPU1.AN50 UD3.E3
DDR_B_CA1_7: RD36.1 UCPU1.AN48 UD3.E2
DDR_B_CA1_8: RD38.1 UCPU1.AN53 UD3.D2
DDR_B_CA1_9: RD40.1 UCPU1.AN52 UD3.C2
DDR_B_CA2_0: RD42.1 UCPU1.BA43 UD1.R2
DDR_B_CA2_1: RD44.1 UCPU1.AY43 UD1.P2
DDR_B_CA2_2: RD46.1 UCPU1.AY44 UD1.N2
DDR_B_CA2_3: RD48.1 UCPU1.AW44 UD1.N3
DDR_B_CA2_4: RD50.1 UCPU1.BB44 UD1.M3
DDR_B_CA2_5: RD52.1 UCPU1.AY47 UD1.F3
DDR_B_CA2_6: RD54.1 UCPU1.BA44 UD1.E3
DDR_B_CA2_7: RD56.1 UCPU1.AW46 UD1.E2
DDR_B_CA2_8: RD58.1 UCPU1.AY46 UD1.D2
DDR_B_CA2_9: RD60.1 UCPU1.BA46 UD1.C2
DDR_B_CKE0: RD66.1 UCPU1.AN56 UD3.K3
DDR_B_CKE1: RD68.1 UCPU1.AP55 UD3.K4
DDR_B_CKE2: RD70.1 UCPU1.AN55 UD1.K3
DDR_B_CKE3: RD72.1 UCPU1.AP53 UD1.K4
DDR_B_CLK0: RD76.1 UCPU1.AP45 UD3.J3
DDR_B_CLK1: RD80.1 UCPU1.AP46 UD1.J3
DDR_B_CLK#0: RD78.1 UCPU1.AN45 UD3.J2
DDR_B_CLK#1: RD82.1 UCPU1.AN46 UD1.J2
DDR_B_CS#0: RD62.1 UCPU1.BB42 UD1.L3 UD3.L3
DDR_B_CS#1: RD64.1 UCPU1.AY42 UD1.L4 UD3.L4
DDR_B_D0: UCPU1.AY39 UD1.R8
DDR_B_D1: UCPU1.AW39 UD1.T8
DDR_B_D2: UCPU1.AY37 UD1.T11
DDR_B_D3: UCPU1.AW37 UD1.R10
DDR_B_D4: UCPU1.BB39 UD1.R9
DDR_B_D5: UCPU1.BA39 UD1.T9
DDR_B_D6: UCPU1.BA37 UD1.R11
DDR_B_D7: UCPU1.BB37 UD1.T10
DDR_B_D8: UCPU1.AY35 UD1.M10
DDR_B_D9: UCPU1.AW35 UD1.P9
DDR_B_D10: UCPU1.AY33 UD1.M9
DDR_B_D11: UCPU1.AW33 UD1.M11
DDR_B_D12: UCPU1.BB35 UD1.N11
DDR_B_D13: UCPU1.BA35 UD1.N10
DDR_B_D14: UCPU1.BA33 UD1.M8
DDR_B_D15: UCPU1.BB33 UD1.N9
DDR_B_D16: UCPU1.AU40 UD3.C9
DDR_B_D17: UCPU1.AT40 UD3.C8
DDR_B_D18: UCPU1.AT37 UD3.C10
DDR_B_D19: UCPU1.AU37 UD3.C11
DDR_B_D20: UCPU1.AR40 UD3.B8
DDR_B_D21: UCPU1.AP40 UD3.B9
DDR_B_D22: UCPU1.AP37 UD3.B10
DDR_B_D23: UCPU1.AR37 UD3.B11
DDR_B_D24: UCPU1.AT33 UD3.M9
DDR_B_D25: UCPU1.AU33 UD3.M10
DDR_B_D26: UCPU1.AU30 UD3.N10
DDR_B_D27: UCPU1.AT30 UD3.N11
DDR_B_D28: UCPU1.AR33 UD3.N9
DDR_B_D29: UCPU1.AP33 UD3.M8
DDR_B_D30: UCPU1.AR30 UD3.P9
DDR_B_D31: UCPU1.AP30 UD3.M11
DDR_B_D32: UCPU1.AY31 UD1.E9
DDR_B_D33: UCPU1.AW31 UD1.F8
DDR_B_D34: UCPU1.AY29 UD1.E11
DDR_B_D35: UCPU1.AW29 UD1.E10
DDR_B_D36: UCPU1.BB31 UD1.D9
DDR_B_D37: UCPU1.BA31 UD1.F9
DDR_B_D38: UCPU1.BA29 UD1.F10
DDR_B_D39: UCPU1.BB29 UD1.F11
DDR_B_D40: UCPU1.AY27 UD1.B10
DDR_B_D41: UCPU1.AW27 UD1.C11
DDR_B_D42: UCPU1.AY25 UD1.C9
DDR_B_D43: UCPU1.AW25 UD1.B9
DDR_B_D44: UCPU1.BB27 UD1.B11
DDR_B_D45: UCPU1.BA27 UD1.C10
DDR_B_D46: UCPU1.BA25 UD1.B8
DDR_B_D47: UCPU1.BB25 UD1.C8
DDR_B_D48: UCPU1.AU27 UD3.F11
DDR_B_D49: UCPU1.AT27 UD3.E10
DDR_B_D50: UCPU1.AT25 UD3.F9
DDR_B_D51: UCPU1.AU25 UD3.F10
DDR_B_D52: UCPU1.AP27 UD3.E11
DDR_B_D53: UCPU1.AN27 UD3.D9
DDR_B_D54: UCPU1.AN25 UD3.F8
DDR_B_D55: UCPU1.AP25 UD3.E9
DDR_B_D56: UCPU1.AT22 UD3.T11
DDR_B_D57: UCPU1.AU22 UD3.R10
DDR_B_D58: UCPU1.AU21 UD3.T9
DDR_B_D59: UCPU1.AT21 UD3.R9
DDR_B_D60: UCPU1.AN22 UD3.R11
DDR_B_D61: UCPU1.AP22 UD3.T10
DDR_B_D62: UCPU1.AP21 UD3.T8
DDR_B_D63: UCPU1.AN21 UD3.R8
DDR_B_DQS0: UCPU1.AY38 UD1.P10
DDR_B_DQS1: UCPU1.BA34 UD1.L10
DDR_B_DQS2: UCPU1.AR38 UD3.D10
DDR_B_DQS3: UCPU1.AR32 UD3.L10
DDR_B_DQS4: UCPU1.AY30 UD1.G10
DDR_B_DQS5: UCPU1.BA26 UD1.D10
DDR_B_DQS6: UCPU1.AR27 UD3.G10
DDR_B_DQS7: UCPU1.AR21 UD3.P10
DDR_B_DQS#0: UCPU1.BA38 UD1.P11
DDR_B_DQS#1: UCPU1.AY34 UD1.L11
DDR_B_DQS#2: UCPU1.AT38 UD3.D11
DDR_B_DQS#3: UCPU1.AT32 UD3.L11
DDR_B_DQS#4: UCPU1.BA30 UD1.G11
DDR_B_DQS#5: UCPU1.AY26 UD1.D11
DDR_B_DQS#6: UCPU1.AR25 UD3.G11
DDR_B_DQS#7: UCPU1.AR22 UD3.P11
DDR_B_ODT0: RD74.1 UCPU1.BA42 UD1.J8 UD3.J8
DDR_CHA_EN: RH30.1 RH31.1 UCPU1.P3
DDR_CHB_EN: RH28.1 RH29.1 UCPU1.P2
DDR_VTT_CNTL: UC1.2 UCPU1.AW67
DDR_XDP_SMBCLK: JXDP1.53 RN2.2 UCPU1.R7
DDR_XDP_SMBDAT: JXDP1.51 RN1.2 UCPU1.R8
DEBUG_UART0_TX: JDEG3.9 UCPU1.AB2
DET_L#: JIO2.14 PR158.1 UE3.F9
DET_R: JIO2.5 PR121.2 PR162.1
DET_R#: PR161.1 UE3.G5
DISPOFF#: D39.1 PR407.1 R61.1
DMIC_CLK12: CA41.1 MIC1.3 MIC2.3 RA24.1 TC3.1(TP-1)
DMIC_CLK34: C83.1 JWFC1.32 MIC3.3 RA32.1
DMIC_CLK_R: RA24.2 RA32.2 UA1.6
DMIC_DATA12: C74.1 CA34.1 MIC1.4 MIC2.4 RA19.2 TC2.1(TP-1) UA1.5
DMIC_DATA34: C73.1 CA35.1 JWFC1.31 MIC3.4 RA15.1 UA1.2
DOCK_PWR_EN: R73.2 U7.4 UE3.H8
EC_FPM_EN: JIO1.29 UE3.D6
EC_SLP_S0IX#: R5749.1 RC163.2 UCPU1.AY5
EC_SLP_S0IX#_EC: R5749.2 UE3.C11
EDP_AUXN: C176.1 UCPU1.E45
EDP_AUXN_CONN: JEDP1.42 R417.2
EDP_AUXN_R: C176.2 R417.1
EDP_AUXP: C175.1 UCPU1.F45
EDP_AUXP_CONN: JEDP1.43 R416.2
EDP_AUXP_R: C175.2 R416.1
EDP_BIA_PWM: D40.3 UCPU1.R11
EDP_CAB_DET#: JEDP1.2 RC180.2 UCPU1.AP7
EDP_COMP: RC108.2 UCPU1.E52
EDP_HPD: JEDP1.35 RC126.2 UCPU1.L10
EDP_ID0: R433.1 RC193.1 UCPU1.W7
EDP_TXN_P0: C177.1 UCPU1.C47
EDP_TXN_P0_CONN: JEDP1.46 R414.2
EDP_TXN_P0_R: C177.2 R414.1
EDP_TXN_P1: C180.1 UCPU1.D46
EDP_TXN_P1_CONN: JEDP1.49 R412.2
EDP_TXN_P1_R: C180.2 R412.1
EDP_TXP_P0: C178.1 UCPU1.C46
EDP_TXP_P0_CONN: JEDP1.45 R415.2
EDP_TXP_P0_R: C178.2 R415.1
EDP_TXP_P1: C179.1 UCPU1.C45
EDP_TXP_P1_CONN: JEDP1.48 R413.2
EDP_TXP_P1_R: C179.2 R413.1
EDRAM_OPIO_RCOMP: RC122.1 UCPU1.H66
EMMC_RCOMP: RC66.1 UCPU1.AT1
EN_0.6V: PC613.1 PR605.2 PR607.1 PR608.2 PU600.16
EN_1.0VA: PC700.1 PR700.2 PR701.1 PU700.11
EN_1.2V: PC615.1 PR611.2 PR612.1 PU600.15
EN_1.8VA: PC720.2 PR720.2 PR721.2 PU720.13
EN_1.8VU: PC728.2 PR727.2 PR728.2 PU721.13
EN_INVPWR: Q32.2 RE69.2 UE3.B2
EN_INVPWR_R: C231.2 Q33.3 R485.2 R486.1
EN_PD_HV1: PR165.2 PR184.1 PR217.1 RT46.2
EN_PD_HV2: PR167.2 PR182.1 PR224.1 RT75.2
EN_PRIM_COREP: PC810.1 PR815.2 PR816.1 PU801.13
EN_VCCIO: PC800.1 PR803.1 PR826.2 PU800.13
ENVDD: D60.1 R76.1 U8.4
EOPIO_RCOMP: RC123.1 UCPU1.H65
ESPI_ALERT#: RC83.2 UCPU1.AY11 UE3.H7
ESPI_CLK: CC78.2 JESPI1.10 RC70.2 RC71.2 RE172.1 UE3.G7
ESPI_CS#: JESPI1.7 UCPU1.BA12 UE3.H6
ESPI_IO0: JESPI1.3 RC383.2 UE3.K5
ESPI_IO0_R: RC383.1 UCPU1.AY13
ESPI_IO1: JESPI1.4 RC384.2 UE3.L4
ESPI_IO1_R: RC384.1 UCPU1.BA13
ESPI_IO2: JESPI1.5 RC385.2 UE3.G6
ESPI_IO2_R: RC385.1 UCPU1.BB13
ESPI_IO3: JESPI1.6 RC386.2 UE3.L5
ESPI_IO3_R: RC386.1 UCPU1.AY12
ESPI_RESET#: UCPU1.BA11 UE3.K6
FB_1.8VA: PC721.2 PR722.2 PR724.1 PU720.5
FB_1.8VU: PC729.2 PR729.2 PR731.1 PU721.5
FIVR_EN: RC109.2 RC111.2 RC121.1
FIVR_EN_R: JXDP1.45 RC119.2 RC121.2 RC144.2
GNSS_IRQ: JNGFF1.44 RH8.1 UCPU1.AM3
GNSS_OFF#: Q29.1 RH5.1 UCPU1.AN2
GNSS_OFF#_R: JNGFF1.26 Q29.3 R35.2
GNSS_SCL: JNGFF1.40 R219.1
GPP_B22: RC65.2 UCPU1.AN5
GPP_B23: RC64.1 UCPU1.AM7
GPP_C5: RC58.1 UCPU1.W1
GPP_C17: RC206.1 UCPU1.U6
GPP_E1: RC41.1 RC204.2 UCPU1.H3
H_CATERR#: RC7.2 UCPU1.D63
H_CPU_SVIDALRT#: RC22.1 UCPU1.B63
H_CPUPWRGD: CA4.1 RC39.2 UCPU1.A68
H_CPUPWRGD_R: RC39.1 T7.1(TP-1)
H_PECI: RE49.2 UCPU1.A54
H_PROCHOT#: PR315.1 PR600.1 PR933.1 RC27.1 RC28.2 RE50.2
H_PROCHOT#_R: RC27.2 UCPU1.C65
H_THERMTRIP#: QE16.3 RC389.1
H_THERMTRIP#_R: RC20.2 RC389.2 UCPU1.C63
H_VCCST_PWRGD_P: CA3.1 RC25.2 RC26.1 RC132.1 UE7.4
H_VCCST_PWRGD_XDP: JXDP1.39 RC131.2 RC132.2
HDA_BLK: CC17.1 RA16.2 RC77.1
HDA_BLK_L: CA37.1 RA16.1 UA1.8
HDA_BLK_R: RC77.2 UCPU1.AY22
HDA_SDI0: CC94.1 RA17.2 UCPU1.BA21
HDA_SDI0_L: RA17.1 UA1.10
HDA_SDOUT: CC93.1 RC76.1 RC81.2 RC92.2 UA1.11
HDA_SDOUT_R: RC76.2 UCPU1.BB22
HDA_SYNC: RC75.1 UA1.9
HDA_SYNC_R: RC75.2 UCPU1.BA22
HOME_KEY#: C219.1 JIO1.20 RE62.1 UE3.H9
HOST_DEBUG_TX: JDEG3.8 RE1.2 UE3.G11
HOST_SD_WP#: QR1.2 RC56.2 UCPU1.AB3
HP2: RA40.2 UA1.48
HP_PLUG#: RA7.1 RA14.1
HP_PLUG#_R: DA6.1 JP1.6 RA7.2
HPOL_CONN: CA50.1 DA5.1 JP1.1 L19.2
HPOR_CONN: CA49.1 DA4.1 JP1.2 L18.2
HPOUT-L: CA11.1 CA12.2 RA6.1 UA1.26
HPOUT-L_L: L19.1 RA6.2
HPOUT-R: CA9.1 CA10.2 RA3.1 UA1.25
HPOUT-R_L: L18.1 RA3.2
I2C0_IRQ_TS: JEDP1.3 RC194.2 UCPU1.L6
I2C1_CLK_PD1: RT25.2 RT26.2 UT1.D2
I2C1_CLK_PD2_C: RT86.2 RT92.2 UT2.D2
I2C1_DAT_PD1: RT29.2 RT30.2 UT1.D1
I2C1_DAT_PD2_C: RT87.2 RT93.2 UT2.D1
I2C1_INT#_PD1: RT32.2 RT33.2 UT1.C1
I2C1_INT#_PD2_C: RT94.2 RT95.2 UT2.C1
I2C1_SCK_TS: CC99.1 R421.1 RC50.2 UCPU1.U9
I2C1_SDA_TS: CC98.1 R420.1 RC48.2 UCPU1.U8
I2C2_CLK_PD1: RT39.2 RT43.2 UT1.B5
I2C2_CLK_PD2: RT63.2 RT64.2 UT2.B5
I2C2_DAT_PD1: RT40.2 RT44.2 UT1.A5
I2C2_DAT_PD2: RT66.2 RT67.2 UT2.A5
I2C2_INT#_PD1: RT38.2 RT42.2 UT1.B6
I2C2_INT#_PD2: RT61.2 RT62.2 UT2.B6
I_ADP: CE15.1 PC350.1 PR328.2 RE124.2 UE3.B11
I_BATT: CE19.1 RE124.1 UE3.J4
I_SYS: CE13.1 RE125.1 UE3.J5
ILEDA: R99.1 U12.B2
ILEDB: R96.1 R447.1 U12.B3
ILMT_1.0VA: PR707.2 PR708.2 PU700.13
IMVP_SMBCLK: PR922.1 RE270.1 UE3.B3
IMVP_SMBDAT: PR923.1 RE269.1 UE3.E5
IMVP_U42_U22#_LED: Q356.2 UE3.A12
IMVP_VR_ON: RE10.2 RE247.2 U15.2 UE3.N7
IMVP_VR_ON_P: PR916.1 RE10.1 RE29.1 U15.4 UE7.2
INTRUDER#: RC88.1 UCPU1.AP16
INV_PWM: D40.1 MC1.1 PR411.1 R67.1
ISH_I2C0_SCL: LGA1.13 RS15.1 RS19.1 UCPU1.N3
ISH_I2C0_SDA: LGA1.14 RS16.1 RS18.1 UCPU1.M4
ITP_PMODE: JXDP1.46 RC10.1 UCPU1.E8
JACK_PLUG#: CA40.1 RA13.2 RA14.2 UA1.1
JTAG_CLK: JDEG3.4 RE6.2 UE3.C8
JTAG_RST#: CE24.1 RE41.1 RE42.2 UE3.G13
JTAG_TDI: JDEG3.2 RE8.2 UE3.E9
JTAG_TDO: JDEG3.5 RE5.2 UE3.F6
JTAG_TMS: JDEG3.3 RE7.2 UE3.C5
JUSBC1_GND: CT2.1 JUSBC1.1 JUSBC1.2 JUSBC1.3 JUSBC1.4 LT1.1
JUSBC2_GND: CT3.1 JUSBC2.1 JUSBC2.2 JUSBC2.3 JUSBC2.4 LT2.1
K52: R280.1 UCPU1.K52
KICKSTD_SW_DET#: D109.1 R488.2 RE118.2 RE119.1 SW5.1 SW5.2
KICKSTD_SW_DET#_PCH: D109.2 RC391.1 UCPU1.AW7
KICKSTD_SW_DET#_R: RE119.2 UE3.L11
LAN_WAKE#: RC143.2 UCPU1.AM15 UE3.L3
LCD_POWER_20V: PC110.1 PC112.1 PQ102.1 PQ102.2 PQ102.3 PQ103.1 PQ103.2 PQ103.3 PQ138.3 PR104.1 PR105.1 PR251.1 R501.1
LCD_TST: JEDP1.36 RE51.2 UE3.M2
LCD_VCC_TEST_EN: D60.3 UE3.E1
LDO_1.0VA: PC712.1 PU700.16 PU700.17
LDO_IN: PC128.1 PD103.1 PD106.1 PR108.1 PR149.1 PU101.1
LED_IFB1: JEDP1.23 PC408.1 PU400.7
LED_IFB2: JEDP1.24 PC409.1 PU400.8
LED_IFB3: JEDP1.25 PC410.1 PU400.9
LED_IFB4: JEDP1.26 PC412.1 PU400.10
LED_IFB5: JEDP1.27 PC413.1 PU400.12
LED_IFB6: JEDP1.28 PC414.1 PU400.13
LED_IFB7: JEDP1.29 PR417.2
LED_IFB8: JEDP1.30 PR416.2
LED_PWM: PC416.1 PR411.2 PR413.1 PU400.1
LED_SD: PC411.1 PR407.2 PR408.1 PR409.1
LED_SOURCE: PC283.1 PR119.2 PR137.1 PR249.2 PR253.1 PR272.1 PU105.4
LED_SW: PD400.2 PL400.2 PR400.1 PU400.23 PU400.24
LID_CL_SIO#: JIO1.24 RE115.2 UE3.N11
LINE1-L: CA12.1 UA1.34
LINE1-R: CA10.1 UA1.33
LX_1.0VA: PC702.2 PL701.1 PR702.1 PU700.6 PU700.19 PU700.20
LX_PRIM: PL803.1 PR819.1 PU801.2 PU801.3
LX_VCCIO: PL801.1 PR806.1 PU800.2 PU800.3
M2280_PCIE_SATA#: R66.1 RC41.2 RC195.1 UCPU1.H2
M3042_PCIE#_SATA: UCPU1.G4 UE3.J12
ME_FWP: Q25.5 R5774.1 RE54.1 RE61.2 UE3.G12
ME_RESET#: RC96.1 RC97.2 UC3.2
ME_SUS_PWR_ACK: RC162.2 UCPU1.AR13 UE3.B13
MEC_XTAL1: CE12.1 UE3.A1 Y2.1
MEC_XTAL2: CE11.1 UE3.A3 Y2.2
MEDIACARD_IRQ#: RC197.2 RC199.2 RR12.1
MEM_CONFIG0: RH17.1 RH18.2 UCPU1.AP2
MEM_CONFIG1: RH15.1 RH16.2 UCPU1.AP1
MEM_CONFIG2: RH12.1 RH13.2 UCPU1.AP3
MEM_CONFIG3: RH9.1 RH10.2 UCPU1.AN3
MIC2-VREFO-L: RA2.1 UA1.27
MIC2-VREFO-R: RA1.1 UA1.28
MONO_IN: CA14.2 UA1.32
MSCLK: JDEG3.6 RE4.2 UE3.H10
MSDATA: JDEG3.7 RE2.2 RE3.2 UE3.G9
MUX1_ADDR: RV5.1 RV6.1 UV1.3
MUX1_CEXT: CV61.1 RV19.1 RV61.2 UV1.1
MUX1_CSCL: QC2.1 RV57.2 RV65.1 RV91.1 UV1.21
MUX1_CSDA: QC2.4 RV58.2 RV66.1 RV92.1 UV1.22
MUX1_I2C_EN: RV12.1 RV13.1 UV1.29
MUX1_REXT: RV7.1 RV75.1 RV76.2 UV1.2
MUX1_TUSB_DPEQ0: RV77.1 RV78.2 UV1.14
MUX1_TUSB_SSEQ0: RV79.1 RV80.2 UV1.11
MUX2_ADDR: RV31.1 RV32.1 UV2.3
MUX2_CEXT: CV62.1 RV43.1 RV62.2 UV2.1
MUX2_CSCL: QC3.1 RV59.2 RV69.1 RV93.1 UV2.21
MUX2_CSDA: QC3.4 RV60.2 RV70.1 RV94.1 UV2.22
MUX2_I2C_EN: RV40.1 RV41.1 UV2.29
MUX2_REXT: RV30.1 RV81.1 RV82.2 UV2.2
MUX2_TUSB_DPEQ0: RV83.1 RV84.2 UV2.14
MUX2_TUSB_SSEQ0: RV85.1 RV86.2 UV2.11
NB_MUTE#: Q22.1 UE3.A4
NFC_DET#: RC68.2 UCPU1.BA5
NGFF_COEX1: JNGFF3.48 R494.2
NGFF_COEX2: JNGFF3.46 R493.2
NGFF_COEX3: JNGFF3.44 R492.2
NGFF_CONFIG_0: JNGFF1.21 RE56.2 UE3.N9
NGFF_CONFIG_1: JNGFF1.69 RE53.2 U4.9 UE3.M10
NGFF_CONFIG_2: JNGFF1.75 RE63.2 UE3.N10
NGFF_CONFIG_3: JNGFF1.1 RE40.2 UE3.F4
NGFF_WWAN_PWREN: D61.3 UCPU1.J5
NRB_BIT: RC63.2 UCPU1.AR7
OSC_IN: C71.1 R104.1 U12.B1 Y1.1
OSC_OUT: C67.1 R104.2 U12.A1 Y1.3
OTG_ID: RC62.1 RH90.1 UCPU1.AG3
P_SENSOR_ACT#: RS5.2 T3.1(TP-1) U1.A2 UE3.N6
P_SYS_R: PR329.2 PR333.1 PR949.1 RE125.2
PANEL_BKEN_EC: D39.3 UE3.J9
PANEL_BKLEN: D39.2 UCPU1.R12
PBAT_SMBCLK: PD104.2 PR152.2 RE38.1 UE3.N2
PBAT_SMBDAT: PD104.3 PR154.2 RE35.1 UE3.M3
PCH_3.3V_TS_EN: R209.1 R5764.1 RC396.2 UCPU1.AP5
PCH_AUD_PWR_EN: RE120.1 UCPU1.W8
PCH_DDI1_AUXN: CT37.1 CV59.1 UCPU1.G50
PCH_DDI1_AUXN_C: CV59.2 RV45.2 UV2.25
PCH_DDI1_AUXP: CT36.1 CV58.1 UCPU1.F50
PCH_DDI1_AUXP_C: CV58.2 RV44.2 UV2.24
PCH_DDI2_AUXN: CT35.1 CV64.1 UCPU1.E48
PCH_DDI2_AUXP: CT34.1 CV63.1 UCPU1.F48
PCH_DDI2_N0: CV25.1 UCPU1.C50
PCH_DDI2_N1: CV28.1 UCPU1.C52
PCH_DDI2_N2: CV32.1 UCPU1.A50
PCH_DDI2_N3: CV35.1 UCPU1.D51
PCH_DDI2_P0: CV24.1 UCPU1.D50
PCH_DDI2_P1: CV26.1 UCPU1.D52
PCH_DDI2_P2: CV30.1 UCPU1.B50
PCH_DDI2_P3: CV34.1 UCPU1.C51
PCH_DP1_HPD_UT2: RT51.1 UT2.C10
PCH_DP1_HPD_UV2: RV39.2 UV2.32
PCH_DP2_HPD_UT1: RT34.1 UT1.C10
PCH_DPWROK: RE248.2 UE3.F8
PCH_DPWROK_P: CC16.1 RC78.1 RC80.1 RE248.1 UCPU1.BB20
PCH_ENVDD: D60.2 UCPU1.U13
PCH_JTAG_TCLK: JXDP1.55 RC17.2 UCPU1.B56
PCH_PCIE_WAKE#: RC90.2 RE55.1 UCPU1.BB15 UE3.L1
PCH_PLTRST#: RC150.2 RC154.2 UC4.1 UC4.2 UCPU1.AN10
PCH_PLTRST#_EC: RE183.1 UE3.K1 UE5.4
PCH_POPIRCOMP: RC167.1 UCPU1.AU16
PCH_PWR_EN: R146.2 R148.1 UE3.M8
PCH_PWR_EN_R: R147.2 R148.2 U21.3
PCH_PWROK: PR932.1 RC397.2 UCPU1.BA20
PCH_RSMRST#: RE245.2 UE3.M5
PCH_RSMRST#_R: RC78.2 RC131.1 RC189.2 RE245.1 UCPU1.AY17
PCH_RTCX1: CC23.1 RC86.2 UCPU1.AM18 YC2.1
PCH_RTCX2: RC86.1 RC87.1 UCPU1.AM20
PCH_RTCX2_R: CC24.1 RC87.2 YC2.2
PCH_SMB_ALERT#: RC49.1 UCPU1.R10
PCH_SPI_CLK: JSPI2.4 RP2.6 RP2.7 UCPU1.AV2
PCH_SPI_CLK_TPM: C226.1 RP2.3 U4246.19
PCH_SPI_CS0#: JSPI2.5 UCPU1.AU3 UH1.1
PCH_SPI_CS1#: JSPI2.1 UCPU1.AU2
PCH_SPI_CS2#: U4246.20 UCPU1.AU1
PCH_SPI_DO2_XDP: RC69.1 RC187.1
PCH_SPI_DO_XDP: RC67.1 RC100.1 RC107.2
PCH_SPI_IO2: JSPI2.6 RC69.2 RH19.2 RP3.6 UCPU1.AW2
PCH_SPI_IO3: JSPI2.7 RH20.2 RH21.2 RP3.5 UCPU1.AU4
PCH_SPI_SI: JSPI2.2 RC67.2 RP2.5 RP2.8 UCPU1.AV3
PCH_SPI_SI_TPM: RP2.4 U4246.21
PCH_SPI_SO: JSPI2.3 RP3.7 RP3.8 UCPU1.AW3
PCH_SPI_SO_TPM: RP3.1 U4246.24
PCI_CLK_LPC0: RC71.1 UCPU1.AW9
PCI_CLK_LPC1: RC70.1 UCPU1.AY9
PCIE_PRX_CARDTX_N9: CR12.1 UCPU1.E22
PCIE_PRX_CARDTX_N9_C: CR12.2 UR1.8
PCIE_PRX_CARDTX_P9: CR14.1 UCPU1.E23
PCIE_PRX_CARDTX_P9_C: CR14.2 UR1.7
PCIE_PRX_SSDTX_N7: JNGFF2.29 UCPU1.F20
PCIE_PRX_SSDTX_P7: JNGFF2.31 UCPU1.E20
PCIE_PRX_WLANTX_N5: JNGFF3.43 UCPU1.F16
PCIE_PRX_WLANTX_P5: JNGFF3.41 UCPU1.E16
PCIE_PRX_WTX_UR_N12_SW: ML2.1 U4.8
PCIE_PRX_WTX_UR_N12_SW_CONN: JNGFF1.29 ML2.2
PCIE_PRX_WTX_UR_P12_SW: ML2.4 U4.7
PCIE_PRX_WTX_UR_P12_SW_CONN: JNGFF1.31 ML2.3
PCIE_PRX_WWANTX_N11: JNGFF1.41 UCPU1.E28
PCIE_PRX_WWANTX_N12: U4.12 UCPU1.E30
PCIE_PRX_WWANTX_P11: JNGFF1.43 UCPU1.E27
PCIE_PRX_WWANTX_P12: U4.13 UCPU1.F30
PCIE_PTX_CARDRX_N9: CR23.1 UCPU1.B23
PCIE_PTX_CARDRX_N9_C: CR23.2 UR1.4
PCIE_PTX_CARDRX_P9: CR22.1 UCPU1.A23
PCIE_PTX_CARDRX_P9_C: CR22.2 UR1.3
PCIE_PTX_SSDRX_N7: CD42.1 UCPU1.B21
PCIE_PTX_SSDRX_N7_C: CD42.2 JNGFF2.35
PCIE_PTX_SSDRX_P7: CD43.1 UCPU1.A21
PCIE_PTX_SSDRX_P7_C: CD43.2 JNGFF2.37
PCIE_PTX_WLANRX_N5: CV10.1 UCPU1.C19
PCIE_PTX_WLANRX_N5_C: CV10.2 JNGFF3.37
PCIE_PTX_WLANRX_P5: CV9.1 UCPU1.D19
PCIE_PTX_WLANRX_P5_C: CV9.2 JNGFF3.35
PCIE_PTX_WRX_UT_N12_SW: ML1.1 U4.4
PCIE_PTX_WRX_UT_N12_SW_CONN: JNGFF1.35 ML1.2
PCIE_PTX_WRX_UT_P12_SW: ML1.4 U4.3
PCIE_PTX_WRX_UT_P12_SW_CONN: JNGFF1.37 ML1.3
PCIE_PTX_WWANRX_N11: CV2.1 UCPU1.D24
PCIE_PTX_WWANRX_N11_C: CV2.2 JNGFF1.47
PCIE_PTX_WWANRX_N12: C30.1 UCPU1.A25
PCIE_PTX_WWANRX_N12_C: C30.2 U4.14
PCIE_PTX_WWANRX_P11: CV1.1 UCPU1.C24
PCIE_PTX_WWANRX_P11_C: CV1.2 JNGFF1.49
PCIE_PTX_WWANRX_P12: C31.1 UCPU1.B25
PCIE_PTX_WWANRX_P12_C: C31.2 U4.15
PCIE_RCOMPN: RC113.1 UCPU1.F5
PCIE_RCOMPP: RC113.2 UCPU1.E5
PCIE_WAKE#: JNGFF1.54 JNGFF3.55 JNGFF3.70 R57.2 RE67.1 UE3.N13
PD1_AUX_N: CT35.2 RT13.2 RT119.2 UT1.J2
PD1_AUX_P: CT34.2 RT14.2 RT120.2 UT1.J1
PD1_CC1: CT8.1 RT113.1 UT1.K9 UT1.L9
PD1_CC2: CT7.1 RT114.1 UT1.K10 UT1.L10
PD1_DEBUG1: RT5.2 RT6.2 UT1.L2
PD1_DEBUG2: RT7.2 RT8.2 UT1.K2
PD1_DEBUG3: RT3.2 UT1.L3
PD1_DEBUG4: RT4.2 RT125.2 UT1.K3
PD1_DEBUG_CTL1: RT35.2 UT1.E4
PD1_DEBUG_CTL2: RT36.2 UT1.D5
PD1_GPIO0: RT45.1 UT1.B2
PD1_GPIO1: RT46.1 RT99.1 UT1.C2
PD1_GPIO2: RT28.1 RT100.1 UT1.D10
PD1_GPIO3: RT20.1 UT1.G11
PD1_GPIO5: RT27.1 RT31.1 UT1.E10
PD1_GPIO6: RT17.1 UT1.G10
PD1_GPIO7: RT97.1 UT1.D7
PD1_GPIO8: RT11.1 UT1.H6
PD1_GPIO8_EXT: RT11.2 RT103.2 RT104.1 TC19.1(TP-1)
PD1_HWRST: R470.1 RT110.1 UT1.D6
PD1_LPS1: PQ134.6 PR214.2 PR216.2
PD1_LPS2: PQ100.5 PQ101.5 PR111.1
PD1_LSRX: TC7.1(TP-1) UT1.K4
PD1_LSTX: RT2.2 UT1.L4
PD1_OTG_ID: RC62.2 RT31.2
PD1_SBU1: RT117.1 UT1.K8
PD1_SBU2: RT118.1 UT1.L8
PD1_USBC_AMSEL: RT3.1 UV1.23
PD1_USBC_EN: RT4.1 RV66.2 RV88.2
PD1_USBC_POL: RT45.2 RV65.2 RV87.2
PD1_VBUS_SENSE: RC61.2 RT27.2
PD2_AUX_N: CT37.2 RT91.2 RT123.2 UT2.J2
PD2_AUX_P: CT36.2 RT82.2 RT124.2 UT2.J1
PD2_CC1: CT26.1 RT115.1 UT2.K9 UT2.L9
PD2_CC2: CT25.1 RT116.1 UT2.K10 UT2.L10
PD2_DEBUG1: RT80.2 RT81.2 UT2.L2
PD2_DEBUG2: RT89.2 RT90.2 UT2.K2
PD2_DEBUG3: RT77.2 UT2.L3
PD2_DEBUG4: RT78.2 RT126.2 UT2.K3
PD2_DEBUG_CTL1: RT83.2 UT2.E4
PD2_DEBUG_CTL2: RT79.2 UT2.D5
PD2_EE_CLK: RT73.2 UT2.A3
PD2_EE_CS#: RT72.2 UT2.B3
PD2_EE_MISO: RT69.2 UT2.A4
PD2_EE_MOSI: RT70.2 UT2.B4
PD2_GPIO0: RT76.1 UT2.B2
PD2_GPIO1: RT75.1 RT101.1 UT2.C2
PD2_GPIO2: RT57.1 RT102.1 UT2.D10
PD2_GPIO3: RT59.1 UT2.G11
PD2_GPIO5: RT52.1 UT2.E10
PD2_GPIO6: RT60.1 UT2.G10
PD2_GPIO7: RT98.1 UT2.D7
PD2_GPIO8: RT65.1 UT2.H6
PD2_GPIO8_EXT: RT65.2 RT105.2 RT106.1 TC22.1(TP-1)
PD2_HWRST: R471.1 RT112.1 UT2.D6
PD2_LPS1: PQ136.6 PR221.2 PR225.2
PD2_LPS2: PQ113.5 PQ114.5 PR113.1
PD2_LSRX: TC13.1(TP-1) UT2.K4
PD2_LSTX: RT74.2 UT2.L4
PD2_SBU1: RT121.1 UT2.K8
PD2_SBU2: RT122.1 UT2.L8
PD2_USBC_AMSEL: RT77.1 RV50.1 RV53.1 UV2.23
PD2_USBC_EN: RT78.1 RV70.2 RV89.2
PD2_USBC_POL: RT76.2 RV69.2 RV90.2
PD_EE_CLK: TC4.1(TP-1) U22.6 UT1.A3
PD_EE_CS#: RT47.2 TC10.1(TP-1) U22.1 UT1.B3
PD_EE_MISO: RT48.2 TC11.1(TP-1) U22.2 UT1.A4
PD_EE_MOSI: TC5.1(TP-1) U22.5 UT1.B4
PD_EE_WP#: RT49.2 U22.3
PD_HOLD#: RT10.2 U22.7
PECI_EC_R: RE49.1 UE3.K13
PEWAKE#: JNGFF2.54 R57.1 R64.1
PLL_COMP1: C56.1 R95.1 U12.A3
PLL_COMP2: C63.2 R100.1 U12.A4
PLL_VDD: C64.2 U12.A5
PLT_RST#: JNGFF1.50 JNGFF2.50 Q16.2 R418.1 RC150.1 RC152.1 RE193.1 U12.H2 U23.1 U4246.17 UC4.4 UE5.2 UR1.1
PME#: T38.1(TP-1) UCPU1.AU11
POA_WAKE#: JIO1.27 RE117.2 UE3.E4
POWER_SW_IN#: CE21.1 JIO1.22 PU280.1 RE27.2 RE113.1 UE3.D5
POWER_SW_IN#_R: RE113.2 SW3.1 SW3.3
PRIM_CORE_OPT_DIS: RC12.1 U4252.1 UCPU1.B9
PROCHOT#: Q12.2 UE3.H13
PS_SMBCLK: Q1.1 RS3.2 T1.1(TP-1) U1.B1
PS_SMBDAT: Q1.4 RS4.2 T4.1(TP-1) U1.A1
PWM_CORE1: PU900.43 PU1005.9
PWM_CORE2: PU900.42 PU1006.9
PWM_FAN1: C1120.1 JFAN1.3 R27.1 UE3.L10
PWM_GT: PU900.39 PU1107.9
PWM_SA: PU900.38 PU1108.7
REM_DIODE1_N: CE2.2 CE26.1 CE27.1 Q6.1 Q6.2 Q11.3 UE3.A8
REM_DIODE1_P: CE2.1 CE26.2 CE27.2 Q6.3 Q11.1 Q11.2 UE3.A7
REM_DIODE2_N: CE3.2 CE4.1 CE29.1 Q7.3 Q8.1 Q8.2 UE3.A10
REM_DIODE2_P: CE3.1 CE4.2 CE29.2 Q7.1 Q7.2 Q8.3 UE3.A9
REM_DIODE3_N: CE1.2 CE28.1 JIO1.16 Q2.3 UE3.B9
REM_DIODE3_P: CE1.1 CE28.2 JIO1.18 Q2.1 Q2.2 UE3.B8
RESET_IN#: RE250.2 UE3.C1
RESET_OUT#_R: CC26.1 JXDP1.47 RC99.2 RC100.2
RING2: L15.1 RA2.2 UA1.29
RING2_CONN: CA8.1 DA3.1 JP1.3 L15.2
RREF: RR1.2 UR1.9
RTC_RST#: CC25.2 CLRP1.2 CMOS1.2 JAPS1.10 RC89.2 RE12.1 UCPU1.AM16
RTCRST_ON: Q10.2 R5779.2 RE16.1 UE3.F11
RTCRST_ON_R: C1132.1 D116.2 Q348.2 R5769.1
RUN_ON: RE17.2 RE100.1 RE114.1 UE3.E8
RUN_ON#: QE14.2 QE14.3 RE174.1
RUN_ON_EC: PR608.1 RE13.2 RE99.2 RE100.2 UC5.2
RUN_ON_P: PR728.1 PR826.1 QE14.5 R31.2 R117.2 R149.1 R5780.2 RE13.1 RE14.1 U2.3 U13.5 U4255.3 UC2.2 UC5.4
RUNPWROK: QE14.6 RE168.1 UE3.G3
SAR_DPR#: D111.1 UE3.M4
SAR_DPR_R: D111.2 JNGFF1.25 R33.2
SATA_PRX_SSDTX_N8: JNGFF2.43 UCPU1.G21
SATA_PRX_SSDTX_P8: JNGFF2.41 UCPU1.F21
SATA_PTX_SSDRX_N8: CD44.1 UCPU1.D21
SATA_PTX_SSDRX_N8_C: CD44.2 JNGFF2.47
SATA_PTX_SSDRX_P8: CD45.1 UCPU1.C21
SATA_PTX_SSDRX_P8_C: CD45.2 JNGFF2.49
SD_CD#: JCR1.9 UR1.30
SD_CLK: CR13.1 JCR1.5 RR4.2
SD_CLK_L: RR4.1 UR1.17
SD_CMD: CR16.1 JCR1.3 RR6.2
SD_CMD_L: RR6.1 UR1.19
SD_D2: CR18.1 JCR1.1 RR9.2
SD_D2_L: RR9.1 UR1.21
SD_D3: CR17.1 JCR1.2 RR8.2
SD_D3_L: RR8.1 UR1.20
SD_LN0_M: JCR1.17 UR1.25
SD_LN0_P: JCR1.16 UR1.26
SD_LN1_M: JCR1.19 UR1.23
SD_LN1_P: JCR1.20 UR1.22
SD_PWR_EN: R210.1 R211.1 UCPU1.BA9 UZ4.5
SD_RCLK_M: CR10.1 JCR1.8 RR2.2
SD_RCLK_M_L: RR2.1 UR1.15
SD_RCLK_P: CR11.1 JCR1.7 RR3.2
SD_RCLK_P_L: RR3.1 UR1.16
SD_RCOMP: RC140.1 UCPU1.AB7
SD_REG2: CR19.2 UR1.24
SHD_CLK: T57.1(TP-1) UE3.J8
SHD_IO2: RE252.1 UE3.L7
SIO_EXT_SCI#: RC149.2 RC399.2 UCPU1.AN7
SIO_EXT_SMI#: RC8.2 UCPU1.A6
SIO_EXT_WAKE#: RC59.2 UCPU1.J2 UE3.M12
SIO_PWRBTN#: CC36.1 JAPS1.8 JXDP1.41 RC127.2 UCPU1.BA15 UE3.K11
SIO_RCIN#: RC73.2 UCPU1.AW13
SIO_SLP_A#: JAPS1.13 UCPU1.AN16 UE3.M11
SIO_SLP_S0#: JAPS1.4 PR801.1 PR921.1 R450.1 R460.1 U4252.2 UC2.1 UCPU1.AT11
SIO_SLP_S3#: JAPS1.17 QE15.2 RE99.1 U15.1 UC5.1 UCPU1.AP15 UE3.K9
SIO_SLP_S4#: JAPS1.14 RE97.1 UC7.1 UCPU1.BA16 UE3.N12
SIO_SLP_S5#: JAPS1.15 UCPU1.AY16 UE3.N8
SIO_SLP_SUS#: PR700.1 PR721.1 PR815.1 QE13.2 R147.1 RE265.1 UC8.1 UCPU1.AN15
SIO_SLP_WLAN#: Q357.1 UCPU1.BB17
SKYCAM_I2C_CLK: CC11.1 R478.1 RH25.1 UCPU1.AH10
SKYCAM_I2C_DATA: CC13.1 R477.1 RH26.1 UCPU1.AH9
SLEEVE: L12.1 RA1.2 UA1.30
SLEEVE_CONN: CA7.1 DA1.1 JP1.4 L12.2
SLP_WLAN#_GATE: Q357.2 R5773.2 UE3.K10
SM_PG_CTRL: PR605.1 R32.2 UC1.4
SM_RCOMP0: RC164.1 UCPU1.AR18
SM_RCOMP1: RC166.1 UCPU1.AT18
SM_RCOMP2: RC165.1 UCPU1.AU18
SML1_SMBCLK: RC55.1 UCPU1.W3 UE3.D8
SML1_SMBDAT: RC51.1 UCPU1.V3 UE3.E11
SNUB_CHG1: PC342.1 PR316.2
SNUB_CHG2: PC343.1 PR317.2
SP7_SDWP: QR1.1 UR1.29
SPI_CLK_VROM1: RC169.2 RP2.2 UH1.6
SPI_IO2_VROM1: RP3.3 UH1.3
SPI_IO3_VROM1: RP3.4 UH1.7
SPI_SI_VROM1: RP2.1 UH1.5
SPI_SO_VROM1: RP3.2 UH1.2
SPK_-OUT-L+: LA8.1 UA1.42
SPK_-OUT-L-: LA7.1 UA1.43
SPK_-OUT-R+: LA6.1 UA1.45
SPK_-OUT-R-: LA5.1 UA1.44
SPK_ID: RA38.2 RA39.2 UCPU1.AB13
SPK_L+: CA45.1 DA9.2 JSPK.1 LA8.2
SPK_L-: CA44.1 DA9.3 JSPK.2 LA7.2
SPK_R+: CA43.1 DA8.2 JSPK.3 LA6.2
SPK_R-: CA42.1 DA8.3 JSPK.4 LA5.2
SPKR: RA9.1 RC158.2 UCPU1.AW5
SRTCRST#: CC22.1 RC85.2 UCPU1.AN18
SS_1.8VA: PC726.1 PU720.9
SS_1.8VU: PC734.1 PU721.9
SS_PRIM: PC819.1 PU801.7
SS_VCCIO: PC809.1 PU800.7
SSD_DEVSLP: JNGFF2.38 T32.1(TP-1) UCPU1.J1
SSD_PEDET: JNGFF2.69 R66.2
SSD_PWR_EN: R150.1 R151.2 UCPU1.W12
STROBE_IN: R108.2 U12.D2
SUS_ON_EC: JIO1.25 PR611.1 RE36.2 RE97.2 RE98.2 U4245.1 UC7.2
SUS_ON_EC_R: RE98.1 RE112.1 UE3.D2
SUS_ON_P: PR720.1 PR727.1 RE36.1 RE44.1 UC7.4 UC8.2
SUSACK#: UCPU1.AP11 UE3.K12
SUSCLK: C32.1 R65.2 R124.2 R161.2 RC74.1 UCPU1.BA17
SUSCLK_L: C107.1 JNGFF1.68 R124.1
SW_1.8VA: PL721.1 PR723.1 PU720.1 PU720.2 PU720.3
SW_1.8VU: PL723.1 PR730.1 PU721.1 PU721.2 PU721.3
SW_DP2_HPD_UV1: RV11.2 UV1.32
SX9306_CS0: LS1.2 T2.1(TP-1) U1.A3
SYNC: PU900.34 PU1005.10 PU1006.10 PU1107.10 PU1108.8
SYS_PRES#: JT100.5 PR285.1 PU280.5
SYS_PWROK: RC99.1 RE157.1 UCPU1.B6 UE3.G4
SYS_RESET#: JAPS1.6 RC36.2 RC38.2 UCPU1.B5
SYS_RESET#_R: RC34.2 RC36.1 UC3.4
SYSPWR_PRES: RE152.1 RE154.1 UE3.B1
TACH_FAN1: D22.2 R28.1 UE3.E3
TBAT_3V3: JT100.6 PR157.1
TCLK_XDP: JXDP1.57 RC3.1 RC102.2 UCPU1.A59 UCPU1.B61
TDI_XDP: JXDP1.56 RC2.2 UCPU1.D59 UCPU1.D60
TDO_XDP: JXDP1.52 RC19.2 UCPU1.A56 UCPU1.A61
THERMATRIP1#: RE246.1 UE3.B12
THERMATRIP2#: CE86.1 QE16.1 RE215.2 UE3.H3
TMS_XDP: JXDP1.58 RC18.2 UCPU1.C59 UCPU1.C60
TOUCH_SCREEN_PD#: R419.1 RC9.2 UCPU1.A7
TOUCH_SCREEN_PD#_R: JEDP1.6 R419.2
TPM_DET: RH11.2 RH14.1 UCPU1.H5
TPM_LPM: R460.2 U4246.3
TPM_PIRQ#: R439.2 R5777.2 RC196.1 RC198.1 RC398.1 RC399.1 U4246.18
TPM_PIRQ#_R: RC398.2 UCPU1.AP8
TRST#_XDP: JXDP1.54 RC106.2 UCPU1.B59 UCPU1.C61
TS_ID0: D112.2 RC192.1 UCPU1.BB7
TS_ID0_D: Q351.3 R432.1 RC393.2
TS_ID0_M: D112.1 Q351.1
TS_ID0_R: JEDP1.1 R432.2
TS_RST#: R495.1 RC205.1 UCPU1.U7
TS_RST#R: DI1.2 JEDP1.7 R418.2 R495.2
TUSB1_USB_EQ0: RV20.1 RV27.1 RV67.2
TUSB1_USB_EQ1: RV21.1 RV28.1 RV68.2
TUSB2_USB_EQ0: RV34.1 RV35.1 RV90.1 UV2.38
TUSB2_USB_EQ1: RV37.1 RV38.1 RV89.1 UV2.35
TYPEC_ID: CE87.1 RE264.1 UE3.F2
UART2_CTS#: JUART.4 RC191.2 UCPU1.AD4
UART2_RTS#: JUART.1 RC190.2 RC196.2 UCPU1.AD3
UART2_RXD: JUART.3 RH4.2 UCPU1.AD1
UART2_TXD: JUART.2 RH3.2 UCPU1.AD2
UART_MISO: RT15.2 UT1.F2 UT2.E2
UART_MOSI: RT18.2 UT1.E2 UT2.F2
UF_HCLK: C50.1 JUFC1.11 L21.1
UF_HCLK_R: C58.1 L21.2 U12.C5
UF_I2C_CLK: CC8.1 D1.1 JUFC1.19 RH1.1 UCPU1.AF12
UF_I2C_DATA: CC7.1 D3.1 JUFC1.17 RH2.1 UCPU1.AF11
UF_SENSOR_RST#: D5.1 JUFC1.15 R3.2 R5.2 R101.1
UF_SENSOR_RST#_R: R101.2 U12.C6
UFCAM_CSI2_CLKN0: R6.1 UCPU1.C37
UFCAM_CSI2_CLKN0_L: D6.1 JUFC1.12 R6.2
UFCAM_CSI2_CLKP0: R4.1 UCPU1.D37
UFCAM_CSI2_CLKP0_L: D7.1 JUFC1.10 R4.2
UFCAM_CSI2_DN0: R1.1 UCPU1.A36
UFCAM_CSI2_DN0_L: D2.1 JUFC1.18 R1.2
UFCAM_CSI2_DN1: R8.1 UCPU1.C38
UFCAM_CSI2_DN1_L: D8.1 JUFC1.6 R8.2
UFCAM_CSI2_DP0: R2.1 UCPU1.B36
UFCAM_CSI2_DP0_L: D4.1 JUFC1.16 R2.2
UFCAM_CSI2_DP1: R7.1 UCPU1.D38
UFCAM_CSI2_DP1_L: D9.1 JUFC1.4 R7.2
UFCAM_LED#: Q9.3 R487.1
UIM_CLK: C136.1 C137.2 D64.2 JNGFF1.32 JSIM1.3
UIM_DATA: C134.1 C135.2 D63.2 JNGFF1.34 JSIM1.6 R154.2
UIM_DET: C133.1 D62.2 JSIM1.8 R122.2
UIM_DET#: JNGFF1.66 R122.1
UIM_RESET: C138.1 D65.2 JNGFF1.30 JSIM1.2
UPD1_HPD: R475.2 RE258.1 UE3.K7
UPD1_HPD_R: D105.2 R475.1
UPD1_PS_SMBCLK: Q1.6 QC2.6 RE32.1 RT5.1 RT39.1 RV91.2 UE3.C3
UPD1_PS_SMBDAT: Q1.3 QC2.3 RE30.1 RT8.1 RT40.1 RV92.2 UE3.B4
UPD1_SMBINT#: RE20.1 RT38.1 UE3.F10
UPD2_HPD: R476.2 RE259.1 UE3.M1
UPD2_HPD_R: D106.2 R476.1
UPD2_SMBINT#: RE52.1 RT61.1 UE3.F5
UPD2_USH_SMBCLK: C221.1 JIO1.35 QC3.6 RE70.1 RT63.1 RT80.1 RV93.2 UE3.D7
UPD2_USH_SMBDAT: C220.1 JIO1.37 QC3.3 RE68.1 RT66.1 RT89.1 RV94.2 UE3.E7
USB3RN1: CV23.1 UCPU1.H8
USB3RN1_C: CV23.2 UV1.4
USB3RN2: U4.16 UCPU1.J6
USB3RN3: ML4.4 UCPU1.J10
USB3RN3_CONN: JUSB1.5 MD1.1 ML4.3
USB3RN4: CV44.1 UCPU1.E10
USB3RN4_C: CV44.2 UV2.4
USB3RP1: CV22.1 UCPU1.G8
USB3RP1_C: CV22.2 UV1.5
USB3RP2: U4.17 UCPU1.H6
USB3RP3: ML4.1 UCPU1.H10
USB3RP3_CONN: JUSB1.6 MD1.2 ML4.2
USB3RP4: CV43.1 UCPU1.F10
USB3RP4_C: CV43.2 UV2.5
USB3TN1: CV21.1 UCPU1.C13
USB3TN1_C: CV21.2 UV1.7
USB3TN2: C215.1 UCPU1.B13
USB3TN2_C: C215.2 U4.18
USB3TN3: C110.1 UCPU1.B15
USB3TN3_C: C110.2 ML5.4
USB3TN3_CONN: JUSB1.8 MD1.3 ML5.3
USB3TN4: CV41.1 UCPU1.C15
USB3TN4_C: CV41.2 UV2.7
USB3TP1: CV20.1 UCPU1.D13
USB3TP1_C: CV20.2 UV1.8
USB3TP2: C217.1 UCPU1.A13
USB3TP2_C: C217.2 U4.19
USB3TP3: C111.1 UCPU1.A15
USB3TP3_C: C111.2 ML5.1
USB3TP3_CONN: JUSB1.9 MD1.4 ML5.2
USB3TP4: CV40.1 UCPU1.D15
USB3TP4_C: CV40.2 UV2.8
USB20_N1: ML7.1 UCPU1.AB9
USB20_N1_R: ML7.2 UT1.K5
USB20_N2: JIO2.10 UCPU1.AD6
USB20_N3: ML14.1 UCPU1.AH3
USB20_N3_R: ML14.2 UT2.K5
USB20_N4: L10.4 UCPU1.AD9
USB20_N4_CONN: JNGFF1.9 L10.3
USB20_N5: ML3.4 UCPU1.AJ1
USB20_N5_CONN: JIR1.10 ML3.3
USB20_N7: ML8.1 UCPU1.AH1
USB20_N7_R: JNGFF3.5 ML8.2
USB20_N9: UCPU1.AG1 US1.2
USB20_N9_CONN: JUSB1.2 MD1.5 ML6.2
USB20_N9_PS: ML6.1 US1.11
USB20_N10: JIO1.30 UCPU1.AH7
USB20_P1: ML7.4 UCPU1.AB10
USB20_P1_R: ML7.3 UT1.L5
USB20_P2: JIO2.11 UCPU1.AD7
USB20_P3: ML14.4 UCPU1.AJ3
USB20_P3_R: ML14.3 UT2.L5
USB20_P4: L10.1 UCPU1.AD10
USB20_P4_CONN: JNGFF1.7 L10.2
USB20_P5: ML3.1 UCPU1.AJ2
USB20_P5_CONN: JIR1.9 ML3.2
USB20_P7: ML8.4 UCPU1.AH2
USB20_P7_R: JNGFF3.3 ML8.3
USB20_P9: UCPU1.AG2 US1.3
USB20_P9_CONN: JUSB1.3 MD1.6 ML6.3
USB20_P9_PS: ML6.4 US1.10
USB20_P10: JIO1.28 UCPU1.AH8
USB_DET#: JUSB1.10 R449.1 T42.1(TP-1)
USB_ILIM_SEL1: R54.2 US1.4
USB_OC0#: RC13.1 UCPU1.A9
USB_OC1#: RC11.1 UCPU1.C9
USB_OC2#: RC14.1 UCPU1.D9 US1.13
USB_POWERSHARE_EN#: UE3.J3 US1.6
USB_POWERSHARE_VBUS_EN: R51.2 UE3.J2 US1.5
USBC1_BN2_L: ML9.1 UT1.L7
USBC1_BOT_DN2: D72.2 JUSBC1.B7 ML9.2
USBC1_BOT_DP2: D73.2 JUSBC1.B6 ML9.3
USBC1_BP2_L: ML9.4 UT1.K7
USBC1_CC1: D50.1 JUSBC1.A5 RT113.2
USBC1_CC2: D77.2 JUSBC1.B5 RT114.2
USBC1_RX1N: D70.1 JUSBC1.B10 UV1.31
USBC1_RX1P: D68.1 JUSBC1.B11 UV1.30
USBC1_RX2N: D52.2 JUSBC1.A10 UV1.39
USBC1_RX2P: D53.2 JUSBC1.A11 UV1.40
USBC1_SBU1: D51.1 JUSBC1.A8 RT117.2 RV95.2
USBC1_SBU2: D69.2 JUSBC1.B8 RT118.2 RV96.2
USBC1_TN1_L: ML10.4 UT1.L6
USBC1_TOP_DN1: D75.1 JUSBC1.A7 ML10.3
USBC1_TOP_DP1: D74.1 JUSBC1.A6 ML10.2
USBC1_TP1_L: ML10.1 UT1.K6
USBC1_TX1N: CV31.2 D49.1 JUSBC1.A3
USBC1_TX1N_C: CV31.1 UV1.34
USBC1_TX1P: CV33.2 D48.1 JUSBC1.A2
USBC1_TX1P_C: CV33.1 UV1.33
USBC1_TX2N: CV29.2 D76.2 JUSBC1.B3
USBC1_TX2N_C: CV29.1 UV1.36
USBC1_TX2P: CV27.2 D78.2 JUSBC1.B2
USBC1_TX2P_C: CV27.1 UV1.37
USBC2_BN2_L: ML11.1 UT2.L7
USBC2_BOT_DN2: D83.2 JUSBC2.B7 ML11.2
USBC2_BOT_DP2: D84.2 JUSBC2.B6 ML11.3
USBC2_BP2_L: ML11.4 UT2.K7
USBC2_CC1: D54.1 JUSBC2.A5 RT115.2
USBC2_CC2: D89.2 JUSBC2.B5 RT116.2
USBC2_RX1N: D81.1 JUSBC2.B10 UV2.31
USBC2_RX1P: D80.1 JUSBC2.B11 UV2.30
USBC2_RX2N: D58.2 JUSBC2.A10 UV2.39
USBC2_RX2P: D59.2 JUSBC2.A11 UV2.40
USBC2_SBU1: D57.1 JUSBC2.A8 RT121.2 RV97.2
USBC2_SBU2: D79.2 JUSBC2.B8 RT122.2 RV98.2
USBC2_TN1_L: ML12.4 UT2.L6
USBC2_TOP_DN1: D86.1 JUSBC2.A7 ML12.3
USBC2_TOP_DP1: D85.1 JUSBC2.A6 ML12.2
USBC2_TP1_L: ML12.1 UT2.K6
USBC2_TX1N: CV54.2 D56.1 JUSBC2.A3
USBC2_TX1N_C: CV54.1 UV2.34
USBC2_TX1P: CV56.2 D55.1 JUSBC2.A2
USBC2_TX1P_C: CV56.1 UV2.33
USBC2_TX2N: CV48.2 D87.2 JUSBC2.B3
USBC2_TX2N_C: CV48.1 UV2.36
USBC2_TX2P: CV46.2 D88.2 JUSBC2.B2
USBC2_TX2P_C: CV46.1 UV2.37
USBCOMP: RC137.1 UCPU1.AB6
USH_DET: Q31.1 R474.2 UE3.C13
USH_DET#: JIO1.40 R480.2 RH7.1 UCPU1.AM2
USH_PWR_STATE#: JIO1.21 RE122.2 UE3.H2
USH_RST#: JIO1.19 RE47.1
USH_RST#_L: RE47.2 UE3.L6
UV1_SBU1: RV18.1 RV95.1 UV1.27
UV1_SBU2: RV17.1 RV96.1 UV1.26
UV2_SBU1: RV47.1 RV97.1 UV2.27
UV2_SBU2: RV46.1 RV98.1 UV2.26
VCI_IN1#: RE141.1 UE3.B5
VCI_IN2#: RE142.1 UE3.D4
VID0_PRIM_CORE: PR818.2 PR821.1 PR822.2 PU801.9
VID0_VCCIO: PR804.2 PR809.1 PU800.9
VID1_PRIM_CORE: PR817.2 PR820.1 PR823.2 PU801.8
VID1_VCCIO: PR805.2 PR808.1 PU800.8
VIDALERT_N: PR930.1 RC22.2 RC94.2
VIDSCLK: PR924.1 RC21.2 RC95.2
VIDSCLK_R: RC21.1 UCPU1.A63
VIDSOUT: PR929.1 RC23.2 RC93.2
VIDSOUT_R: RC23.1 UCPU1.D64
VOL_DOWN#: C20.1 R24.1 RE65.1 UE3.J6
VOL_UP#: C19.1 R23.1 RE64.1 UE3.D1
VOLUME_DOWN#: D21.1 R24.2 SW2.2
VOLUME_UP#: D20.1 R23.2 SW1.2
VR_LPM#: PR813.1 PR814.2 PU801.14
VR_LPM_R#: PR814.1 U4252.4
VRA_VDD18: PC901.1 PR935.2 PU900.26
VRACPU_VINSEN: PC911.1 PR942.1 PR943.2 PU900.47
VRACPU_VTEMP: PR947.1 PU1005.11 PU1006.11 PU1107.11 PU1108.9
VRALERT#: RC60.1 UCPU1.AM11
VSA_SEN+: PR951.2 RC116.2 UCPU1.H20
VSA_SEN-: PR952.2 RC115.1 UCPU1.H21
VSET_5105: CE30.1 RE58.1 UE3.C9
WF_HCLK: C49.1 JWFC1.27 L20.1
WF_HCLK_R: C57.1 L20.2 U12.D5
WF_I2C_CLK: JWFC1.25 RH27.1 U12.F6
WF_I2C_DATA: JWFC1.24 RH24.1 U12.D6
WF_SENSOR_RST#: JWFC1.29 R14.2 R15.2 R115.1
WF_SENSOR_RST#_R: R115.2 U12.E4
WF_VSYNC: C11.1 R11.2 R107.1
WFCAM_CSI2_CLKN1: R20.1 UCPU1.C32
WFCAM_CSI2_CLKN1_L: D17.1 JWFC1.8 R20.2
WFCAM_CSI2_CLKP1: R19.1 UCPU1.D32
WFCAM_CSI2_CLKP1_L: D16.1 JWFC1.9 R19.2
WFCAM_CSI2_DN4: R16.1 UCPU1.C31
WFCAM_CSI2_DN4_L: D13.1 JWFC1.5 R16.2
WFCAM_CSI2_DN5: R12.1 UCPU1.C33
WFCAM_CSI2_DN5_L: D11.1 JWFC1.2 R12.2
WFCAM_CSI2_DN6: R18.1 UCPU1.A31
WFCAM_CSI2_DN6_L: D15.1 JWFC1.11 R18.2
WFCAM_CSI2_DN7: R22.1 UCPU1.A33
WFCAM_CSI2_DN7_L: D19.1 JWFC1.14 R22.2
WFCAM_CSI2_DP4: R13.1 UCPU1.D31
WFCAM_CSI2_DP4_L: D12.1 JWFC1.6 R13.2
WFCAM_CSI2_DP5: R9.1 UCPU1.D33
WFCAM_CSI2_DP5_L: D10.1 JWFC1.3 R9.2
WFCAM_CSI2_DP6: R17.1 UCPU1.B31
WFCAM_CSI2_DP6_L: D14.1 JWFC1.12 R17.2
WFCAM_CSI2_DP7: R21.1 UCPU1.B33
WFCAM_CSI2_DP7_L: D18.1 JWFC1.15 R21.2
WFCAM_LED#: JWFC1.17 Q26.3 R434.1
WL_OFF#_R: D92.2 JNGFF3.56 R157.2 R159.1
WLAN_RST#: RH505.1 U23.2 UCPU1.N9
WLAN_RST#_Q: JNGFF3.52 JNGFF3.66 R160.1 U23.4
WLAN_WIGIG60GHZ_DIS#: D92.1 RE251.1 UE3.L13
WWAN_DEVSLP: R489.2 UCPU1.J3
WWAN_EN: D61.1 R216.2 U17.5
WWAN_OFF#: D95.1 RC202.1 UCPU1.W10
WWAN_PWR_OFF#: R125.2 UCPU1.AP4
WWAN_PWR_OFF#_R: C108.1 JNGFF1.6 R123.2 R125.1 R479.2
WWAN_RADIO_DIS#: D94.1 RE266.1 UE3.F12
WWAN_RADIO_DIS#_R: D94.2 D95.2 JNGFF1.8
WWAN_RST#: RC181.2 UCPU1.AB1
WWAN_WAKE#: R38.1 RH6.1 UE3.M13
WWAN_WAKE#_R: JNGFF1.23 R38.2
XCLK_BIASREF: RC31.1 UCPU1.E42
XDP_DBRESET#: CC95.1 JXDP1.48 RC34.1 RC120.2 UC3.1
XDP_OBS0: JXDP1.21 RC138.2
XDP_OBS0_R: RC138.1 UCPU1.C55
XDP_OBS1: JXDP1.23 RC136.2
XDP_OBS1_R: RC136.1 UCPU1.D55
XDP_OBS2_R: T9.1(TP-1) UCPU1.B54
XDP_OBS3_R: T10.1(TP-1) UCPU1.C56
XDP_PRSENT: U44.4 U4245.2
XDP_PRSENT#: JXDP1.60 RC187.2 U44.2
XDP_PRSNT_PIN1: JXDP1.1 RC141.1
XTAL24_IN: RC380.1 UCPU1.E37
XTAL24_IN_RU: RC377.2 UCPU1.E3
XTAL24_OUT: RC381.1 UCPU1.E35
XTAL24_OUT_RU: RC378.2 UCPU1.C7
N04830: PC341.1 PR318.1 PU300.3
N16784922: CA13.1 CA14.1 CA48.1 RA9.2 RA28.2 RA30.1
N17750417: RR10.2 UR1.28
N19378299: JNGFF1.63 T25.1(TP-1)
N19378306: JNGFF1.65 T24.1(TP-1)
N20151644: PR300.3 PR302.1
N20151664: PR300.2 PR301.1
N20422204: PC407.1 PR400.2
N21436900: JNGFF2.68 R65.1
N21618504: PC500.2 PL501.1 PR502.1 PU500.7
N21618541: PC511.1 PR502.2
N21619867: PC505.2 PR519.2 PU500.6
N21620615: PR500.2 PU500.12
N21622450: PR501.1 PU500.8
N21622453: PC500.1 PR501.2
N21624147: PC513.2 PL503.1 PR508.1 PU501.7
N21624438: PR506.2 PU501.12
N21624470: PC523.1 PR509.2 PU501.9
N21624512: PC513.1 PR507.2
N21624514: PR507.1 PU501.8
N21628470: PC601.1 PR602.2
N21628480: PC600.2 PL600.1 PR602.1 PU600.9
N21628542: PC602.2 PR603.2 PR604.1 PU600.13
N21628589: PC607.1 PC608.1 PC609.1 PL601.2 PU600.1
N21630461: PC614.1 PR606.2 PR610.1 PU600.3
N21632067: PC612.1 PU600.7
N21637474: PR601.1 PU600.10
N21637478: PC600.1 PR601.2
N21803574: R75.1 U8.1
N22437505: RT22.2 UT1.F1
N22440570: RT24.1 UT1.E11
N22441485: CT6.1 UT1.H7
N22441497: RT16.1 RT19.1 RT23.1 UT1.F10
N22441511: RT21.1 UT1.G2
N22442963: RT17.2 TC6.1(TP-1)
N22450757: C62.2 R100.2
N22450864: C52.1 R95.2
N22451929: R102.1 U12.B7
N22451931: R113.1 U12.H4
N22451933: R106.1 U12.D7
N22452420: R105.1 U12.C7
N22452424: R98.1 U12.A6
N22483897: C43.2 R77.1 R78.2 U9.2
N22483924: R79.1 U9.1
N23252533: JNGFF1.67 T20.1(TP-1)
N23877759: Q9.2 R92.1 R93.2 R99.2 R447.2
N23878175: Q9.5 R91.2 R92.2 R97.1
N23878217: Q9.6 R97.2
N24116145: R107.2 U12.C1
N24402677: TC8.1(TP-1) UT1.G4
N24402691: TC9.1(TP-1) UT1.F4
N25217210: PC510.1 PU500.9
N25410508: PQ280.1 PR280.2 PU280.3
N25410589: PD280.1 PR280.1 PR281.1 PR282.1 PU280.8
N25410879: PR281.2 PU280.2
N25411106: PQ280.2 PR283.2 PR284.1
N25958709: PR609.1 PU600.14
N25961009: PC280.1 PR282.2 PU280.7
N27076067: PC349.1 PR327.2
N28344853: T36.1(TP-1) UCPU1.AT13
N28375965: T6.1(TP-1) UCPU1.G46
N28375966: T5.1(TP-1) UCPU1.F46
N28424999: T23.1(TP-1) UCPU1.AW71
N28425002: T29.1(TP-1) UCPU1.AW70
N28563008: CC2.1 RC35.2 RC380.2 YC1.3
N28563023: CC1.1 RC35.1 RC381.2 YC1.1
N28769860: PR807.2 PR810.1 PU800.5
N28769975: PR811.1 PR812.1 PU800.6
N28771761: PR800.1 PR801.2 PU800.14
N28842863: CC14.1 UCPU1.AL1
N28843886: CC81.1 UCPU1.BB10
N28846534: CC53.1 L23.1 RC185.2 RC186.2
N28846574: CC64.1 L23.2 UCPU1.AJ19
N28856399: T31.1(TP-1) UCPU1.BA70
N28856402: T28.1(TP-1) UCPU1.BA68
N28857231: T27.1(TP-1) UCPU1.BB68
N28857234: T30.1(TP-1) UCPU1.BB69
N28857237: T33.1(TP-1) UCPU1.AK13
N28857240: T34.1(TP-1) UCPU1.AK12
N28861827: RC24.1 UCPU1.C64
N28891648: RC72.2 UCPU1.BB11
N28938912: CC91.2 RC169.1
N29263363: PR824.1 PR825.1 PU801.5
N29436789: PC1108.1 PR1106.2
N29436793: PC1110.2 PL1100.1 PR1106.1 PU1005.2 PU1005.3 PU1005.4
N29708559: T40.1(TP-1) UCPU1.AY4
N29708561: T41.1(TP-1) UCPU1.BB3
N29708599: T22.1(TP-1) UCPU1.AU5
N29708601: T37.1(TP-1) UCPU1.AT5
N29708639: T39.1(TP-1) UCPU1.BB5
N30248348: PR310.2 PR323.1
N30249106: PR310.3 PR324.1
N30252391: PC336.2 PR311.2
N30256954: PR341.2 PU300.24
N30258320: PC330.1 PR306.1
N30277718: PD300.1 PD301.1 PR309.1
N30656673: PC526.2 PL505.1 PR513.1 PU502.7
N30656764: PR511.2 PU502.12
N30656777: PC536.1 PR514.2 PU502.9
N30656793: PC526.1 PR512.2
N30656795: PR512.1 PU502.8
N30663743: PC417.1 PR416.1 PR419.1 PU400.15
N30664458: PC415.1 PR417.1 PR418.1 PU400.14
N30667395: PC524.1 PR508.2
N30667598: PC537.1 PR513.2
N30668208: PR415.1 PU400.17
N30669197: PR410.2 PR412.1 PU400.22
N30669308: PR404.1 PU400.6
N30669341: PR402.1 PU400.5
N30670358: PR401.2 PU400.3
N30670363: PR403.2 PU400.2
N30671219: PC402.1 PU400.4
N30672425: PR406.2 PU400.28
N30672977: PR414.1 PU400.18
N30673276: PR405.2 PU400.27
N30674980: PR409.2 PU400.25
N31973375: RZ1.2 UZ1.4
N33626933: R50.1 US1.7 US1.8
N33627020: R56.1 US1.16
N34282781: RS1.2 U1.C2
N34283012: RS2.2 U1.C1
N35110163: PC131.1 PQ126.1 PR149.2 PR153.1 PU101.4
N35110188: PC129.1 PR147.1 PU101.5
N35110226: PC125.2 PQ123.3 PQ124.3 PR148.2 PR155.2 PR231.1
N35113641: PC109.2 PQ100.4 PQ133.1 PR100.2 PR106.1
N35114956: PQ106.2 PQ141.1 PR166.1 PR259.2
N35119332: PC111.2 PQ101.4 PQ104.1 PR103.2 PR109.1
N35124847: PQ108.1 PR109.2
N35126885: PQ109.6 PR107.2
N35128375: PQ109.5 PR123.2 PR176.1
N35129437: PQ109.2 PQ109.3 PR115.2
N35130312: PQ104.2 PR101.2 PR107.1
N35131434: PC123.2 PQ113.4 PQ135.1 PR128.2 PR133.1
N35131606: PQ118.2 PQ142.1 PR172.1 PR263.2
N35132002: PC124.2 PQ114.4 PQ115.1 PR130.2 PR134.1
N35132051: PQ115.2 PR118.1 PR129.2
N35132981: PQ119.1 PR134.2
N35133273: PQ121.2 PQ121.3 PR139.2
N35133295: PQ121.6 PR118.2
N35133673: PQ121.5 PR136.2 PR177.1
N35136432: PC112.2 PQ102.4 PR104.2 PR112.1
N35140615: PC110.2 PQ103.4 PQ138.1 PR105.2 PR110.1
N35180205: PQ111.1 PR160.2 PR161.2
N35180386: PQ111.2 PR121.1
N35223686: PQ119.2 PR135.1 PR179.2
N35624566: R94.1 R448.2 U11.7 U11.8
N35624658: C51.1 U11.6
N35660943: RT52.2 TC16.1(TP-1)
N35661018: RT53.1 RT54.1 RT55.1 UT2.F10
N35661105: TC15.1(TP-1) UT2.G4
N35661109: TC14.1(TP-1) UT2.F4
N35661245: RT96.1 UT2.F1
N35662475: RT58.1 UT2.E11
N35662526: CT27.1 UT2.H7
N35662534: RT88.1 UT2.G2
N35662625: RT60.2 TC12.1(TP-1)
N35882361: PQ108.2 PR114.1 PR178.2
N35974919: PR332.2 PU300.26
N35975325: PR325.2 PU300.25
N36019742: PR733.1 PU721.7
N36023370: PC735.1 PR730.2
N36145369: PQ133.2 PR213.2 PR214.1
N36146502: PQ134.2 PQ134.3 PR215.2
N36147287: PQ134.5 PR217.2 PR228.1
N36148115: PQ135.2 PR220.2 PR221.1
N36148155: PQ136.2 PQ136.3 PR222.2
N36148188: PQ136.5 PR224.2 PR229.1
N36161939: PQ118.1 PR133.2
N36235793: CA16.1 CA17.1 UA1.38
N36236376: CA20.1 RA10.2 UA1.39
N36237197: CA24.1 CA29.1 RA11.2 UA1.16 UA1.21
N36239979: CA25.1 CA26.1 LA2.2 UA1.41
N36240770: CA30.1 CA31.2 LA3.2 UA1.46
N36262747: CA32.1 UA1.13
N36265856: CA27.1 CA28.1 UA1.17
N36266417: CA18.1 UA1.24
N36266424: CA21.2 UA1.23
N36266433: CA21.1 UA1.22
N36267340: CA15.1 UA1.31
N36486549: C47.2 U10.2
N36486567: L80.2 U10.1
N36486588: L14.1 U10.8
N36486790: L17.1 U10.6
N36486804: L16.1 U10.5
N36486942: JANT7.1(TP-1) U10.10
N36486969: L13.1 U10.9
N36486975: R81.2 U10.4
N36508056: PQ110.2 PR137.2
N36512614: PQ139.5 PQ139.6 PR252.2
N36516654: PQ138.2 PR250.1 PR251.2
N36517432: PQ139.2 PR253.2
N36723920: RA12.2 RA31.2 UA1.47
N36849615: RV67.1 RV87.1 UV1.38
N36849628: RV68.1 RV88.1 UV1.35
N36872279: TC1.1(TP-1) UCPU1.V1
N37047752: R74.2 U7.3
N37304443: C200.1 UZ4.12
N37304446: C201.1 UZ4.10
N37731575: JUFC1.26 RS26.1
N37731577: JUFC1.24 RS27.1
N37731579: JUFC1.22 RS25.1
N37841352: R490.1 RE123.2 SW5.3 SW5.4
N37999674: PC130.1 PQ125.2 PR151.2
N38000200: PQ124.2 PQ125.5 PR155.1 PR156.1
N38000331: PQ125.6 PR156.2
N38000578: PC125.1 PQ123.2 PR148.1 PR150.1
N38004921: PQ125.3 PR150.2
N38544513: C137.1 R155.1
N38872026: PC713.1 PR709.2 PU700.15
N38875212: PR703.1 PU700.1
N38877032: PC707.2 PR704.2 PR706.1 PU700.14
N38894882: PC808.1 PR806.2
N38989784: RT97.2 TC17.1(TP-1)
N38989867: RT98.2 TC18.1(TP-1)
N39725320: C91.1 U13.12
N39725481: C92.1 U13.10
N39731522: RT28.2 TC20.1(TP-1)
N39731534: RT57.2 TC21.1(TP-1)
N40373298: CD67.2 RD17.1
N40373501: CD20.2 RD3.1
N40376778: CD46.2 RD9.1
N40520768: R427.1 U4245.4
N40551930: Q25.2 Q25.3 RC188.1
N40551947: Q25.1 R5774.2 RC92.1
N40701409: Q26.2 R96.2 R429.1 R431.2
N40701429: Q26.5 R428.1 R429.2 R430.2
N40701445: Q26.6 R428.2
N40769084: C1133.1 QZ9.2 R5778.1
N40913230: PQ112.2 PR266.2
N40915054: R214.1 R215.1 U16.4
N40922663: JEDP1.4 R421.2
N40922742: JEDP1.5 R420.2
N40924684: JEDP1.33 R433.2
N40928090: PQ106.1 PR106.2
N40945196: JWFC1.30 R11.1
N41064828: C206.1 R217.1 R218.2 U16.3
N41228936: PR322.1 PU300.27
N41258423: RT107.2 UT1.A6 UT1.A7 UT1.A8 UT1.B7
N41259108: RT108.2 UT2.A6 UT2.A7 UT2.A8 UT2.B7
N41312056: JWFC1.33 R435.1
N41704672: C9.1 JANT3.1 L81.1
N41704676: C1039.1 JANT2.1(TP-1) L81.2
N41804763: D22.1 JFAN1.2 R29.1
N41804779: JFAN1.4 R438.2
N41946502: RC198.2 UCPU1.V2
N42195540: JSPK.5 RA38.1
N43237751: PQ130.1 PR216.1
N43238317: PQ130.2 PR125.2
N43294004: PQ131.1 PR225.1
N43294007: PQ131.2 PR146.2
N43294016: PQ132.2 PR165.1
N43396886: R450.2 U4246.29
N43397013: R451.1 U4246.27
N43502333: PC146.1 PD110.2 PR117.1 PR163.2 PR182.2 PU103.4
N43502350: PC281.1 PD110.1 PQ132.1 PR111.2 PR163.1 PR256.1 PU103.3
N43507801: PC144.1 PR183.2 PR255.1 PU103.1
N43518647: CA46.1 RA8.2 RA27.1
N43518650: CA47.1 RA27.2 RA28.1
N43524087: PC282.1 PD111.1 PQ140.1 PR113.2 PR164.1 PR258.1 PU104.3
N43524117: PC149.1 PD111.2 PR120.1 PR164.2 PR184.2 PU104.4
N43524149: PC148.1 PR185.2 PR257.1 PU104.1
N43524263: PQ140.2 PR167.1
N44373987: RT109.1 UT1.L11
N44375634: RT111.1 UT2.L11
N44998008: JEDP1.15 R464.2
N44998011: JEDP1.14 R465.2
N44998014: JEDP1.12 R466.2
N44998017: JEDP1.10 R467.2
N44998020: JEDP1.9 R468.2
N45241794: RC197.1 UCPU1.B7
N45337950: QE13.5 QE13.6 R473.2
N45337958: QE13.3 R472.2
N45343408: R477.2 U12.F5
N45343411: R478.2 U12.G5
N46285260: C231.1 Q33.4 R484.1 R485.1 R501.2 R502.2
N46285448: Q32.1 R486.2
N46619932: PC902.1 PR950.2 PU900.44
N46621117: PR914.1 PU900.6
N46621120: PR914.2 PR953.1 PU900.7
N46621397: PC931.1 PR953.2
N46621424: PR903.1 PU900.8
N46621427: PR904.1 PU900.9
N46621964: PC932.1 PR954.2
N46621983: PR915.1 PU900.10
N46621986: PR915.2 PR954.1 PU900.11
N46622191: PR906.1 PU900.12
N46622194: PR907.1 PU900.13
N46622340: PC900.2 PR916.2 PR920.2 PU900.37
N46622659: PR917.2 PR921.2 PU900.35
N46622666: PR918.2 PR922.2 PU900.33
N46622669: PR919.2 PR923.2 PU900.32
N46623252: PR925.2 PR928.1 PR929.2
N46623254: PR901.2 PR926.1 PR930.2
N46623256: PR900.2 PR924.2 PR927.1
N46623799: PR931.2 PR932.2 PU900.30
N46624101: PR927.2 PU900.27
N46624104: PR926.2 PU900.29
N46624128: PR928.2 PU900.28
N46624575: PR933.2 PR934.2 PU900.31
N46625447: PR936.2 PR937.2 PU900.25
N46626304: PC1423.2 PR938.2 PR949.2 PU900.46
N46626546: PR939.2 PR940.2 PU900.36
N46626820: PR956.2 PU900.24
N46626937: PC904.2 PR941.2 PU900.21
N46627867: PC905.2 PR944.2 PU900.22
N46628199: PC906.2 PR945.2 PU900.23
N46634435: PC907.1 PR946.1 PR947.2 PU900.45
N46635062: PR948.1 PU900.14
N46635065: PR948.2 PR955.1 PU900.15
N46635193: PC933.1 PR955.2
N46635895: PR951.1 PU900.16
N46635936: PR952.1 PU900.17
N46642074: PC327.1 PR1101.2 PU1005.14
N46643804: PC1110.1 PU1005.15
N46645023: PC1114.2 PL1101.1 PR1108.1 PU1006.2 PU1006.3 PU1006.4
N46645025: PC1111.1 PR1108.2
N46645111: PC328.1 PR1103.2 PU1006.14
N46645235: PC1114.1 PU1006.15
N46647976: PC1117.1 PR1117.2
N46647978: PC1120.2 PL1102.1 PR1117.1 PU1107.2 PU1107.3 PU1107.4
N46648066: PC337.1 PR1118.2 PU1107.14
N46648174: PC1120.1 PU1107.15
N46648285: PC1126.2 PL1103.1 PR1125.1 PU1108.2 PU1108.3
N46648306: PC1124.1 PR1125.2
N46648384: PC338.1 PR1126.2 PU1108.12
N46648510: PC1126.1 PU1108.13
N46677664: JUFC1.29 R487.2
N46798093: JWFC1.34 RA44.2
N46884959: JNGFF1.38 R489.1
N48002177: JNGFF1.60 R492.1
N48002180: JNGFF1.62 R493.1
N48002183: JNGFF1.64 R494.1
N48798623: C151.1 JNGFF3.50 R161.1
N48801679: JDEG3.1 RE9.2
N48802004: LED4.2 R411.2
N48802006: LED4.1 Q16.1
N49010205: CC97.2 RC374.2 RC377.1 YC3.3
N49010514: CC96.2 RC374.1 RC378.1 YC3.1
N49018040: JESPI1.8 RE193.2
N49019257: Q12.1 RE50.1
N49054522: CE65.1 RE172.2
N49063593: QE15.3 RE219.1 RE222.2
N49063613: QE16.2 RE219.2
N49105313: PQ141.3 PR122.2 PR262.2
N49105729: PQ141.2 PR261.2
N49107876: PQ142.3 PR132.2 PR264.2
N49107912: PQ142.2 PR265.2
N49135368: PQ129.5 PR206.2 PR207.2
N49135372: PQ129.6 PR175.2 PR207.1 PR208.1
N49135382: PQ127.5 PQ127.6 PR124.2
N49135384: PQ122.1 PQ127.3 PR142.2 PR203.2
N49135442: PQ129.3 PR209.1
N49135489: PQ127.2 PR201.2 PR203.1
N49135666: PQ120.5 PQ120.6 PR127.2
N49135672: PQ120.2 PR144.2 PR204.1
N49135678: PQ120.3 PQ128.1 PR143.2 PR204.2
N49135704: PQ128.6 PR200.1
N49135720: PQ128.2 PR145.2
N49135818: PQ122.6 PR192.1
N49135824: PQ129.2 PR202.2
N49135828: PQ122.5 PR206.1
N49135838: PQ122.2 PR138.2
N49140312: PQ126.2 PR271.1
N49146615: PQ308.2 PR336.1 PR338.2
N49148321: PD303.2 PR343.2
N49148324: PD302.2 PR342.2
N49148345: PD302.1 PD303.1 PR347.1 PU301.2
N49148379: PR345.2 PU301.1
N49149484: PR351.1 PU301.4
N49570913: PC701.1 PR702.2
N49571039: PC702.1 PR703.2
N49601346: MIC1.1 MIC1.2 RA41.2
N49601372: MIC3.1 MIC3.2 RA42.2
N49601403: MIC2.1 RA43.2
N49659209: RS15.2 U3.1
N49659657: RS16.2 U3.4
N49660582: CS8.2 U3.5
N49667281: Q10.1 RE12.2
N49699324: C1134.1 Q352.2 R233.1 R234.2
N49699330: Q353.1 R233.2
N49815531: PQ139.3 PR110.2
N49816160: PQ112.1 PR250.2
N49816176: PQ103.5 PR116.2
N49817963: PQ102.5 PR268.2
N49822184: PC284.1 PR102.1 PR119.1 PR267.2 PU105.1
N49835416: PQ110.1 PR112.2
N50054694: R470.2 UE3.D13
N50054805: R471.2 UE3.E12
N50084753: Q31.2 R480.1 R481.1
N50745785: RE265.2 UE3.N4
N51017534: T58.1(TP-1) UE3.H5
N51017637: T59.1(TP-1) UE3.L9
N51049452: D114.1 Q354.3
N51049502: D113.1 Q354.6
N51064237: LED5.2 R5766.2
N51064241: LED5.1 Q356.1
N51204121: R5751.2 U4247.5
N51204123: R5755.2 U4247.4
N51204155: R5752.2 U4248.5
N51204157: R5756.2 U4248.4
N51204189: R5753.2 U4249.5
N51204191: R5757.2 U4249.4
N51204271: R5758.2 U4250.4
N51204273: R5754.2 U4250.5
N51204761: R5759.2 R5767.2 U4251.1
N51263457: D115.2 Q357.3
N51360660: C1131.1 D116.1 Q349.2 R2745.1 R5769.2 R5779.1
N51360785: Q348.1 R5768.2
N51362251: JNGFF2.8 T60.1(TP-1)
N52900707: C24.1 U2.6
N52929311: C129.1 U21.10
N52929327: C127.1 U21.12
N52930580: C118.1 U17.10
N52930730: C119.1 U17.12
N52934547: C85.1 U14.10
N52934693: C84.1 U14.12
N54060987: C1137.1 U4255.6
N56035976: PC727.1 PR723.2
N56036060: PR726.1 PU720.7
N57034346: T15.1(TP-1) UCPU1.AC3
N57313074: RC168.2 UCPU1.AU8
N57670088: T26.1(TP-1) UCPU1.AW15
N58864976: R149.2 R150.2 U21.5
N64926554: CC49.1 R121.2
N118152590: PC818.1 PR819.2

Pads without a net: DI1 3; FD1 1; FD2 1; FD3 1; FD4 1; JAPS1 1 2 3; JCR1 14; JEDP1 16 18 22 31 37 40; JIO1 10 11; JIO2 15 21 22 23 24 25 26 27; JIR1 3; JNGFF1 10 20 22 24 28 42 46 48 56 58; JNGFF2 5 6 7 10 11 13 17 19 20 22 23 24 25 26 28 30 32 34 36 40 42 44 46 48 56 58 67; JNGFF3 6 16 17 19 20 21 22 25 26 27 28 31 32 34 58 59 60 61 62 64 65 67 68 71 73; JSIM1 5; JUFC1 7 23 25 28; JWFC1 22; LGA1 10 11; PD105 3; PQ128 3 4 5; PR402 2; PR404 2; PU101 3; PU300 13; PU400 16 19; PU500 4; PU501 4; PU502 4; PU700 10 12; PU900 2 3 40 41; R108 1; R464 1; R465 1; R467 1; RT26 1; RT30 1; RT33 1; RT92 1; RT93 1; RT95 1; U1 B3 C3; U3 7; U8 3; U9 3 6 7; U12 C2 C3 D3 D4 E1 E2 E3 E5 E6 F1 F2 F3 H1 H3; U44 1; U4246 2 4 5 6 7 10 11 12 13 15 25 26 28 30 31; U4247 3; U4248 3; U4249 3; U4250 3; U4251 2; UA1 7 14 15 19 20 35 36; UC1 1; UCPU1 A3 A4 A11 A17 A19 A26 A27 A29 A38 A40 A45 A47 A52 A65 A69 AB4 AB12 AB62 AC1 AC2 AC63 AD11 AD12 AE62 AE63 AF6 AF7 AF8 AF9 AF13 AG62 AH11 AH12 AJ62 AK6 AK7 AK9 AK10 AK62 AL25 AL27 AL61 AL63 AM1 AM4 AM5 AM10 AN1 AN8 AN43 AP43 AP56 AR10 AR56 AT43 AT52 AU56 AW1 AW17 AW20 AW22 AW42 AW48 AW50 AW68 AW69 AY1 AY2 AY20 AY21 B2 B3 B11 B17 B19 B26 B27 B29 B38 B40 B45 B47 B52 B69 B70 BA3 BA4 BA7 BA47 BA50 BB2 BB4 BB9 BB46 BB52 C2 C4 C8 C11 C12 C16 C17 C20 C23 C27 C28 C29 C36 C42 C54 C70 C71 D1 D3 D4 D5 D7 D8 D12 D16 D17 D20 D23 D27 D28 D29 D36 D42 D54 D71 E1 E2 E25 E61 F6 F11 F15 F18 F25 F52 F60 F61 G11 G13 G15 G16 G18 G61 H1 H11 H13 H16 H63 J4 J68 J71 K45 K46 M1 M2 M3 N11 N12 P62 R9 U1 U2 U3 U4 U11 U12 V62 W2 W4; UD1 A1 A2 A12 A13 B1 B13 C4 K9 R3 T1 T13 U1 U2 U12 U13; UD2 A1 A2 A12 A13 B1 B13 C4 K9 R3 T1 T13 U1 U2 U12 U13; UD3 A1 A2 A12 A13 B1 B13 C4 K9 R3 T1 T13 U1 U2 U12 U13; UD4 A1 A2 A12 A13 B1 B13 C4 K9 R3 T1 T13 U1 U2 U12 U13; UE3 A11 B10 D9 E2 F13 G2 L2 L8; UE5 1; UE7 1; UR1 31; US1 9 15; UT1 A9 B9 F11; UT2 A9 B9 F11

## Via types
v1: diameter 0.254, hole 0.102, IN4 to BOTTOM, 503 vias
v2: diameter 0.305, hole 0.152, TOP to BOTTOM, 576 vias
v3: diameter 0.254, hole 0.102, TOP to IN2, 834 vias
v4: diameter 0.406, hole 0.203, GND1 to GND3, 1067 vias
v5: diameter 0.254, hole 0.102, IN3 to BOTTOM, 1048 vias
v6: diameter 0.254, hole 0.102, IN3 to IN4, 443 vias
v7: diameter 0.457, hole 0.203, TOP to BOTTOM, 2349 vias
v8: diameter 0.254, hole 0.102, TOP to IN1, 471 vias
v9: diameter 0.406, hole 0.203, TOP to BOTTOM, 86 vias
v10: diameter 0.254, hole 0.102, IN1 to IN2, 211 vias
v11: diameter 0.508, hole 0.254, TOP to BOTTOM, 51 vias
