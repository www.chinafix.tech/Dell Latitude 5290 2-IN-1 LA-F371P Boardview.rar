# Allegro board Dell Latitude 5290 2-IN-1 LA-F371P Boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EDP_TXN_P0_CONN: length 11.3
  IN1 w0.066: v7(77.93,39.4) 78.15,39.19 78.34,39.19 82.21,43.06 84.96,43.06 v8(85.1,43.2)
  BOTTOM w0.112: R414.2 79.09,37.86 78.93,38.03 78.93,38.77 78.74,38.96 78.74,39.11 78.49,39.37 77.97,39.37 v7(77.93,39.4)
EDP_TXN_P0_R: length 1.6
  BOTTOM w0.112: C177.2 78.78,35.81 78.78,36.16 78.93,36.3 78.93,36.78 79.09,36.95 R414.1
EDP_TXN_P1: length 175
  IN2 w0.081: v7(76.6,34.35) 76.98,34.73 76.98,34.87 76.83,35.02 73.06,35.02 67.75,40.33 67.75,81.16 67.18,81.73 67.18,85.69 68.79,87.3 68.79,87.62 69.65,88.48 72.03,88.48 73.25,89.69 75.77,89.69 76.78,88.68 79.12,88.68 80.64,90.19 94.13,90.19 94.63,89.69 98.91,89.69 99.63,90.41 101.71,90.41 103.4,92.09 103.4,99.19 104.52,100.32 104.52,100.94 110.61,107.03 112.66,107.03 113.78,108.15 113.78,119.55 108.47,124.86 97.92,124.86 94.66,128.13 93.85,128.13 92.55,129.43 90.91,129.43 90.09,130.25 90.09,131.58 88.57,133.1 85.33,133.1 82.49,135.94 81.77,135.94 80.09,134.25 80.09,133.48 v3(80.37,133.2)
  BOTTOM w0.112: v7(76.6,34.35) 76.79,34.54 76.79,34.74 C180.1
EDP_TXN_P1_CONN: length 12.4
  IN1 w0.066: v7(76.58,38.74) 76.73,38.88 76.73,39.42 77.34,40.03 77.94,40.03 82.55,44.64 85.04,44.64 v8(85.1,44.7)
  BOTTOM w0.112: R412.2 76.42,37.86 76.58,38.03 76.58,38.3 76.75,38.46 76.75,38.57 v7(76.58,38.74)
EDP_TXN_P1_R: length 1.6
  BOTTOM w0.112: R412.1 76.42,36.95 76.58,36.78 76.58,36.38 76.73,36.24 76.73,35.81 C180.2
EDP_TXP_P0: length 176.3
  IN2 w0.081: v3(80.37,133.85) 80.79,133.96 80.82,134.02 80.82,134.41 81.96,135.55 82.33,135.55 84.54,133.34 84.54,133.33 85.18,132.69 88.43,132.69 89.7,131.42 89.7,129.52 90.72,128.5 92.87,128.5 93.63,127.75 94.5,127.75 97.76,124.48 98.57,124.48 108.31,124.48 113.4,119.39 113.4,108.32 112.5,107.42 110.45,107.42 104.14,101.1 104.14,100.48 103.01,99.35 103.01,92.25 101.55,90.79 99.47,90.79 98.75,90.08 94.79,90.08 94.25,90.63 80.52,90.63 78.96,89.06 76.94,89.06 75.93,90.08 73.06,90.08 71.84,88.86 69.49,88.86 68.41,87.78 68.41,87.46 66.8,85.85 66.8,81.57 67.37,81 67.37,40.17 74.26,33.28 77.35,33.28 v7(77.6,33.52)
  BOTTOM w0.112: v7(77.6,33.52) 77.8,33.32 77.93,33.32 78.08,33.47 78.08,34.01 78.57,34.5 78.57,34.81 C178.1
EDP_TXP_P0_CONN: length 11.2
  IN1 w0.066: v8(85.1,42.7) 84.89,42.91 82.28,42.91 78.4,39.04 78.15,39.04 v7(77.93,38.82)
  BOTTOM w0.112: R415.2 78.26,37.86 78.43,38.03 78.43,38.26 78.71,38.54 78.71,38.68 78.53,38.87 78.53,39.03 78.4,39.16 78.23,39.16 77.93,38.86 v7(77.93,38.82)
EDP_TXP_P0_R: length 1.6
  BOTTOM w0.112: C178.2 78.57,35.81 78.57,36.16 78.43,36.3 78.43,36.78 78.26,36.95 R415.1
EDP_TXP_P1: length 175.1
  IN2 w0.081: v7(77.18,34.35) 77.18,34.96 76.92,35.22 73.15,35.22 67.96,40.41 67.96,81.24 67.39,81.81 67.39,85.61 69,87.21 69,87.54 69.73,88.27 72.11,88.27 73.33,89.49 75.68,89.49 76.7,88.47 79.2,88.47 80.72,89.99 94.05,89.99 94.55,89.49 99,89.49 99.71,90.2 101.8,90.2 103.6,92.01 103.6,99.11 104.73,100.23 104.73,100.86 110.7,106.83 112.75,106.83 113.99,108.07 113.99,119.63 108.55,125.07 98.01,125.07 94.74,128.33 93.93,128.33 92.63,129.63 90.99,129.63 90.29,130.33 90.29,131.66 88.65,133.3 85.41,133.3 82.57,136.14 81.69,136.14 79.88,134.34 79.88,133.6 v3(79.81,133.52)
  BOTTOM w0.112: v7(77.18,34.35) 77,34.53 77,34.87 C179.1
EDP_TXP_P1_CONN: length 12.4
  IN1 w0.066: v8(85.1,44.2) 85.1,44.33 84.94,44.49 82.61,44.49 78,39.88 77.4,39.88 76.88,39.36 76.88,39.02 v7(77.17,38.74)
  BOTTOM w0.112: v7(77.17,38.74) 76.98,38.55 76.98,38.41 77.08,38.3 77.08,38.03 77.25,37.86 R413.2
EDP_TXP_P1_R: length 1.6
  BOTTOM w0.112: C179.2 76.94,35.81 76.94,36.24 77.08,36.38 77.08,36.78 77.25,36.95 R413.1
EDRAM_OPIO_RCOMP: length 3.6
  TOP w0.254: v3(92.43,130.62) 92.02,130.21 UCPU1.H66
  IN2 w0.254: v3(92.43,130.62) v4(92.43,130.95)
  IN3 w0.254: v4(92.43,130.95) 92.02,130.54 v5(91.69,130.54)
  BOTTOM w0.112: v2(92.67,131.57) 91.69,130.6 v5(91.69,130.54)
EMMC_RCOMP: length 2.9
  TOP w0.076: 52.45,115.44 53.21,115.44 53.83,116.06 UCPU1.AT1
  TOP w0.305: 52.45,115.44 RC66.1
EN_0.6V: length 5.1
  TOP w0.254: v7(109.46,121.47) 109.73,121.2 109.73,120.84 109.59,120.7 PU600.16
  BOTTOM w0.254: PC613.1 PR607.1 PR605.2 PR608.2 109.98,121.99 v7(109.46,121.47)
EN_1.0VA: length 4.8
  TOP w0.112: PR700.2 134.12,138.96 v2(134.12,139.52)
  TOP w0.254: PR700.2 PR701.1 PC700.1 131.5,138.57 130.82,139.25 PU700.11
EN_1.2V: length 4.7
  TOP w0.254: PR611.2 PR612.1 PC615.1 110.62,121.86 110.08,121.32 110.08,120.46 109.83,120.2 PU600.15
EN_1.8VA: length 4.3
  TOP w0.112: v2(141.62,139.96) 141.91,140.25 PC720.2
  TOP w0.254: PU720.13 141.22,140.98 141.29,140.91 PC720.2 PR720.2 PR721.2
EN_1.8VU: length 4
  TOP w0.203: PR727.2 104.44,98.08 104.57,97.96 104.88,97.96 PR728.2
  TOP w0.254: PR728.2 PC728.2 105.6,96.59 106.15,97.14 PU721.13
EN_INVPWR: length 89.6
  TOP w0.112: v2(80.73,72.98) 81.47,73.71 v12(81.82,73.71)
  GND1 w0.066: v12(81.82,73.71) v4(82.5,73.71)
  IN3 w0.066: v6(26.29,91.78) 26.37,91.7 32.85,91.7 40.03,84.52 41.15,84.52 42.07,83.6 45.65,83.6 48.11,81.14 52.17,81.14 52.36,81.33 60.53,81.33 62.48,79.38 66.86,79.38 67.56,78.68 77.54,78.68 v4(82.5,73.71)
  IN4 w0.066: v6(26.29,91.78) 26.61,91.78 27.82,92.99 27.82,98.43 28.5,99.11 28.5,102.25 28.54,102.29 v1(28.54,102.45)
  BOTTOM w0.076: 30.75,108.02 30.71,108.02 29.83,108.89 29.83,109.3 UE3.B2
  BOTTOM w0.112: 30.75,108.02 31.38,108.02 32.44,106.95 32.44,105.4 32.32,105.28 32.02,105.28 RE69.2 31.67,104.45 31.68,104.45 31.77,104.36 31.77,103.85 31.68,103.76 30.92,103.76 29.62,102.45 v1(28.54,102.45)
EN_INVPWR_R: length 9.8
  TOP w0.254: R486.1 85.59,74.45 85.59,76.86 85.32,77.13 Q33.3 84.52,77.97 84.12,78.37 R485.2 83.76,79.05 v2(83.28,79.52) 81.9,80.9 C231.2
EN_PD_HV1: length 68.8
  TOP w0.112: v3(32.28,42) 32.28,43.47 32.64,43.83 PR184.1 ; v8(31.29,41.8) 30.71,41.21 PR165.2 30.43,40.32 v2(30.52,40.24)
  IN1 w0.066: v3(32.28,42) 32.16,41.87 31.37,41.87 v8(31.29,41.8)
  IN2 w0.066: v3(19.7,32.96) 20.7,32.96 22.17,34.43 v4(22.17,39.49) ; v3(32.28,42) v4(31.95,42)
  IN3 w0.066: v4(22.17,39.49) 24.59,39.49 26.87,41.76 28.43,41.76 28.52,41.67 30.53,41.67 30.86,42 v4(31.95,42) 34.39,42 34.7,42.31 41.2,42.31 42.15,41.36 45.13,41.36 45.52,41.75 v6(45.52,41.94)
  IN4 w0.066: v1(32.74,61.14) 34.79,59.09 34.79,58.25 35.68,57.36 35.68,56.04 35.46,55.82 35.46,51.4 36.58,50.27 41.34,50.27 45.67,45.95 45.67,42.79 45.44,42.56 45.44,42.02 v6(45.52,41.94)
  BOTTOM w0.112: RT46.2 32.62,59.68 33.01,60.07 33.01,60.91 32.79,61.14 v1(32.74,61.14)
EN_PD_HV2: length 113.7
  TOP w0.112: v3(35.26,48.48) 34.8,48.93 33.73,48.93 33.27,48.48 33.27,47.69 PR182.1
  IN1 w0.066: v7(64.33,9.21) 52.51,9.21 45.15,16.58 15.88,16.58 15.11,17.34 15.11,19.5 15.71,20.09 v8(15.71,20.16) 16.26,20.7 16.26,22.41 16.5,22.66 16.5,24.18 16.79,24.46 16.79,29.47 15.71,30.55 15.71,31.24 15.57,31.38 15.57,31.94 16.64,33.01 v10(16.64,33.57)
  IN2 w0.066: v3(35.26,48.48) v4(34.82,48.48) ; v4(20.88,46.22) 20.88,45.91 21.11,45.68 21.11,35.93 18.75,33.57 v10(16.64,33.57)
  IN3 w0.066: v4(34.82,48.48) 33.27,48.48 32.11,49.65 30.4,49.65 28.7,47.94 27.41,47.94 26.39,46.93 22.38,46.93 21.67,46.22 v4(20.88,46.22)
  BOTTOM w0.112: RT75.2 64.33,14.3 v2(64.33,12.04) v7(64.33,9.21)
EN_PRIM_COREP: length 4.3
  TOP w0.254: v2(50.47,150.46) 50.47,150.17 50.28,149.98 PR815.2 PR816.1 PC810.1 PU801.13
EN_VCCIO: length 7.3
  TOP w0.254: PR826.2 126.15,133.16 v2(126.49,132.82) 126.49,131.09 126.2,130.8 PR803.1 PC800.1 124.08,130.24 124.53,129.79 PU800.13
ENVDD: length 5.7
  TOP w0.112: D60.1 38.35,21.4 38.19,21.24 R76.1 37,20.77 36.83,20.77 36.7,20.64 36.7,18.73 37.15,18.29 U8.4
EOPIO_RCOMP: length 2.8
  TOP w0.254: UCPU1.H65 90.73,130.21 90.9,130.39 90.91,130.39 v3(90.96,130.44)
  IN2 w0.254: v4(91.06,130.77) 90.96,130.67 v3(90.96,130.44)
  IN3 w0.254: v4(91.06,130.77) 91.03,130.8 91.03,130.85 90.82,131.07 v5(90.82,131.7)
  BOTTOM w0.112: v5(90.82,131.7) v2(90.82,132.63)
ESPI_ALERT#: length 97.9
  TOP w0.076: 61.16,110.43 61.16,110.48 60.67,110.97 60.67,112.83 60.46,113.03 60.46,113.2 UCPU1.AY11
  TOP w0.112: v3(61.72,105.91) v2(61.72,106.8) 61.16,107.35 61.16,110.43
  IN2 w0.066: v3(61.72,105.91) 62.03,105.59 62.03,104.76 63.27,103.52 63.27,99.92 63.35,99.85 63.35,99.71 63.36,99.7 v4(63.36,98.92)
  IN3 w0.066: v6(45.11,106.67) 45.18,106.74 48.47,106.74 48.47,106.73 49.23,106.73 49.23,106.74 49.69,106.74 49.69,106.73 49.98,106.73 56.69,100.03 59.26,100.03 61.85,97.45 62.83,97.45 62.98,97.3 63.26,97.3 63.46,97.5 63.46,98.83 v4(63.36,98.92) ; v6(46.46,97.97) 45.32,99.11 45.02,99.11 42.43,101.69 39.55,101.69 38.49,100.63 29.18,100.63 26.74,103.07 24.26,103.07 23.96,102.76 19.66,102.76 18.81,103.61 18.13,103.61 17.84,103.32 v6(16.92,103.32)
  IN4 w0.066: v6(16.92,103.32) 16.85,103.39 16.85,104.92 17.05,105.13 17.05,106.64 17.69,107.27 17.69,107.44 17.87,107.62 v1(17.91,107.62) ; v6(45.11,106.67) 45.11,105.2 46.24,104.07 46.24,101.72 46.46,101.5 v6(46.46,97.97)
  BOTTOM w0.076: 20.27,110.89 20.81,110.89 21.07,111.14 21.07,111.17 21.41,111.5 22.01,111.5 22.14,111.64 22.37,111.64 22.61,111.88 22.61,111.89 23.21,112.49 23.21,112.49 23.63,112.91 23.63,112.91 23.84,113.12 23.96,113.12 24.44,113.6 24.73,113.6
  BOTTOM w0.112: 20.27,110.89 19.53,110.15 19.53,108.71 18.96,108.14 18.96,107.79 18.85,107.67 17.96,107.67 v1(17.91,107.62) 17.65,107.88 RC83.2
ESPI_CLK: length 79.2
  TOP w0.112: RC71.2 v8(58.8,107.94) ; v7(47,91.92) 47.89,92.81 v8(55.05,92.81) 56,92.81 v2(56.34,92.47)
  IN1 w0.066: v8(58.8,107.94) 58.8,105.93 58.46,105.59 58.46,104.75 58.32,104.61 58.32,103.98 58.16,103.81 58.16,96.52 56.91,95.28 56.91,94.39 55.33,92.81 v8(55.05,92.81)
  IN3 w0.066: v6(28.09,95.34) 28.56,95.8 36.43,95.8 36.5,95.73 36.5,94.85 36.57,94.78 36.79,94.78 36.86,94.85 36.86,95.73 36.92,95.8 37.12,95.8 37.19,95.73 37.19,94.82 37.25,94.76 37.48,94.76 37.54,94.82 37.54,95.73 37.61,95.8 37.84,95.8 37.91,95.73 37.91,94.85 37.98,94.78 38.19,94.78 38.25,94.85 38.25,95.73 38.32,95.8 38.53,95.8 38.59,95.73 38.59,94.87 38.66,94.81 38.87,94.81 38.94,94.87 38.94,95.73 39,95.8 39.39,95.8 43.92,91.28 46.04,91.28 46.69,91.92 v7(47,91.92)
  IN4 w0.066: v6(28.09,95.34) 28.09,98.3 28.78,98.99 28.78,101.82 28.83,101.87 28.83,102.53 28.05,103.31 26.62,103.31 v1(26.06,103.87) 26.21,104.03 26.21,106.4 25.42,107.2 25.42,108.49 26.29,109.36 26.29,110.64 v1(26.04,110.89)
  BOTTOM w0.076: 25.53,113.6 25.24,113.32 25.24,112.68 25.64,112.29 25.65,112.29 26.04,111.89 v1(26.04,110.89)
  BOTTOM w0.112: RE172.1 CC78.2 26.01,103.87 v1(26.06,103.87)
ESPI_CS#: length 91.3
  TOP w0.076: v8(60.58,113.47) 60.73,113.32 UCPU1.BA12
  IN1 w0.066: v8(60.58,113.47) 60.58,113.47 60.58,113.48 60.47,113.59 60.47,113.93 60.62,114.08 61.08,114.08 61.73,113.43 61.73,112.26 60.76,111.28 60.76,110.85 58.34,108.43 58.34,106.11 58.08,105.86 58.08,105.85 58.01,105.78 58.01,105.04 57.84,104.87 57.84,104.23 57.71,104.1 57.71,96.97 v8(55.05,94.31) 54.73,94.31 52.81,92.4 51.93,92.4 51.68,92.15 48.17,88.63 47.42,88.63 46.31,87.52 46.31,84.4 45.39,83.48 43.46,83.48 39.48,79.5 38.83,79.5 38.2,78.87 v7(37.78,78.87)
  IN4 w0.066: v7(37.78,78.87) 37.7,78.87 36.91,79.65 36.91,81.21 32.91,85.22 32.91,88.38 32.11,89.18 32.11,90.47 32.19,90.55 32.19,96.59 32.41,96.82 32.41,99.76 31.43,100.75 31.43,101.74 30.85,102.32 30.85,104.33 30.97,104.45 30.97,104.67 30.49,105.15 30.38,105.15 29.11,105.15 28.02,106.24 28.02,108.56 28.15,108.69 28.15,109.62 27.98,109.78 27.98,110.66 27.39,111.25 27.39,111.26 27.28,111.37 26.82,111.37 26.54,111.65 25.78,111.65 25.58,111.85 25.23,112.2 v1(25.1,112.2)
  BOTTOM w0.076: v1(25.1,112.2) 25.1,112.27 24.73,112.64 UE3.H6
ESPI_IO0: length 78.5
  IN1 w0.066: v7(37.72,79.6) 37.72,80.33 38.15,80.76 39.65,80.76 43.56,84.67 43.56,87.18 45.16,88.78 46.26,88.78 47.59,90.11 48.55,90.11 51.51,93.07 52.53,93.07 53.17,93.71 53.17,94.43 v8(55.05,96.31) 56.55,97.81 56.55,101.93 56.55,102.21 57.1,102.76 57.1,104.64 57.56,105.09 v8(57.56,105.22)
  IN4 w0.066: v7(37.72,79.6) 37.72,81.73 33.86,85.59 33.86,88 32.92,88.94 32.92,99.98 31.93,100.97 31.93,101.95 31.78,102.1 31.78,104.58 30.7,105.65 30.35,105.65 29.17,106.83 29.17,107.06 28.72,107.52 28.72,108.53 28.87,108.68 28.87,110.49 28.6,110.76 27.99,111.37 27.99,111.8 27.6,112.18 25.72,112.18 25.28,112.62 24.92,112.62 24.64,112.35 23.47,112.35 v5(23.13,112)
ESPI_IO0_R: length 10.6
  TOP w0.112: v8(57.1,105.6) 56.72,105.22 RC383.1
  IN1 w0.066: v8(57.1,105.6) 57.33,105.83 57.33,106.33 58,107 58,108.57 60.33,110.89 60.33,111.67 61.19,112.54 61.42,112.54 61.57,112.69 61.57,113.25 61.32,113.5 v8(61.3,113.5)
ESPI_IO1: length 82.1
  TOP w0.112: v8(55.05,95.81) 55.93,95.81 v2(56.1,95.65)
  IN1 w0.066: v8(57.94,106.11) 57.84,106.01 57.84,105.12 57.28,104.56 57.28,102.68 56.72,102.12 56.72,102 56.72,97.48 v8(55.05,95.81) 53.34,94.1 53.34,93.64 52.6,92.9 51.62,92.9 48.63,89.92 47.67,89.92 46.34,88.58 45.24,88.58 43.76,87.1 43.76,84.59 39.73,80.56 38.61,80.56 v7(38.1,80.06)
  IN4 w0.066: v7(38.1,80.06) 38.1,81.74 34.03,85.82 34.03,88.07 33.08,89.01 33.08,100.05 32.38,100.75 32.38,104.61 31.42,105.58 31.42,105.91 31.24,106.09 31.02,106.09 30.71,106.39 30.08,106.39 29.24,107.24 29.24,107.87 29.04,108.07 29.04,110.56 28.56,111.04 28.56,111.54 27.75,112.35 25.79,112.35 25.35,112.79 24.85,112.79 24.57,112.51 22.47,112.51 22.06,112.11 22.06,111.46 v1(22.33,111.2)
ESPI_IO1_R: length 8.6
  IN1 w0.066: v8(61.3,112.85) 61.22,112.85 60.09,111.71 60.09,110.89 57.83,108.64 57.83,107.09 57.02,106.28 v8(57.02,106.11)
ESPI_IO2: length 76.5
  TOP w0.112: v8(55.05,95.31) 56.98,95.31 v2(57.29,95)
  IN1 w0.066: v7(38.67,80.06) 39.49,80.06 43.28,83.84 45.14,83.84 45.95,84.65 45.95,87.71 47.26,89.02 48.01,89.02 51.72,92.73 52.67,92.73 53.51,93.57 53.51,93.77 v8(55.05,95.31) 56.98,97.24 56.98,102.03 57.48,102.52 57.48,104.26 v8(57.56,104.33)
  IN4 w0.066: v1(25.96,112.61) 26.08,112.61 26.15,112.54 27.79,112.54 28.72,111.61 28.72,111.11 29.2,110.63 29.2,108.14 31.09,106.26 31.31,106.26 31.6,105.97 31.6,105.64 32.55,104.68 32.55,100.82 33.25,100.12 33.25,89.08 34.19,88.14 34.19,85.88 38.67,81.4 v7(38.67,80.06)
  BOTTOM w0.076: UE3.G6 25.77,112.8 v1(25.96,112.61)
ESPI_IO2_R: length 9.8
  IN1 w0.066: v8(61.3,112.19) 60.55,111.45 60.55,110.88 58.17,108.5 58.17,106.74 57.58,106.15 57.58,105.63 56.64,104.69 v8(56.64,104.33)
ESPI_IO3: length 78.8
  TOP w0.112: v8(57.38,101.84) 57.56,102.02 RC386.2
  IN1 w0.066: v8(57.38,101.84) 57.38,97.14 v8(55.05,94.81) 54.99,94.81 52.74,92.56 51.83,92.56 48.09,88.83 47.34,88.83 46.73,88.21 46.12,87.6 46.12,84.51 45.26,83.66 43.37,83.66 39.4,79.69 38.51,79.69 v7(38.26,79.44)
  IN4 w0.066: v1(22.33,112) 22.59,111.74 23.25,111.74 23.69,112.18 24.71,112.18 24.99,112.46 25.21,112.46 25.65,112.02 25.84,112.02 26.43,112.02 26.8,111.64 27.2,111.64 27.44,111.88 27.67,111.88 27.82,111.73 27.82,111.3 28.53,110.59 28.7,110.42 28.7,108.75 28.55,108.6 28.55,107.45 28.85,107.15 28.85,106.91 30.28,105.48 30.63,105.48 31.31,104.81 31.31,104.31 31.18,104.19 31.18,102.46 31.76,101.88 31.76,100.9 32.75,99.91 32.75,88.83 33.1,88.48 33.1,85.3 37.1,81.29 37.1,79.7 37.57,79.23 38.05,79.23 v7(38.26,79.44)
ESPI_IO3_R: length 12.5
  IN1 w0.066: v8(56.64,103.44) 56.64,103.87 56.38,104.14 56.38,104.66 56.76,105.04 56.76,106.25 57.61,107.1 57.61,108.65 59.92,110.96 59.92,111.9 60.99,112.97 60.99,113.56 v8(60.73,113.82)
ESPI_RESET#: length 89.8
  TOP w0.076: UCPU1.BA11 60.43,112.52 60.43,110.43
  TOP w0.112: v8(60.54,110.26) 60.43,110.38 60.43,110.43
  IN1 w0.066: v7(38.76,78.89) 39.15,78.89 43.41,83.15 45.47,83.15 46.81,84.49 46.81,86.19 52.17,91.55 52.91,91.55 54.94,93.57 55.71,93.57 56.64,94.5 56.64,95.39 57.89,96.64 57.89,103.98 58.01,104.1 58.01,104.76 58.19,104.94 58.19,105.72 58.25,105.78 58.25,105.79 58.5,106.04 58.5,107.37 58.5,108.23 v8(60.54,110.26)
  IN4 w0.066: v7(38.76,78.89) 39.04,79.16 39.04,81.41 34.36,86.09 34.36,88.21 33.86,88.71 33.86,90.12 33.42,90.56 33.42,100.19 32.72,100.89 32.72,105.21 32.26,105.67 32.26,105.72 31.82,106.16 31.64,106.16 31.38,106.43 31.15,106.43 29.37,108.21 29.37,111.28 29.03,111.63 29.03,112.47 28.44,113.06 26.22,113.06 26.16,113.01 25.83,113.01 25.01,113.01 24.83,113.01 24.62,112.8 v1(23.13,112.8)
FB_1.8VA: length 3.4
  TOP w0.254: PR722.2 135.95,142.42 PR724.1 ; PR722.2 136.01,142.48 PU720.5 ; PR722.2 PC721.2
FB_1.8VU: length 3.8
  TOP w0.254: PC729.2 111.32,95.43 PR731.1 ; PR731.1 110.54,95.45 110.36,95.64 PU721.5 ; PR731.1 111.32,96.32 PR729.2
FIVR_EN: length 3
  BOTTOM w0.112: RC109.2 RC111.2 148.82,131.81 148.82,130.95 RC121.1
FIVR_EN_R: length 17.5
  IN4 w0.066: v1(153.21,131.5) 152.98,131.5 150.88,129.39 150.88,123.1 150.03,122.26 150.03,120.33 v1(149.4,119.7)
  BOTTOM w0.112: v1(153.21,131.5) 150.31,131.5 RC119.2 RC121.2
GNSS_IRQ: length 44.7
  TOP w0.076: 52.45,118.69 53.94,118.69 54.34,118.29 54.78,118.29 55.02,118.05 UCPU1.AM3
  TOP w0.112: v8(45.47,121.5) 45.83,121.13 45.83,119.13 45.96,119.01 47.58,119.01 47.9,118.69 49.51,118.69 v2(49.75,118.45) 50.04,118.16 51.57,118.16 52.1,118.69 52.45,118.69
  IN1 w0.066: v10(22.16,117.73) 29.42,117.73 33.07,121.38 38.94,121.38 39.33,120.99 40.85,120.99 41.34,121.48 42.93,121.48 43.26,121.81 44.94,121.81 45.25,121.5 v8(45.47,121.5)
  IN2 w0.066: v10(22.16,117.73) 22.16,119.66 23.68,121.18 23.68,121.86 23.37,122.17 v3(22.13,122.17)
GNSS_OFF#: length 45.9
  TOP w0.076: UCPU1.AN2 54.69,117.66 53.99,117.66 53.6,118.05 52.45,118.05
  TOP w0.112: v8(43.56,121.5) 43.97,121.1 44.21,121.1 45.1,120.21 v2(45.1,119.18) 45.1,118.96 45.6,118.47 47.22,118.47 47.63,118.05 49.32,118.05 49.76,117.62 51.89,117.62 52.32,118.05 52.45,118.05 ; Q29.1 33.64,107.33 33.22,106.91 32.02,106.91 31.79,107.14 31.79,107.81 31.52,108.08 v8(29.71,108.08)
  IN1 w0.066: v8(29.71,108.08) 29.71,108.09 29.28,108.51 29.28,108.52 29.28,115.83 32.1,118.65 34.28,118.65 35.74,120.11 35.74,120.12 35.9,120.28 35.91,120.28 35.99,120.36 38.61,120.36 38.88,120.63 41.18,120.63 41.61,121.06 43.12,121.06 v8(43.56,121.5)
GNSS_OFF#_R: length 18.5
  TOP w0.112: v8(34.29,117.03) 34,117.33 30.19,117.33 26.63,120.88 JNGFF1.26 ; Q29.3 32.99,111.84 33.15,111.99 33.53,111.99 33.71,112.17 v8(33.71,112.41)
  IN1 w0.066: v8(34.29,117.03) 34.33,117.03 34.85,116.51 34.85,112.42 34.43,112 34.11,112 v8(33.71,112.41)
GNSS_SCL: length 8
  TOP w0.112: JNGFF1.40 23.13,123.41 23.38,123.66 23.95,123.66 v3(23.98,123.64)
  IN2 w0.066: v3(23.98,123.64) 23.98,123.46 23.77,123.26 v4(23.7,123.26)
  IN3 w0.066: v6(23.5,123.56) 23.7,123.36 v4(23.7,123.26)
  IN4 w0.066: v1(23.55,125.31) 23.55,125.13 23.32,124.91 23.32,123.74 v6(23.5,123.56)
  BOTTOM w0.112: v1(23.55,125.31) 23.27,125.59 21.31,125.59 21.09,125.38 R219.1
GPP_B22: length 6.8
  TOP w0.066: UCPU1.AN5 56.36,118.2 56.36,118.88 56.12,119.12 52.45,119.12
  TOP w0.112: 52.45,119.12 52.27,119.12 52.12,119.27 v2(52.12,119.32) 52.07,119.32 51.63,119.76 RC65.2
GPP_B23: length 8.8
  TOP w0.066: UCPU1.AM7 57,119.12 56.52,119.12 56.39,119.24 56.39,120.08 56.07,120.4 53.88,120.4
  TOP w0.112: 53.88,120.4 53.36,120.91 52.58,120.91 52.45,120.78 52.45,120.33 52.2,120.08 51.45,120.08 RC64.1
GPP_C5: length 3.1
  TOP w0.076: 53.34,124.68 UCPU1.W1
  TOP w0.112: 53.34,124.68 53.23,124.68 52.29,123.74 51.3,123.74 RC58.1
GPP_C17: length 16.4
  IN1 w0.066: v8(56.71,125.78) 56.94,125.55 56.94,125.45 56.84,125.35 56.4,125.35 55.95,125.8 55.17,125.8 54.51,125.13 52.68,125.13 52.45,124.91 51.88,124.91 51.67,124.7 47.73,124.7 47.57,124.55 47.57,124.55 47.29,124.27 45,124.27 44.48,123.75 43.4,123.75 43.15,123.5 v8(42.11,123.5)
GPP_E1: length 17.8
  TOP w0.076: 60.88,136.21 59.61,134.94 59.61,132.73 58.9,132.02 58.9,131.23 58.75,131.08 56.34,131.08 55.91,130.65 UCPU1.H3 55.53,130.65 55.11,131.07 53.72,131.07 53.66,131.13 53.34,131.13
  TOP w0.112: v2(62.27,140.02) 62.19,139.94 62.19,138.48 RC204.2 61.72,138.01 61.72,137.05 60.88,136.21 ; 53.34,131.13 52.64,131.13 52.1,131.68 RC41.1
H_CATERR#: length 10.9
  TOP w0.076: 87.5,138.24 87.46,138.2 87.46,137.8 87.19,137.52 87.19,137.16 88.11,136.23 88.11,135.73 88.21,135.62 88.82,135.62 89.03,135.83 89.2,135.83 89.48,135.55 89.48,135.22 89.29,135.03 89.29,134.69 89.32,134.59 89.32,134.4 89.29,134.31 89.29,134.06 89.43,133.58 89.43,133.46 89.46,133.35 89.46,133.13 UCPU1.D63
  TOP w0.112: 87.5,138.24 87.5,138.79 87.5,138.79 87.5,139.26 87.05,139.71 RC7.2 v2(87.05,141.39)
H_CPU_SVIDALRT#: length 12.8
  TOP w0.076: RC22.1 90.22,138.9 90.32,138.9 90.4,138.83 90.4,138.34 90.22,138.16 89.36,138.16 89.28,138.09 89.28,137.92 89.36,137.85 90.22,137.85 90.3,137.77 90.3,137.62 90.22,137.54 89.36,137.54 89.28,137.47 89.28,137.31 89.36,137.24 90.22,137.24 90.3,137.16 90.3,137.01 90.22,136.93 v2(89.66,136.93) 89.41,136.93 89.33,136.86 89.33,136.7 89.41,136.63 90.27,136.63 90.35,136.55 90.35,136.4 90.27,136.32 89.71,136.32 89.64,136.25 89.64,136.09 89.71,136.02 90.35,136.02 90.42,135.94 90.42,135.79 90.35,135.71 90.12,135.71 90.03,135.62 90.03,134.74 89.89,134.6 89.89,134.48 90.03,134.34 90.03,134.24 89.9,134.11 89.78,134.11 UCPU1.B63
H_CPUPWRGD: length 7.6
  TOP w0.076: UCPU1.A68 92.85,134.84 93.44,135.43 94.94,135.43 96.14,134.23 97.16,134.23 97.43,134.51 97.43,135.17 RC39.2
  TOP w0.112: CA4.1 RC39.2
H_CPUPWRGD_R: length 2.1
  TOP w0.112: T7.1 99.57,136.39 RC39.1
H_PECI: length 83.1
  TOP w0.076: UCPU1.A54 84.46,135.13 84.46,135.78 84.07,136.17 84.07,136.21
  TOP w0.112: v7(83.83,137.9) 84.07,137.66 84.07,136.21
  IN3 w0.066: v6(25.92,136.96) 25.92,137.09 26.45,137.62 29.54,137.62 33.75,141.83 36.94,141.83 37.11,141.67 41.33,141.67 42.03,142.37 43.65,142.37 43.85,142.57 50.64,142.57 53.49,139.71 v6(54,139.71)
  IN4 w0.066: v6(25.92,136.96) 25.92,136.78 25.66,136.52 25.66,127.07 24.89,126.3 24.89,125.64 23.87,124.62 23.87,123.95 24.07,123.75 v1(24.07,123.48) ; v6(54,139.71) 54.28,139.43 54.51,139.43 54.64,139.3 56.36,139.3 56.68,139.62 60.26,139.62 60.66,139.23 68.07,139.23 69.16,138.14 71.65,138.14 72.12,138.61 83.12,138.61 v7(83.83,137.9)
  BOTTOM w0.112: v7(83.83,137.9) 84.87,137.9 85.55,137.23 v2(85.55,137)
H_PROCHOT#: length 255.5
  TOP w0.254: v3(95.5,138.95) 95.5,138.93 RC28.2
  IN1 w0.066: v7(91.34,140.4) 91.34,140.37 91.57,140.15 94.31,140.15 v3(95.5,138.95)
  IN2 w0.254: v4(95.21,138.66) v3(95.5,138.95)
  IN3 w0.066: v6(40.21,125.62) 40.21,124.91 40.01,124.7 37.19,124.7 36.04,125.85 32,125.85 30.9,126.95 29.62,126.95 29.35,126.67 28.18,126.67 28.17,126.66 28.14,126.66 v5(28.14,126.67)
  IN3 w0.254: v6(114.46,125.84) 119.55,120.74 122.12,120.74 122.4,120.46 122.4,115.89 122.59,115.7 122.59,101.33 123.39,100.53 123.39,96.57 123.84,96.13 144.78,96.13 145.53,96.88 v6(145.53,103.86) ; v6(145.53,106.47) 145.53,115.29 146.9,116.66 146.9,123.37 v5(147.28,123.75) ; v4(95.21,138.66) 95.12,138.57 v6(95.12,138.24)
  IN4 w0.066: v7(91.34,140.4) 91.24,140.5 91.24,140.73 88.85,143.12 79.92,143.12 79.4,143.64 73.47,143.64 72.95,143.12 64.19,143.12 63.12,144.18 63.12,147.39 63.8,148.07 63.8,148.91 63.63,149.09 63.1,149.09 59.99,145.98 v1(58.24,145.98) 58.24,147.11 58.6,147.46 58.6,149.8 56.08,152.31 54.38,152.31 53.67,153.02 44.02,153.02 42.95,151.95 42.95,148.79 41.79,147.63 41.79,143.93 39.01,141.15 39.01,135.34 39.24,135.1 39.24,134.9 39.25,134.89 39.25,132.34 39.24,132.34 39.24,131.44 38.85,131.06 38.85,130.13 39.11,129.88 39.11,127.74 40.21,126.63 v6(40.21,125.62)
  IN4 w0.254: v5(147.28,123.75) 146.96,124.07 146.96,126.76 146.75,126.97 146.75,129.95 144.86,131.84 143.99,131.84 143.86,131.71 140.89,131.71 140.52,132.08 138.73,132.08 v1(138.37,131.71) ; v6(114.46,125.84) 112.59,127.7 109.62,127.7 108.13,126.2 v5(108.13,125.99) 106.06,125.99 105.93,126.11 99.69,126.11 97.35,128.46 97.35,130.75 95.63,132.46 95.63,135.19 94.81,136.02 94.81,136.88 95.12,137.2 v6(95.12,138.24) ; v6(145.53,103.86) v6(145.53,106.47)
  BOTTOM w0.112: RE50.2 27.6,126.19 28.04,126.63 28.08,126.63 28.12,126.66 28.14,126.66 v5(28.14,126.67) ; v2(138.79,132.72) 138.37,132.3 v1(138.37,131.71)
  BOTTOM w0.254: PR600.1 109.94,120.16 110.81,121.02 110.81,123.77 108.59,125.99 v5(108.13,125.99)
H_PROCHOT#_R: length 26.1
  TOP w0.076: UCPU1.C65 90.84,133.65 91.03,133.83 91.11,134.08 91.11,134.26 91.05,134.45 91.05,134.6 91.11,134.71 91.11,135.44 91.92,136.25 91.92,137.23 92.05,137.35 92.23,137.35 92.31,137.28 92.31,136.23 92.38,136.16 92.53,136.16 92.61,136.23 92.61,137.28 92.69,137.35 92.84,137.35 92.92,137.28 92.92,136.23 92.99,136.16 93.14,136.16 93.22,136.23 93.22,137.28 93.3,137.35 93.45,137.35 93.52,137.28 93.52,136.23 93.6,136.16 93.75,136.16 93.83,136.23 93.83,137.28 93.91,137.35 94.06,137.35 94.13,137.28 94.13,136.23 94.21,136.16 94.36,136.16 94.44,136.23 94.44,137.28 94.52,137.35 94.67,137.35 94.74,137.28 94.74,136.23 94.82,136.16 94.97,136.16 95.05,136.23 95.05,137.28 95.13,137.35 95.33,137.35 95.4,137.28 95.4,136.31 95.53,136.18 95.63,136.18 95.76,136.31 95.76,137.14 95.89,137.27 96,137.27 96.11,137.15 96.11,136.01 96.19,135.93 96.37,135.93 96.44,136.01 96.44,137.14 96.62,137.32 96.62,137.5 96.54,137.58 96.01,137.58 95.94,137.66 95.94,137.91 95.81,138.04 RC27.2
H_THERMTRIP#: length 107.8
  TOP w0.112: v3(88.93,140.27) 88.98,140.32 88.98,140.96 RC389.1
  IN2 w0.066: v3(88.93,140.27) v4(88.57,140.27)
  IN3 w0.066: v5(16.62,122.19) 15.28,123.53 11.66,123.53 10.87,124.33 10.87,128.04 9.19,129.71 9.19,134.4 9.44,134.64 9.77,134.64 9.99,134.42 10.82,134.42 10.88,134.36 19.6,134.36 19.63,134.37 21.65,134.37 22.49,133.53 32.2,133.53 33.73,135.06 33.73,135.69 32.91,136.5 32.91,137.76 33.75,138.6 34.74,138.6 35.78,138.6 36.17,138.22 36.28,138.22 36.4,138.1 37.5,138.1 37.62,138.22 41.5,138.22 41.51,138.23 v6(41.76,138.23) ; v4(88.57,140.27) 88.42,140.27 v6(88.19,140.5)
  IN4 w0.066: v6(41.76,138.23) 42.81,138.23 46.41,141.82 53.98,141.82 54.46,141.34 54.81,141.34 54.99,141.16 61.87,141.16 62.28,140.76 70.11,140.76 70.18,140.83 74.22,140.83 74.88,141.49 76.4,141.49 76.63,141.27 78.23,141.27 78.76,140.75 87.93,140.75 88.18,140.49 v6(88.19,140.5)
  BOTTOM w0.112: v5(16.62,122.19) 16.61,122.18 QE16.3
H_THERMTRIP#_R: length 10.2
  TOP w0.076: 88.01,138.24 RC20.2 87.39,137.47 87.39,137.24 88.29,136.34 88.29,135.88 88.39,135.78 88.75,135.78 88.95,135.98 89.28,135.98 89.68,135.58 89.68,135.2 89.45,134.98 89.45,134.71 89.51,134.6 89.51,134.45 89.45,134.26 89.45,134.08 89.54,133.83 89.57,133.8 89.57,133.67 UCPU1.C63
  TOP w0.112: RC389.2 88.39,140.63 88.39,139.74 88.52,139.61 88.52,138.75 88.01,138.24
H_VCCST_PWRGD_P: length 220.4
  TOP w0.112: RC25.2 RC26.1 CA3.1 v2(95.62,140.03) 95.92,140.32 99.64,140.32 100.89,139.08 v3(104.72,139.08)
  IN1 w0.066: v10(116.08,144.87) 116.08,145.1 117.22,146.24 117.22,150.06 113.92,153.36 113.92,154.17 110.8,157.29 109.35,157.29 107.94,158.7 107.94,162.93 108.27,163.26 108.27,163.9 v7(107.23,164.94)
  IN2 w0.066: v3(104.72,139.08) 104.75,139.1 v4(105.21,139.1) ; v4(147.29,134.72) 146.71,134.72 146.38,134.39 133.97,134.39 133.3,135.07 130.43,135.07 129.95,134.59 125.16,134.59 124.97,134.78 116.91,134.78 113.68,138.02 113.68,141 114.68,142 114.68,143.02 v4(116.08,144.41) v10(116.08,144.87)
  IN3 w0.066: v4(147.29,134.72) 147.46,134.72 148.07,134.11 v6(148.07,132.48) ; v4(116.08,144.41) 110.52,144.41 108.75,142.65 108.75,139.73 108.13,139.1 v4(105.21,139.1)
  IN4 w0.066: v1(147.78,127.65) 147.57,127.85 147.57,130.25 148.07,130.75 v6(148.07,132.48) ; v5(37.87,122.16) 37.87,122.39 37.72,122.55 37.72,122.77 37.66,122.83 37.66,123.62 37.45,123.82 37.45,124.7 36.59,125.55 36.59,129.39 36.42,129.55 36.42,131.79 37.34,132.7 37.34,133.64 37.57,133.87 37.57,136.85 37.62,136.91 37.62,142.26 40.07,144.7 40.07,145.15 40.58,145.67 40.58,148.1 41.57,149.09 41.57,155.65 40.43,156.79 40.43,163.36 40.43,163.45 41.54,164.56 106.57,164.56 106.95,164.94 v7(107.23,164.94)
  BOTTOM w0.112: v1(147.78,127.65) 147.61,127.65 147.43,127.47 147.43,126.95 147.9,126.48 148.82,126.48 RC132.1
H_VCCST_PWRGD_XDP: length 4.7
  BOTTOM w0.112: RC132.2 RC131.2 152.07,129.7 JXDP1.39
HDA_BLK: length 143.5
  TOP w0.112: v8(67.82,107.94) 68.71,108.83 CC17.1
  IN1 w0.066: v10(32.89,75.12) 44.18,75.12 48.77,79.71 48.77,84.88 52.44,88.55 53.49,88.55 54,89.05 57.65,89.05 65.49,96.9 65.49,103.14 66.51,104.15 66.51,106.63 v8(67.82,107.94)
  IN2 w0.066: v10(32.89,75.12) 32.89,75.31 32.43,75.77 32.43,83.97 32.45,83.99 32.45,88.52 32.23,88.74 32.23,89.55 32.15,89.63 32.15,90.17 32.18,90.2 32.18,97.4 32.34,97.55 32.34,98.93 30.74,100.53 30.74,106.94 29.66,108.02 29.66,114.65 29.54,114.78 29.54,122.45 30.81,123.72 v4(30.81,124.88)
  IN3 w0.066: v6(16.2,127.19) 18.66,127.19 19.56,126.29 27.19,126.29 27.38,126.1 28.98,126.1 28.99,126.11 29.36,126.11 30.18,125.28 30.52,125.28 30.81,124.98 v4(30.81,124.88)
  IN4 w0.066: v6(16.2,127.19) 16.2,127.37 15.84,127.73 15.84,128.69 17,129.84 17,132.98 19.18,135.16 19.18,136.27 22.2,139.28 22.2,140.39 22.72,140.91 v1(23.37,140.91)
  BOTTOM w0.112: RA16.2 23.75,141.29 v1(23.37,140.91)
HDA_BLK_L: length 3.1
  BOTTOM w0.112: CA37.1 RA16.1 23.75,142.81 24.09,143.16 v2(24.09,143.27) 24.09,143.42 23.91,143.6 UA1.8
HDA_BLK_R: length 5.5
  IN1 w0.076: v8(67.82,108.85) 67.82,109.67 66.24,111.25 66.24,111.65 66.48,111.9 66.48,113.15 v8(66.14,113.5)
HDA_SDI0: length 151
  TOP w0.112: CC94.1 67.31,107.6 67.31,109.43 66.95,109.79 v2(66.5,109.79) 65.94,109.79 v8(65.91,109.82)
  IN1 w0.066: v10(33.79,76.03) 42.04,76.03 47.53,81.52 47.53,83.16 47.8,83.43 47.8,85.15 52.04,89.38 52.64,89.38 53.5,90.24 57.66,90.24 64.66,97.25 64.66,103.51 65.1,103.95 65.1,105.83 65.25,105.98 65.25,106.87 65.4,107.02 65.4,108.84 65.91,109.35 v8(65.91,109.82) 65.91,110.39 65.4,110.9 65.4,112.45 65.57,112.63 v8(65.57,113.17)
  IN2 w0.066: v4(32.87,123.97) 32.79,123.97 31.85,123.03 31.29,123.03 30.37,122.11 30.37,115.12 30.5,115 30.5,108.36 31.57,107.29 31.57,107.02 32.38,106.21 32.38,100.06 33.17,99.28 33.17,91.25 33.65,90.77 33.65,84.01 33.3,83.67 33.3,76.52 v10(33.79,76.03)
  IN3 w0.066: v6(16.03,126.02) 16.74,125.31 16.74,124.96 17.41,124.29 19.6,124.29 19.97,124.66 28.68,124.66 28.77,124.57 29.08,124.57 29.67,123.98 31.06,123.98 31.15,123.9 31.97,123.9 32.08,123.79 32.16,123.71 32.54,123.71 32.79,123.97 v4(32.87,123.97)
  IN4 w0.066: v1(21.97,141.47) 21.95,141.49 21.69,141.49 20.02,139.82 20.02,138.5 16.2,134.68 16.2,133.88 14.62,132.3 14.62,127.43 v6(16.03,126.02)
HDA_SDI0_L: length 2.5
  BOTTOM w0.112: UA1.10 23.11,143.34 22.68,142.91 22.5,142.91 RA17.1
HDA_SDOUT: length 147.2
  TOP w0.112: RC81.2 v8(65.8,107.08) ; RC81.2 RC76.1 ; RC81.2 67.01,107.08 v2(67.74,106.34)
  IN1 w0.066: v8(65.8,107.08) 65.48,106.76 65.48,105.94 65.3,105.75 65.3,103.87 64.85,103.43 64.85,97.17 57.74,90.05 53.58,90.05 52.72,89.19 52.12,89.19 48.01,85.08 48.01,83.3 47.72,83.02 47.72,81.44 42.05,75.77 33.56,75.77 v10(33.47,75.85)
  IN2 w0.066: v10(33.47,75.85) 33.11,76.21 33.11,83.75 33.46,84.09 33.46,90.69 32.98,91.17 32.98,99.2 32.19,99.99 32.19,106.13 31.38,106.94 31.38,107.21 30.3,108.28 30.3,114.92 30.18,115.04 30.18,122.19 32.09,124.09 v4(32.28,124.09)
  IN3 w0.066: v4(32.28,124.09) 31.23,124.09 31.14,124.18 29.92,124.18 29.92,124.18 29.74,124.18 29.09,124.83 v5(28.88,124.83) 28.69,125.02 26.93,125.02 26.74,125.2 20.24,125.2 19.52,124.48 17.49,124.48 16.94,125.03 16.94,125.52 v6(16.08,126.38)
  IN4 w0.066: v6(16.08,126.38) 14.81,127.64 14.81,132.22 16.41,133.81 16.41,134.53 20.29,138.42 20.29,139.79 21.21,140.7 21.58,140.7 22.71,141.84 v5(22.71,143.46)
  BOTTOM w0.112: RC92.2 28.83,124.83 v5(28.88,124.83) ; v5(22.71,143.46) UA1.11
HDA_SDOUT_R: length 3.9
  IN1 w0.066: v8(66.14,112.19) 65.79,111.84 65.79,111.06 66.8,110.04 v8(66.8,108.85)
HDA_SYNC: length 143.9
  IN1 w0.066: v8(65.91,107.94) 66.06,107.79 66.06,104.34 65.05,103.33 65.05,97.09 57.82,89.86 53.66,89.86 52.8,89 52.21,89 48.31,85.1 48.31,81.75 42.13,75.57 33.73,75.57 33.73,75.57 33.35,75.57 v10(33.1,75.82)
  IN2 w0.066: v4(31.52,124.58) 31.52,123.8 29.99,122.27 29.99,114.96 30.11,114.84 30.11,108.2 31.19,107.13 31.19,100.72 32.78,99.12 32.78,91.09 33.26,90.61 33.26,84.17 32.91,83.82 32.91,76.01 v10(33.1,75.82)
  IN3 w0.066: v4(31.52,124.58) 31.32,124.37 29.82,124.37 28.98,125.21 27.01,125.21 26.82,125.4 20.1,125.4 19.38,124.67 17.58,124.67 17.21,125.05 17.21,125.66 16.13,126.73 v6(16.13,126.79)
  IN4 w0.066: v6(16.13,126.79) 15.39,127.52 15.39,128.87 15.75,129.23 15.75,132.36 17.05,133.66 17.05,134.77 20.9,138.62 20.9,139.76 23.51,142.36 v1(23.51,143.46)
  BOTTOM w0.112: v1(23.51,143.46) UA1.9
HDA_SYNC_R: length 4.7
  IN1 w0.066: v8(65.91,108.85) 66.29,109.23 66.29,110.28 65.59,110.98 65.59,112.3 v8(66.14,112.85)
HOME_KEY#: length 164
  TOP w0.112: v3(134.39,94.43) 134.45,94.37 v2(134.45,93.28) JIO1.20
  IN2 w0.066: v4(134.41,92.92) 134.41,94.41 v3(134.39,94.43)
  IN3 w0.066: v6(134.41,92.48) v4(134.41,92.92) ; v6(67.18,82.47) 66.29,83.37 54.64,83.37 53.09,84.91 51.31,84.91 50.73,85.5 45.56,85.5 41.72,89.33 41.17,89.33 40.98,89.14 39.05,89.14 39.04,89.15 38.88,89.15 38.36,89.67 38.36,89.71 37.65,90.42 37.61,90.42 36.5,91.53 34.54,91.53 33.05,93.03 29.05,93.03 28.67,92.65 v6(18.95,92.65)
  IN4 w0.066: v6(67.18,82.47) 68.05,83.34 68.7,83.34 68.85,83.5 68.85,84.39 69.44,84.97 69.75,84.97 70.56,85.77 74.4,85.77 78.36,89.74 94.72,89.74 95.17,89.29 109.73,89.29 113.77,93.33 122.96,93.33 123.6,93.97 126.29,93.97 126.66,93.6 128.11,93.6 128.59,93.12 130.83,93.12 132.05,91.9 133.06,91.9 133.61,92.45 133.61,92.61 133.74,92.74 134.15,92.74 v6(134.41,92.48) ; v6(18.95,92.65) 18.83,92.77 18.83,94.08 17.45,95.46 17.45,96.1 15.74,97.81 15.74,103 15.97,103.24 15.97,106.64 16.6,107.26 16.6,107.83 18.86,110.09 18.86,111.67 18.86,111.68 18.86,112.21 18.86,113.25 19.33,113.72 19.38,113.72 v1(19.39,113.73) 19.64,113.98 19.64,115.64 19.77,115.76 v1(19.81,115.76)
  BOTTOM w0.076: v1(19.81,115.76) 20.07,115.51 22.48,115.51 22.73,115.25 22.73,114.87 22.86,114.75 23.65,114.75 23.74,114.84 24,114.84 24.36,115.2 UE3.H9
  BOTTOM w0.112: v1(19.39,113.73) 19.33,113.67 RE62.1
HOST_DEBUG_TX: length 53.4
  TOP w0.112: RE1.2 32.96,89.1 v3(32.96,89.32) 32.61,89.66 32.61,89.91 33.02,90.31 v2(33.08,90.31) 33.9,91.12 33.9,91.21 34.77,92.09 35.29,92.09 35.71,91.68 JDEG3.8
  IN2 w0.066: v4(32.58,89.03) 32.87,89.32 v3(32.96,89.32)
  IN3 w0.066: v6(20.27,90.01) 20.49,89.78 31.44,89.78 32.19,89.03 v4(32.58,89.03)
  IN4 w0.066: 20.9,114.14 20.9,113.73 19.59,112.41 19.59,109.79 17.52,107.73 17.52,107.34 16.89,106.71 16.89,105.19 16.65,104.96 16.65,103.12 17.38,102.4 17.38,98.56 18.03,97.91 18.72,97.91 19.74,96.89 19.74,94.53 20.34,93.92 20.34,90.08 v6(20.27,90.01) ; v1(25.2,116.37) 25.12,116.3 24.21,116.3 24.03,116.12 23.39,116.12 22.89,115.61 22.33,115.61 22.05,115.33 22.05,114.97 21.78,114.71 21.4,114.71 20.9,114.21
  IN4 w0.076: 20.9,114.21 20.9,114.14
  BOTTOM w0.076: v1(25.2,116.37) 25.53,116.7 UE3.G11
HOST_SD_WP#: length 187.2
  IN1 w0.066: v7(68.68,27.83) 50.36,46.15 50.36,66.51 43.5,73.37 36.69,73.37 35.59,72.26 23.43,72.26 22.61,73.08 22.61,76.55 22.58,76.58 22.58,80.18 21.97,80.8 21.97,89.75 23.26,91.04 23.26,98.91 23.62,99.27 23.62,104.6 20.97,107.24 19.54,107.24 17.47,109.32 17.47,117.13 19.26,118.92 19.26,122.7 20.68,124.12 20.68,124.34 21.08,124.74 21.08,125.53 21.36,125.82 25.39,125.82 28.3,122.91 32.85,122.91 33.12,123.18 36.66,123.18 39.44,125.96 42.64,125.96 44.2,127.52 45.53,127.52 v8(45.92,127.13) 46.57,127.13 47.14,126.56 49.71,126.56 49.76,126.51 53.67,126.51 54.08,126.93 55.79,126.93 56.03,127.18 58.23,127.18 58.79,126.63 58.79,125.98 59.69,125.08 59.69,124.59 59.52,124.42 55.65,124.42 55.4,124.17 55.4,123.48 v8(55.28,123.36)
  BOTTOM w0.112: QR1.2 68.42,28.08 v7(68.68,27.83) 68.41,27.56 68.03,27.56 v2(67.86,27.38)
HP2: length 4.7
  BOTTOM w0.203: UA1.48 27.92,145.18 28.07,145.04 28.07,143.75 28.49,143.32 30.57,143.32 RA40.2
HP_PLUG#: length 45.9
  IN3 w0.066: v5(7.2,161.36) 7.2,158.22 8.54,156.88 14.51,156.88 16.38,155.01 16.38,153.33 13.36,150.31 13.36,148.22 13.5,148.08 13.5,144.27 14.17,143.6 19.3,143.6 19.84,143.06 25.91,143.06 26.97,142 27.81,142 28.63,142.82 30.4,142.82 v5(30.66,142.56)
  BOTTOM w0.112: v2(6.27,162.61) 6.27,162.28 v5(7.2,161.36)
HP_PLUG#_R: length 13.3
  IN4 w0.254: v7(7.82,163) 7.82,164.64 11.6,168.42 11.6,171.01 11.46,171.15 JP1.6
  BOTTOM w0.112: v2(7.82,163.61) v7(7.82,163)
  BOTTOM w0.254: v7(7.82,163) DA6.1 7.82,161.39 RA7.2
HPOL_CONN: length 11.5
  IN3 w0.254: JP1.1 6.66,167.53 11.18,163 v7(11.18,162.93)
  BOTTOM w0.127: v7(11.18,162.93) 11.18,163.15 v2(10.81,163.53)
  BOTTOM w0.254: L19.2 11.6,160.14 11.2,160.54 CA50.1 11.18,160.74 DA5.1 v7(11.18,162.93)
HPOR_CONN: length 12.2
  IN3 w0.254: JP1.2 4.2,167.87 v7(9.14,162.94)
  BOTTOM w0.127: L18.2 v2(7.43,159.83)
  BOTTOM w0.254: v7(9.14,162.94) DA4.1 9.07,162.18 CA49.1 8.47,160.12 L18.2
HPOUT-L: length 17.5
  IN4 w0.254: v1(21.92,152.34) 21.92,152.36 17.03,157.25 12.64,157.25 v1(12.01,157.88)
  BOTTOM w0.127: v2(12.29,156.55) 12,156.85 12,157.86
  BOTTOM w0.203: UA1.26 22.71,151.09
  BOTTOM w0.254: 12,157.86 v1(12.01,157.88) 11.96,157.93 CA12.2 11.52,158.83 RA6.1 ; v1(21.92,152.34) 21.92,151.93 22.71,151.14 22.71,151.09
HPOUT-L_L: length 0.9
  BOTTOM w0.254: RA6.2 10.72,159.39 10.75,159.42 L19.1
HPOUT-R: length 20
  IN4 w0.254: v1(20.14,152.34) 20.14,153.42 16.82,156.74 11.85,156.74 11.31,157.29 8.81,157.29 v1(8.19,157.92)
  BOTTOM w0.076: 21.43,151.45 v2(21.45,151.45)
  BOTTOM w0.203: 22.14,151.12 22.31,150.95 UA1.25
  BOTTOM w0.254: v1(8.19,157.92) 8.19,157.93 CA10.2 8.67,158.7 RA3.1 ; v1(20.14,152.34) 20.31,152.17 20.31,151.83 20.69,151.45 21.43,151.45 ; 22.14,151.12 21.81,151.45 v2(21.45,151.45)
HPOUT-R_L: length 3.5
  BOTTOM w0.127: v2(7.47,158.55) 7.47,158.89 7.96,159.39 8.78,159.39 9.22,158.94 RA3.2
  BOTTOM w0.254: RA3.2 9.35,159.8 L18.1
I2C0_IRQ_TS: length 143.6
  IN2 w0.066: v4(56.32,128.98) 56.58,128.98 v3(56.71,128.85) ; v3(84.97,21.7) 84.41,22.26 76.64,22.26 76.45,22.07 72.99,22.07 72.4,22.66 70.09,22.66 v7(69.6,22.16)
  IN3 w0.066: v5(54.52,129.59) 54.52,129.48 55.02,128.98 v4(56.32,128.98)
  IN4 w0.066: v7(69.6,22.16) 69.27,22.16 57.42,34.01 57.42,70.44 56.89,70.97 56.89,82.8 55.49,84.19 55.49,90.31 55.09,90.71 55.09,94.04 53.83,95.31 53.83,97.89 53.66,98.05 53.66,101.73 53.25,102.14 53.25,104.79 51.44,106.6 51.44,109.18 51.72,109.47 51.72,109.9 51.4,110.22 51.4,115.36 50.77,115.99 50.77,116.81 50.49,117.09 50.49,117.18 50.49,117.49 50.49,117.5 50.49,117.71 49.41,118.79 49.41,120.55 47.42,122.54 47.42,123.16 47.42,123.16 47.42,123.57 47.7,123.85 47.7,126.32 48.67,127.29 48.67,127.29 49.36,127.98 52.39,127.98 53.18,128.77 53.18,129.54 53.43,129.79 54.09,129.79 54.22,129.66 54.44,129.66 v5(54.52,129.59)
  BOTTOM w0.112: v5(54.52,129.59) 53.77,128.84 RC194.2 ; v2(69.98,21.77) 69.98,21.78 v7(69.6,22.16)
I2C1_CLK_PD1: length 5.9
  IN3 w0.066: v5(33.69,63.83) 33.51,64.01 33.51,64.14 33.15,64.5 30.59,64.5 30.33,64.24 29.55,64.24 v5(29.16,64.63)
  BOTTOM w0.112: RT26.2 29.12,65.01 29.16,64.97 v5(29.16,64.63)
I2C1_CLK_PD2_C: length 5.4
  IN3 w0.066: v5(57.13,16.1) 57.29,15.95 57.54,15.95 58.99,14.5 58.99,13.57 58.64,13.22 58.64,13.01 58.71,12.94 v5(59.05,12.94)
  BOTTOM w0.112: v5(59.05,12.94) RT92.2
I2C1_DAT_PD1: length 5.6
  IN3 w0.066: v5(29.16,63.74) 29.49,64.07 30.4,64.07 30.66,64.33 33.08,64.33 33.34,64.07 33.34,63.99 v5(33.19,63.83)
  BOTTOM w0.112: RT30.2 29.12,63.27 29.16,63.3 v5(29.16,63.74)
I2C1_DAT_PD2_C: length 5
  IN3 w0.066: v5(57.13,15.6) 57.29,15.75 57.46,15.75 58.8,14.42 58.8,13.65 58.45,13.3 58.45,13.01 58.38,12.94 v5(58.1,12.94)
  BOTTOM w0.112: v5(58.1,12.94) 58.1,12.63 58.04,12.57 RT93.2
I2C1_INT#_PD1: length 6.3
  BOTTOM w0.112: RT33.2 29.18,60.24 29.22,60.28 RT32.2 29.22,61.32 29.53,61.62 29.53,61.98 29.72,62.17 31.47,62.17 32.64,63.33 UT1.C1
I2C1_INT#_PD2_C: length 8.3
  BOTTOM w0.112: UT2.C1 57.63,11.4 57.8,11.24 60.24,11.24 60.62,11.62 RT95.2 RT94.2
I2C1_SCK_TS: length 165.1
  TOP w0.112: v8(44.75,124.65) 44.5,124.91 44.5,126.1 44.63,126.23 CC99.1
  IN1 w0.066: v10(38.2,122.88) 38.57,123.25 40.92,123.25 41.67,124 42.62,124 42.87,124.25 43.99,124.25 44.46,124.72 44.69,124.72 v8(44.75,124.65) 44.91,124.81 47.04,124.81 47.38,125.15 51.91,125.15 52.15,125.39 53.95,125.39 54.6,126.04 57.47,126.04 57.77,125.74 57.77,125.61 57.91,125.47 58.08,125.47 58.38,125.78 v8(58.66,125.78)
  IN2 w0.066: v4(37.82,122.8) 37.9,122.88 v10(38.2,122.88)
  IN3 w0.066: v6(38.18,122.92) 38.05,122.8 v4(37.82,122.8) ; v5(78.8,26.6) 78.42,26.21 78.42,21.75 78.05,21.38 77.23,21.38 v7(77.03,21.17) 76.86,21.34 76.03,21.34 75.54,21.83 75.54,23.21 72.59,26.15 53.57,26.15 v6(53.52,26.2)
  IN4 w0.066: v6(38.18,122.92) 38.47,122.92 38.73,122.66 38.73,113.68 39.4,113.01 39.4,112.36 39.41,112.34 39.41,107.39 39.59,107.21 39.59,106.7 39.59,106.7 39.59,106.33 39.59,106.33 39.59,101.02 41.27,99.33 41.27,98.26 41.02,98 41.02,97.35 41.21,97.16 41.21,95.76 41.16,95.7 41.16,94.67 41.26,94.57 41.26,89.54 40.97,89.25 40.97,87.12 43.55,84.54 43.55,80.9 43.82,80.63 43.82,79.5 43.55,79.23 43.55,74.46 47.95,70.06 47.95,53.19 52.55,48.59 52.55,27.55 53.52,26.59 v6(53.52,26.2)
  BOTTOM w0.112: v7(77.03,21.17) 77.18,21.32 77.46,21.32 R421.1 ; v5(78.8,26.6) RC50.2 v2(79.84,27.56)
I2C1_SDA_TS: length 161.5
  IN1 w0.066: v10(38.2,123.47) 38.22,123.45 40.84,123.45 41.59,124.19 42.54,124.19 42.79,124.44 43.91,124.44 44.75,125.29 v8(45.01,125.29) 45.29,125 46.96,125 47.3,125.34 51.83,125.34 52.07,125.58 53.87,125.58 54.52,126.24 57.55,126.24 v8(58.01,125.78)
  IN2 w0.066: v10(38.2,123.47) 38.11,123.47 37.95,123.31 v4(37.9,123.31)
  IN3 w0.066: v5(77.91,26.61) 78.23,26.29 78.23,26.29 78.23,21.83 77.97,21.57 77.19,21.57 v7(77.03,21.73) 76.82,21.53 76.11,21.53 75.73,21.91 75.73,23.29 72.67,26.35 53.89,26.35 v6(53.81,26.43) ; v4(37.9,123.31) 38.2,123.31 v6(38.23,123.28)
  IN4 w0.066: v6(53.81,26.43) 53.81,26.57 52.75,27.63 52.75,48.67 48.15,53.27 48.15,70.14 43.74,74.54 43.74,79.15 44.02,79.42 44.02,80.71 43.74,80.98 43.74,84.62 41.17,87.2 41.17,89.17 41.46,89.46 41.46,94.65 41.35,94.75 41.35,95.62 41.41,95.68 41.41,97.24 41.22,97.43 41.22,97.92 41.47,98.18 41.47,99.41 39.78,101.1 39.78,106.25 39.78,107.29 39.6,107.47 39.6,112.42 39.59,112.44 39.59,113.09 39.39,113.3 38.93,113.76 38.93,122.74 38.55,123.12 38.39,123.12 v6(38.23,123.28)
  BOTTOM w0.112: v7(77.03,21.73) 77.19,21.57 77.47,21.57 R420.1 ; v5(77.91,26.61) RC48.2 v2(76.94,27.56)
I2C2_CLK_PD1: length 3.4
  IN4 w0.066: v1(35.69,60.87) 35.5,61.06 35.5,61.64 35.75,61.89 35.75,62.49 35.54,62.7 35.32,62.7 v1(35.19,62.83)
  BOTTOM w0.112: RT43.2 36.17,60.87 v1(35.69,60.87)
I2C2_CLK_PD2: length 5.3
  IN4 w0.066: v1(61.54,19.24) 61.54,18.9 61.48,18.83 59.24,18.83 58.29,17.88 58.29,17.66 58.22,17.6 v1(58.13,17.6)
  BOTTOM w0.112: RT63.2 v1(61.54,19.24)
I2C2_DAT_PD1: length 3.1
  IN4 w0.066: v1(35.12,60.87) 35.31,61.06 35.31,61.72 35.56,61.97 35.56,62.41 35.46,62.51 35.36,62.51 v1(35.19,62.33)
  BOTTOM w0.112: RT44.2 34.63,60.87 v1(35.12,60.87)
I2C2_DAT_PD2: length 5
  IN4 w0.066: v1(58.63,17.6) 58.55,17.6 58.48,17.66 58.48,17.8 59.32,18.64 61.48,18.64 61.54,18.57 v1(61.54,18.23)
  BOTTOM w0.112: RT66.2 v1(61.54,18.23)
I2C2_INT#_PD1: length 4.1
  BOTTOM w0.076: 35.5,61.79 35.43,61.85 35.43,62.58 UT1.B6
  BOTTOM w0.112: 35.5,61.79 35.81,61.47 36.42,61.47 RT38.2 37.88,60.68 RT42.2
I2C2_INT#_PD2: length 5.1
  IN4 w0.066: v1(58.13,18.1) 59.31,19.28 60.7,19.28 v1(61.54,20.12)
  BOTTOM w0.112: v1(61.54,20.12) RT61.2
I_ADP: length 47.1
  IN3 w0.066: v6(34.65,102.59) 34.31,102.59 33.17,101.45 29.52,101.45 27.09,103.89 25.36,103.89 24.09,105.15 19.81,105.15 18.52,103.86 17.61,103.86 v5(17.51,103.77)
  IN4 w0.066: v6(34.65,102.59) 34.17,103.07 34.17,105.81 33.54,106.43 32.73,106.43 31.9,107.27 31.5,107.27 30.21,108.56 30.21,111.63 29.93,111.91 29.93,114.53 30.02,114.62 30.24,114.62 30.69,115.06 30.69,115.33 30.69,116.05 29.87,116.87 v1(29.87,117.15)
  BOTTOM w0.076: 31.3,119.19 30.61,118.51 30.61,118.29 30.45,118.12 30.44,118.12 30.04,117.72 30.04,117.32 v1(29.87,117.15) UE3.B11
  BOTTOM w0.112: 31.3,119.19 32.34,120.24 32.42,120.24 32.74,120.56 CE15.1 32.6,121.26 32.3,121.56 PC350.1 31.19,122.38 PR328.2 ; RE124.2 18.22,104.76 17.51,104.05 v5(17.51,103.77)
I_BATT: length 10
  BOTTOM w0.076: 18.98,105.86 18.98,106.78 19.08,106.87 19.3,106.87 19.74,107.3 19.74,107.48 19.93,107.67 20,107.67 20.42,108.09 20.42,108.9 20.64,109.12 20.65,109.12 21.24,109.71 21.24,109.72 21.41,109.89 21.63,109.89 21.96,110.22 21.96,110.44 22.28,110.76 22.29,110.76 22.74,111.22 22.74,111.22 23.01,111.49 23.64,111.49 UE3.J4
  BOTTOM w0.112: RE124.1 18.55,105.4 CE19.1 18.98,105.42 18.98,105.86
I_SYS: length 8.9
  BOTTOM w0.076: UE3.J5 24.1,111.83 24.14,111.83 24.36,111.61 24.36,110.82 24.21,110.67 24.21,110.28 24.05,110.12 23.02,110.12 22.69,109.78 22.69,109.56 22.44,109.32 22.22,109.32 21.87,108.96 21.87,108.52 22.05,108.35 22.05,108.07 21.54,107.56 21.5,107.56 21.31,107.37 21.31,107.23 CE13.1 20.69,106.61 20.69,105.86
  BOTTOM w0.112: RE125.1 20.69,105.86
ILEDA: length 3.8
  IN4 w0.066: v1(151.55,143.56) 151.61,143.62 151.61,144.15 151.87,144.4 151.87,145 152.69,145.82 v1(153.8,145.82)
ILEDB: length 7.7
  IN4 w0.066: v1(155.22,149.04) 155.22,147.88 154.56,147.22 v1(154.32,147.22) 153.85,147.22 151.29,144.66 151.29,144.3 151.45,144.14 151.45,143.83 151.18,143.56 v1(151.15,143.56)
ILMT_1.0VA: length 2.6
  TOP w0.254: PU700.13 131.32,140.15 131.51,140.34 PR707.2 PR708.2
IMVP_SMBCLK: length 67.5
  TOP w0.112: RE270.1 28.19,109.99 v3(27.92,109.71)
  IN1 w0.066: v3(27.92,109.71) 27.94,109.71 27.94,110.56 28.83,111.44 28.83,115.68 31.99,118.84 34.19,118.84 35.94,120.59 38,120.59 v10(38.13,120.72)
  IN2 w0.066: v10(38.13,120.72) 38.15,120.72 38.56,121.12 v4(38.63,121.12) ; v3(27.92,109.71) 27.92,110.08 v4(27.99,110.15)
  IN3 w0.066: v4(38.63,121.12) 40.08,121.12 v6(40.11,121.15) ; v6(40.07,144.21) 43.66,144.21 44.6,143.27 53.67,143.27 54.74,144.34 v5(54.74,144.49) ; v5(28.42,110.15) v4(27.99,110.15)
  IN4 w0.066: v6(40.07,144.21) 40.07,143.61 38.06,141.6 38.06,134.55 38.13,134.48 38.13,133.77 37.85,133.49 37.85,132.5 37.47,132.12 37.47,127.65 37.95,127.16 37.95,126.56 38.15,126.35 38.35,126.35 38.71,126 38.71,124.55 40.21,123.05 40.21,121.93 40.34,121.81 40.34,121.53 40.11,121.3 v6(40.11,121.15)
  BOTTOM w0.076: v5(28.42,110.15) 28.42,110.58 28.57,110.73 28.88,110.73 29.06,110.56 29.06,110.5 29.16,110.4 UE3.B3
  BOTTOM w0.112: PR922.1 56.45,144.78 56.16,144.49 v5(54.74,144.49)
IMVP_SMBDAT: length 64.8
  TOP w0.112: RE269.1 28.07,111.06 28.07,111.7 v3(28.19,111.83)
  IN1 w0.066: v10(38.13,121.1) 37.8,120.77 35.88,120.77 34.12,119 31.92,119 28.66,115.75 28.66,112.54 28.19,112.07 v3(28.19,111.83)
  IN2 w0.066: v3(28.19,111.83) 28.19,111.88 27.71,112.36 v4(27.58,112.36) ; v10(38.13,121.1) 38.13,121.27 38.53,121.68 v4(38.63,121.68)
  IN3 w0.066: v6(39.75,143.88) 43.71,143.88 44.5,143.09 53.92,143.09 v5(54.81,143.98) ; v4(27.58,112.36) 27.58,112.23 27.25,111.9 v5(27,111.9) ; v4(38.63,121.68) v6(40.03,121.68)
  IN4 w0.066: v6(40.03,121.68) 40.03,122.98 38.53,124.48 38.53,125.9 38.25,126.18 38.08,126.18 37.77,126.48 37.77,127.09 37.29,127.57 37.29,132.19 37.67,132.57 37.67,133.56 37.95,133.84 37.95,134.41 37.89,134.47 37.89,141.71 39.75,143.58 v6(39.75,143.88)
  BOTTOM w0.112: PR923.1 57.34,145.29 56.26,144.21 55.75,144.21 55.52,143.98 v5(54.81,143.98)
IMVP_U42_U22#_LED: length 41.6
  TOP w0.112: Q356.2 47.65,86.67 46.84,85.87 46.46,85.87 46,86.32 46,87.67 45.62,88.05 v3(45.26,88.05)
  IN2 w0.066: v4(45.42,88.91) 45.42,88.2 v3(45.26,88.05)
  IN3 w0.066: v4(45.42,88.91) 40.08,94.25 v6(38.68,94.25)
  IN4 w0.066: v1(30.33,117.6) 32.49,115.44 32.49,114.58 34.7,112.36 35.06,112.36 35.4,112.03 35.4,108.07 35.99,107.48 35.99,103.67 36.17,103.49 36.17,102.55 36.91,101.82 36.91,99.66 37.85,98.72 37.85,96.98 38.68,96.14 v6(38.68,94.25)
IMVP_VR_ON: length 31.4
  IN3 w0.066: v6(25.76,116.55) 26.13,116.93 27.19,116.93 27.28,116.84 29.01,116.84 29.14,116.71 33.26,116.71 33.62,117.07 34.18,117.07 34.54,116.7 36.04,116.7 v5(36.17,116.57)
  IN4 w0.066: v6(25.76,116.55) 25.46,116.55 24.73,117.28 22.96,117.28 22.33,116.65 21.8,116.65 21.67,116.52 21.32,116.52 20.9,116.09 19.77,116.09 19.38,115.7 v1(19.38,114.11)
  BOTTOM w0.076: 20.73,113.6 20.11,113.6 19.81,113.9
  BOTTOM w0.112: v5(36.17,116.57) 36.17,116.98 35.53,117.62 35,117.62 v2(34.52,118.1) 34.52,120.36 34.29,120.59 34.29,121.3 RE10.2 34.48,121.72 U15.2 ; RE247.2 17.32,113.78 17.54,114 19.27,114 v1(19.38,114.11) 19.6,114.11 19.81,113.9
IMVP_VR_ON_P: length 75.5
  IN3 w0.066: v6(40.72,116.22) v5(36.22,116.22)
  IN4 w0.066: v6(40.72,116.22) 40.72,116.8 40.17,117.35 40.17,120.47 41.22,121.53 41.22,122.57 39.08,124.72 39.08,126.19 38.89,126.38 38.89,126.79 38.28,127.4 38.28,128.51 38.01,128.78 38.01,131.73 38.81,132.53 38.81,134.71 38.57,134.95 38.57,141.02 38.56,141.03 38.56,141.32 41.2,143.96 41.2,147.84 42.29,148.93 42.29,152.72 43.03,153.46 53.49,153.46 54,153.46 54.61,152.85 v1(54.76,152.85) ; v5(36.22,116.22) 36.45,116.45 36.45,116.78 35.94,117.29 35.94,117.87 35.61,118.2 35.61,118.89 35.84,119.11 35.84,119.83 35.66,120 35.66,121.63 v1(35.57,121.72)
  BOTTOM w0.112: v5(36.22,116.22) 35.74,116.22 34.98,116.98 RE29.1 ; U15.4 33.83,124.52 33.83,125.01 34.24,125.41 36.91,125.41 37.21,125.11 UE7.2 37.21,123.74 37.59,123.36 37.59,123.13 37.36,122.9 37.36,121.86 36.93,121.43 35.69,121.43 RE10.1
INTRUDER#: length 16.1
  TOP w0.112: v8(63.57,103.81) 63.57,103.51 63.8,103.27 RC88.1
  IN1 w0.066: v10(63.46,110.16) 63.57,110.06 v8(63.57,103.81)
  IN2 w0.066: v10(63.46,110.16) 62.96,110.16 v4(62.94,110.19) ; v4(63.5,116.78) 63.04,117.24 v3(63.04,117.26)
  IN3 w0.066: v6(62.83,110.87) 62.92,110.78 62.92,110.21 v4(62.94,110.19)
  GND3 w0.066: v15(63.94,116.59) 63.69,116.59 v4(63.5,116.78)
  IN4 w0.066: v6(62.83,110.87) 62.76,110.94 62.76,111.34 63.09,111.67 63.09,112.32 63.31,112.53 63.31,113.54 63.94,114.17 v15(63.94,116.59)
INV_PWM: length 15.7
  TOP w0.254: PR411.1 MC1.1 R67.1 79.49,84.94 78.96,85.47 78.35,85.47 77.62,86.21 76.25,86.95 75.01,86.95 74.24,87.71 73.26,87.71 71.15,89.82 70.85,89.82 v7(70.71,89.96)
  BOTTOM w0.254: D40.1 70.31,91.7 70.71,91.29 v7(70.71,89.96)
ISH_I2C0_SCL: length 123.3
  TOP w0.076: v8(55.69,128.36) 55.61,128.28 UCPU1.N3
  TOP w0.112: RS15.1 RS19.1 5.84,120.77 5,121.61 5,122.39 v7(5.2,122.59)
  IN1 w0.066: v10(43.47,144.85) 43.37,144.75 43.37,143.49 44.88,141.98 53.65,141.98 53.85,142.18 56.9,142.18 57.99,141.09 61.57,141.09 63.3,139.36 63.3,138.75 63.04,138.49 63.04,137.26 63.07,137.22 65.05,135.24 65.05,135.04 65.98,134.11 65.98,133.03 65.52,132.58 65.52,131.42 64.76,130.66 61.49,130.66 60.94,130.11 60.71,130.11 59.6,129.01 58.25,129.01 58.13,129.12 57.8,129.12 57.04,128.36 v8(55.69,128.36)
  IN2 w0.066: v10(43.47,144.85) 43.44,144.85 43.37,144.91 43.37,145.16 43.1,145.43 32.75,145.43 23.57,136.26 17.7,136.26 6.22,124.78 6.22,124.78 6.03,124.59 6.03,122.57 5.84,122.38 5.27,122.38 5.2,122.46 v7(5.2,122.59)
  IN4 w0.066: v7(5.2,122.59) 4.98,122.81 4.98,123.98 6.99,125.98 6.99,135.97 5.33,137.63 5.33,141.64 4.77,142.21 4.77,142.48 4.77,142.48 v7(5.07,142.78)
  BOTTOM w0.112: v7(5.07,142.78) 5.25,142.96 6.76,142.96 7.11,142.6 v11(7.49,142.6) 8.31,142.6 8.44,142.47 LGA1.13
