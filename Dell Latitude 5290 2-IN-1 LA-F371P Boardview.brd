# Allegro board Dell Latitude 5290 2-IN-1 LA-F371P Boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
WFCAM_CSI2_DN5_L: length 4.9
  TOP w0.112: JWFC1.2 121.4,157.34 121.4,157.34 121.31,157.34 121.22,157.43 121.06,157.43 121.01,157.38 120.78,157.15 v11(120.78,156.47) 120.78,156.15 120.45,155.82 120.13,155.82 D11.1 119.68,155.79 119.51,155.79 119.19,155.47 118.52,155.47 R12.2
WFCAM_CSI2_DN6: length 70.4
  TOP w0.112: v3(116.88,161.57) 117.44,161.57 R18.1
  IN2 w0.081: v3(72.37,134.82) 72.37,134.56 72.45,134.48 72.5,134.48 72.64,134.62 72.64,135.11 73.08,135.54 73.08,136.77 70.78,139.07 70.78,141.55 71.82,142.59 87.27,142.59 87.55,142.86 90.17,142.86 90.95,143.65 107.25,143.65 108.89,145.28 108.89,149.26 113.37,153.74 113.37,154.77 116.22,157.62 116.22,160.61 116.66,161.05 117.04,161.05 117.35,161.36 117.35,161.93 117.16,162.12 116.97,162.12 116.88,162.03 v3(116.88,161.57)
WFCAM_CSI2_DN6_L: length 4.1
  TOP w0.112: JWFC1.11 121.4,160.94 121.4,160.94 121.31,160.94 121.22,161.03 120.97,161.03 120.56,161.44 120.56,161.52 120.2,161.88 120.1,161.88 D15.1 119.66,161.9 119.44,161.9 119.11,161.57 118.52,161.57 R18.2
WFCAM_CSI2_DN7: length 69.8
  TOP w0.112: v3(116.04,164.08) 116.27,164.08 116.43,163.93 116.43,163.71 116.54,163.6 117.44,163.6 R22.1
  IN2 w0.081: v3(73.5,134.82) 73.5,134.64 73.57,134.57 73.69,134.57 73.84,134.72 73.84,135.15 74.47,135.79 74.47,136.7 77.18,139.4 77.18,139.58 76.48,140.29 76.48,141.01 76.88,141.41 87.82,141.41 88.03,141.62 90.91,141.62 91.76,142.47 107.9,142.47 110.11,144.68 110.11,148.82 114.55,153.25 114.55,154.28 117.99,157.72 117.99,163.29 117.13,164.15 116.11,164.15 v3(116.04,164.08)
WFCAM_CSI2_DN7_L: length 4.7
  TOP w0.112: JWFC1.14 121.47,162.14 v11(120.78,162.82) 120.56,163.05 120.56,163.62 120.24,163.93 120.12,163.93 D19.1 119.68,163.91 119.52,163.91 119.21,163.6 118.52,163.6 R22.2
WFCAM_CSI2_DP4: length 70.3
  TOP w0.112: v3(115.95,158.12) 115.99,158.08 116.48,158.08 116.76,158.35 117.44,158.35 R13.1
  IN2 w0.081: v3(72.37,132.87) 72.33,132.91 72.16,132.91 71.88,133.19 71.88,137.03 70.19,138.73 70.19,141.8 71.6,143.21 87,143.21 87.27,143.47 89.35,143.47 90.11,144.24 107,144.24 108.28,145.51 108.28,149.49 112.78,153.99 112.78,155.87 113.03,156.12 113.32,156.12 113.54,155.9 113.66,155.9 113.83,156.07 113.83,156.18 113.34,156.68 113.34,156.96 113.63,157.25 113.91,157.25 114.41,156.76 114.52,156.76 114.7,156.93 114.7,157.05 114.43,157.32 114.43,157.72 114.82,158.12 v3(115.95,158.12)
WFCAM_CSI2_DP4_L: length 4.2
  TOP w0.112: R13.2 118.52,158.35 119.25,158.35 119.57,158.03 119.68,158.03 D12.1 120.1,158.03 120.35,158.03 120.46,158.15 120.46,158.55 120.76,158.85 121.22,158.85 121.31,158.94 JWFC1.6
WFCAM_CSI2_DP5: length 69.5
  TOP w0.112: R9.1 117.22,156.4 117.13,156.32 116.76,156.32 116.59,156.15 116.16,156.15 115.86,155.85 115.86,154.7 116.3,154.26 116.98,154.26 v3(117.02,154.22)
  IN2 w0.081: v3(73.5,132.87) 73.58,132.96 73.9,132.96 74.55,133.61 74.55,134.88 75.43,135.76 75.43,136.54 75.72,136.82 75.84,136.82 75.91,136.76 76.19,136.76 76.48,137.05 76.48,137.33 76.41,137.4 76.41,137.51 76.56,137.66 76.67,137.66 76.74,137.59 77.03,137.59 77.32,137.88 77.32,138.16 77.25,138.23 77.25,138.35 77.42,138.52 77.53,138.52 77.61,138.45 77.89,138.45 78.18,138.74 78.18,139.02 78.11,139.1 78.11,139.21 78.31,139.41 78.31,139.69 78.04,139.96 78.04,140.12 78.17,140.25 78.33,140.25 78.6,139.98 78.88,139.98 79.5,140.6 86.13,140.6 86.21,140.52 86.21,140.32 86.42,140.12 86.83,140.12 87.03,140.32 87.03,140.52 87.11,140.6 88.16,140.6 88.37,140.81 91.74,140.81 92.61,141.68 108.26,141.68 109.13,142.55 109.25,142.55 109.41,142.39 109.69,142.39 109.98,142.68 109.98,142.97 109.82,143.13 109.82,143.24 110,143.41 110.11,143.41 110.27,143.26 110.55,143.26 110.84,143.55 110.84,143.83 110.69,143.99 110.69,144.1 110.92,144.34 110.92,147.77 111.59,148.43 111.59,148.72 111.42,148.89 111.42,149 111.65,149.24 111.77,149.24 111.94,149.07 112.22,149.07 112.51,149.36 112.51,149.64 112.34,149.81 112.34,149.93 112.51,150.1 112.63,150.1 112.8,149.93 113.08,149.93 113.38,150.22 113.38,150.5 113.2,150.67 113.2,150.79 113.38,150.96 113.49,150.96 113.66,150.79 113.95,150.79 114.24,151.08 114.24,151.37 114.07,151.53 114.07,151.65 114.25,151.82 114.36,151.82 114.53,151.65 114.81,151.65 115.1,151.95 115.1,152.23 114.94,152.39 114.94,152.51 115.11,152.68 115.22,152.68 115.39,152.52 115.67,152.52 115.96,152.81 115.96,153.09 115.8,153.26 115.8,153.37 115.94,153.52 115.94,153.8 115.62,154.12 115.62,154.24 115.79,154.41 115.91,154.41 116.23,154.09 116.51,154.09 116.64,154.22 v3(117.02,154.22)
WFCAM_CSI2_DP5_L: length 4.9
  TOP w0.112: JWFC1.3 121.31,157.74 121.22,157.65 120.97,157.65 120.56,157.24 120.56,156.76 120.54,156.74 120.54,156.22 120.36,156.04 120.06,156.04 D10.1 119.68,156 119.57,156 119.25,156.32 118.52,156.32 R9.2
WFCAM_CSI2_DP6: length 70.4
  TOP w0.112: v3(116.88,162.41) 117.13,162.41 117.22,162.5 R17.1
  IN2 w0.081: v3(72.37,134.17) 72.48,134.28 72.59,134.28 72.84,134.53 72.84,135.02 73.28,135.46 73.28,136.86 70.98,139.15 70.98,141.47 71.9,142.39 87.36,142.39 87.63,142.66 90.25,142.66 91.04,143.44 107.34,143.44 109.09,145.2 109.09,149.18 113.57,153.66 113.57,154.69 116.42,157.54 116.42,160.52 116.75,160.85 117.13,160.85 117.55,161.27 117.55,162.01 117.24,162.32 116.97,162.32 v3(116.88,162.41)
WFCAM_CSI2_DP6_L: length 4
  TOP w0.112: JWFC1.12 121.31,161.34 121.22,161.25 121.06,161.25 120.78,161.53 120.78,161.61 120.29,162.1 120.1,162.1 D14.1 119.7,162.12 119.38,162.12 119.08,162.41 118.52,162.41 R17.2
WFCAM_CSI2_DP7: length 69.9
  TOP w0.112: v3(116.14,164.46) 116.16,164.45 117.44,164.45 R21.1
  IN2 w0.081: v3(116.14,164.46) 116.25,164.35 117.22,164.35 118.19,163.38 118.19,157.64 114.75,154.2 114.75,153.17 110.31,148.73 110.31,144.59 107.99,142.27 91.85,142.27 91,141.42 88.11,141.42 87.9,141.21 76.97,141.21 76.68,140.93 76.68,140.37 77.38,139.67 77.38,139.32 74.68,136.61 74.68,135.7 74.04,135.07 74.04,134.63 73.78,134.37 73.61,134.37 73.5,134.26 v3(73.5,134.17)
WFCAM_CSI2_DP7_L: length 4.6
  TOP w0.112: JWFC1.15 121.4,162.54 120.78,163.16 120.78,163.7 120.33,164.15 120.08,164.15 D18.1 119.68,164.13 119.52,164.13 119.21,164.45 118.52,164.45 R21.2
WFCAM_LED#: length 14.9
  TOP w0.112: JWFC1.17 121.71,163.34 121.48,163.34 v3(121.28,163.54) 121.19,163.63 121.19,164.98 v2(120.87,165.3) R434.1
  IN2 w0.066: v3(121.28,163.54) v4(121.28,155.77)
  IN3 w0.066: v5(124.43,155.77) v4(121.28,155.77)
  BOTTOM w0.112: v5(124.43,155.77) 124.68,156.01 Q26.3
WL_OFF#_R: length 47.4
  TOP w0.112: v3(21.53,64.07) 24.22,61.38 JNGFF3.56
  IN2 w0.066: v3(21.53,64.07) v4(20.76,63.31)
  IN3 w0.066: v5(18.98,62.17) 19.63,62.17 v4(20.76,63.31)
  IN4 w0.066: v1(17.77,92.78) 17.97,92.58 17.97,90.26 17.43,89.72 17.43,82.46 24.26,75.63 24.26,72.26 22.66,70.66 22.66,65.85 v5(18.98,62.17)
  BOTTOM w0.112: R157.2 v5(18.98,62.17) 19.1,62.3 R159.1 ; v1(17.77,92.78) 17.86,92.68 19.52,92.68 D92.2
WLAN_RST#: length 136.2
  IN2 w0.066: v4(58.36,127.57) 58.66,127.88 v3(58.66,127.91)
  IN3 w0.066: v4(58.36,127.57) 58.36,127.99 v6(58.23,128.12) ; v6(57.1,50.6) 57.05,50.55 29.81,50.55 29.11,49.85 26.7,49.85 25.99,50.55 25.45,50.55 21,50.55 v5(20.69,50.87)
  IN4 w0.066: v6(57.1,50.6) 57.1,70.3 56.36,71.05 56.36,82.87 55.13,84.1 55.13,90.11 54.73,90.52 54.73,93.96 53.51,95.18 53.51,97.75 53.34,97.92 53.34,101.6 52.93,102.01 52.93,102.27 52.93,104.62 51.08,106.47 51.08,115.23 50.42,115.89 50.42,116.5 49.09,117.82 49.09,120.42 47.5,122.01 v1(47.18,122.01) 47.1,122.09 47.1,123.7 47.38,123.98 47.38,124.85 47.38,127.18 48.52,128.32 52.27,128.32 52.85,128.9 52.85,129.68 54.21,131.04 55.9,131.04 58.23,128.7 v6(58.23,128.12)
  BOTTOM w0.112: v2(21,50.55) v5(20.69,50.87) U23.2
WLAN_RST#_Q: length 16.8
  TOP w0.112: JNGFF3.66 21.72,59.24 19.6,57.12 v7(19.6,56.07) 21.72,56.07 25.22,59.57 JNGFF3.52
  BOTTOM w0.112: R160.1 v7(19.6,56.07) 20.04,55.63 U23.4 20.41,54.82 20.5,54.92 v2(20.5,55.75)
WLAN_WIGIG60GHZ_DIS#: length 36.9
  IN3 w0.066: v6(18.8,118.4) 18.92,118.53 20.78,118.53 21.16,118.91 22.01,118.91 v5(22.18,118.74)
  IN4 w0.066: v6(18.8,118.4) 18.8,118.99 18.31,119.47 17.53,119.47 v1(17.3,119.24) 17.3,118.85 16.67,118.22 16.67,116.16 16.67,116.16 16.67,114.54 16.32,114.19 15.44,114.19 13.96,112.71 13.96,105.99 14.08,105.87 14.08,104.26 13.89,104.07 13.89,97.14 15.93,95.11 15.93,94.93 17.56,93.3 v1(17.56,93.16)
  BOTTOM w0.112: UE3.L13 22.33,118.61 22.2,118.74 v5(22.18,118.74) ; v1(17.56,93.16) 18.3,93.16 D92.1
WWAN_DEVSLP: length 4.4
  TOP w0.076: 53.34,130.36 54.91,130.36 UCPU1.J3
  TOP w0.112: 53.34,130.36 53.2,130.36 52.86,130.02 52.86,129.62 52.16,128.93 52.15,128.93 R489.2
WWAN_EN: length 5.2
  IN4 w0.066: v13(18.44,86.7) 18.44,87.87 v1(18.93,88.36)
  BOTTOM w0.112: D61.1 18.62,89.07 19.51,89.07 R216.2 19.6,88.55 19.11,88.55 v1(18.93,88.36) ; U17.5 v13(18.44,86.7)
WWAN_OFF#: length 44.3
  TOP w0.112: D95.1 30.86,107.58 v8(30.03,107.58) 29.41,107.58 RC202.1
  IN1 w0.066: v8(59.31,124.71) 58.53,124.71 58.28,124.96 55.83,124.96 55.63,124.75 55.63,124.68 55.24,124.3 55.24,123.94 54.97,123.66 54.51,123.66 54.47,123.62 54.31,123.62 53.64,122.95 52.99,122.95 52.77,122.73 50.88,122.73 50.88,122.73 50.74,122.73 50.73,122.72 50.72,122.72 50.66,122.66 50.52,122.66 50.52,122.66 49.54,122.66 49.4,122.79 49.4,122.79 49.36,122.84 47.83,122.84 47.69,122.7 47.14,122.7 45.55,121.11 44.43,121.11 44.21,120.89 41.68,120.89 41.25,120.46 38.97,120.46 38.25,119.75 35.62,119.75 34.35,118.48 32.17,118.48 29.52,115.83 29.52,108.66 30.03,108.15 v8(30.03,107.58)
WWAN_PWR_OFF#: length 33.1
  TOP w0.076: 52.45,114.64 52.62,114.64 53.8,115.82 54.48,115.82 54.61,115.95 54.61,116.1 54.85,116.33 55.57,116.33 55.93,116.69 UCPU1.AP4
  TOP w0.112: 52.45,114.64 52.29,114.48 50.47,114.48 v8(49.98,114.97)
  IN1 w0.066: v10(48.53,115.3) 48.86,114.97 v8(49.98,114.97)
  IN2 w0.066: v4(44.77,116.33) 47.31,116.33 48.28,115.36 48.48,115.36 v10(48.53,115.3)
  IN3 w0.066: v5(30.58,122.82) 30.58,122.67 30.73,122.52 31.98,122.52 32.94,121.56 36.14,121.56 37.62,120.08 41.05,120.08 43.83,117.3 44.82,117.3 45.11,117.01 45.11,116.67 v4(44.77,116.33)
  BOTTOM w0.112: v5(30.58,122.82) 30.58,123.61 30.45,123.74 29.54,123.74 29.26,124.02 R125.2
WWAN_PWR_OFF#_R: length 7.7
  IN2 w0.066: v3(31.63,122.17) 33.25,123.79 v4(33.25,124.4)
  IN3 w0.066: v4(33.25,124.4) 33.15,124.4 33.1,124.45 31.98,124.45 v5(31.93,124.4)
  BOTTOM w0.112: R479.2 31.93,123.53 v5(31.93,124.4) 31.62,124.09 31.62,124.02 31.34,123.74 30.79,123.74 30.7,123.83 30.7,123.84 C108.1 R125.1
WWAN_RADIO_DIS#: length 19.4
  TOP w0.112: RE266.1 29.67,108.78 v8(30.12,108.78) 30.89,108.78 D94.1
  IN1 w0.066: v8(30.12,108.78) 29.97,108.93 29.97,115.48 32.49,118 v10(32.54,118)
  IN2 w0.066: v4(32.89,117.39) 32.54,117.74 v10(32.54,118)
  IN3 w0.066: v5(26.32,117.6) 26.35,117.57 27.26,117.57 27.44,117.39 29.17,117.39 29.25,117.31 32.82,117.31 v4(32.89,117.39)
WWAN_RADIO_DIS#_R: length 18.1
  TOP w0.112: D95.2 D94.2 32.68,109.37 32.31,109.74 32.31,112.1 33.43,113.22 v2(33.88,113.22) 34.58,113.22 34.8,113.44 34.8,116.93 31.13,120.59 JNGFF1.8
WWAN_RST#: length 5.7
  TOP w0.076: v8(52.78,123.43) 52.84,123.43 52.92,123.36 UCPU1.AB1
  IN1 w0.066: v8(48.46,123.52) 48.65,123.32 50.31,123.32 50.37,123.38 52.73,123.38 v8(52.78,123.43)
WWAN_WAKE#: length 22
  TOP w0.112: R38.1 29.79,111.72 v2(29.58,111.51) 28.51,111.51 v3(28.45,111.57)
  IN2 w0.066: v4(28.5,110.71) 28.5,110.71 28.5,111.52 v3(28.45,111.57)
  IN3 w0.066: v4(28.5,110.71) 27.91,110.71 27.28,110.07 26.35,110.07 25.15,111.27 23.49,111.27 22.41,112.35 22.41,113.39 22.76,113.74 22.76,116.16 v5(21.81,117.11)
  BOTTOM w0.076: 19.81,116.35 20.45,115.72 20.87,115.72 20.9,115.75 21.3,115.75 21.33,115.72 21.64,115.72 21.81,115.88 v5(21.81,117.11) 21.81,117.79 21.53,118.08 UE3.M13
  BOTTOM w0.112: 19.81,116.35 19.64,116.52 RH6.1
WWAN_WAKE#_R: length 3.2
  TOP w0.112: JNGFF1.23 27.38,113.53 v2(27.7,113.21) 28.42,113.21 28.88,112.75 R38.2
XCLK_BIASREF: length 6.7
  TOP w0.076: UCPU1.E42 77.95,132.38 78.46,132.38 78.77,132.69 78.77,133.07 79.12,133.42 v8(79.38,133.42)
  IN1 w0.066: v8(80.52,137.15) 80.52,136.32 79.64,135.44 79.64,133.72 79.38,133.46 v8(79.38,133.42)
XDP_DBRESET#: length 123.5
  IN3 w0.066: v6(113.5,134.96) 121.78,134.96 121.92,134.82 123.53,134.82 123.74,135.03 124.31,135.03 125.09,134.25 125.29,134.25 125.57,133.97 129.46,133.97 130.9,132.52 131.66,132.52 132.73,131.45 140.06,131.45 140.37,131.13 140.59,131.13 142.18,129.54 147.44,129.54 147.99,130.09 153.77,130.09 v5(156.09,132.4)
  IN4 w0.066: v6(113.5,134.96) 112.35,136.11 112.35,136.89 108.16,141.09 94.94,141.09 92.45,138.6 87.03,138.6 86.5,139.13 71.9,139.13 71.44,138.66 69.48,138.66 68.35,139.79 61.87,139.79 61.52,140.15 54.81,140.15 54.65,139.98 53.63,139.98 53.4,140.21 51.3,140.21 v1(51.13,140.37)
  BOTTOM w0.112: v1(51.13,140.37) 50.4,139.65 50.4,138.72 49.9,138.22 RC34.1 49.47,138.4 47.53,138.4 46.78,137.65 UC3.1 ; v5(156.09,132.4) 156.68,132.4 157.06,132.02 CC95.1 RC120.2
XDP_OBS0: length 37.8
  IN3 w0.066: v5(120.28,130.81) 120.41,130.68 124.63,130.68 126.75,128.56 126.75,127.97 127.21,127.51 127.87,127.51 128.57,128.21 130.92,128.21 131.29,128.58 134.8,128.58 135.3,129.08 137.39,129.08 140.27,126.2 141.45,126.2 142,126.76 146.17,126.76 148.68,124.24 v5(149.94,124.24)
  BOTTOM w0.112: v5(149.94,124.24) 150,124.3 JXDP1.21
XDP_OBS0_R: length 41.1
  TOP w0.076: v3(85.43,135.24) 85.42,135.22 85.42,133.94 UCPU1.C55
  IN2 w0.066: v4(118.23,130.96) 115.77,128.5 108.83,128.5 108,127.67 99.01,127.67 96.41,130.27 96.41,131.67 95.75,132.33 95.75,132.79 94.25,134.29 86.31,134.29 85.6,135 85.6,135.07 v3(85.43,135.24)
  IN3 w0.066: v5(119.37,130.81) 118.37,130.81 v4(118.23,130.96)
XDP_OBS1: length 37
  IN3 w0.066: v5(120.28,131.7) 120.41,131.57 124.01,131.57 126.75,128.83 128.7,128.83 128.93,129.05 130.76,129.05 131.05,128.77 134.67,128.77 135.21,129.31 137.44,129.31 140.35,126.4 141.37,126.4 141.92,126.95 147.21,126.95 v5(149.4,124.75)
  BOTTOM w0.112: JXDP1.23 149.55,124.9 v5(149.4,124.75)
XDP_OBS1_R: length 42.9
  TOP w0.076: v3(85.05,135.54) 85.03,135.51 85.03,135.16 85.25,134.93 85.25,134.19 85.03,133.97 85.03,133.73 85.16,133.6 85.16,133.37 85.32,133.2 UCPU1.D55
  IN2 w0.066: v3(85.05,135.54) 85.56,135.54 85.85,135.24 85.85,135.09 86.47,134.48 94.33,134.48 95.95,132.87 95.95,132.41 96.6,131.75 96.6,130.35 99.09,127.86 107.9,127.86 108.73,128.69 115.46,128.69 v4(117.72,130.95)
  IN3 w0.066: v4(117.72,130.95) 118.47,131.7 v5(119.37,131.7)
XDP_OBS2_R: length 3.3
  TOP w0.074: 85.06,134.47 84.76,134.17 UCPU1.B54
  TOP w0.076: 85.06,134.47 85.06,134.91 84.72,135.25 84.72,135.92
  TOP w0.112: T9.1 84.61,136.96 84.61,136.03 84.72,135.92
XDP_OBS3_R: length 7.8
  TOP w0.076: UCPU1.C56 85.82,133.6 85.82,133.76 85.65,133.93 85.65,134.97 85.78,135.1 85.78,135.32 84.86,136.23 84.86,137.24 84.58,137.52 84.58,137.96
  TOP w0.112: 84.58,137.96 83.36,139.18 T10.1
XDP_PRSENT: length 180.2
  IN4 w0.066: v1(30.23,125.05) 30.69,125.51 30.69,126.24 29.76,127.17 29.76,139.48 31.47,141.19 31.47,142.41 35.87,146.82 35.96,146.82 36.62,147.47 36.62,154.15 31.79,158.98 31.79,159.85 32.38,160.45 32.38,160.95 35.32,163.89 36.14,163.89 38.65,166.39 106.36,166.39 106.46,166.49 118.53,166.49 124.14,160.88 124.14,157.29 124,157.14 124,155.43 129.22,150.21 138.52,150.21 139.13,149.6 139.13,147.58 139.57,147.13 139.57,146.2 140.51,145.26 140.51,143.09 140.33,142.91 140.33,140.86 143.01,138.18 143.01,135.38 143.52,134.86 143.52,133 v1(143.11,132.59)
XDP_PRSENT#: length 18.5
  IN3 w0.066: v5(144.84,129.99) 147.25,129.99 147.81,130.54 153.56,130.54 154.88,131.85 154.88,135.71 v5(155.17,136)
  BOTTOM w0.112: U44.2 143.76,129.52 RC187.2 144.34,129.48 v5(144.84,129.99) ; JXDP1.60 v5(155.17,136)
XDP_PRSNT_PIN1: length 9.6
  BOTTOM w0.112: JXDP1.1 151.75,118.3 150.75,117.3 149.13,117.3 148.86,117.58 148.86,121.57 RC141.1
XTAL24_IN: length 7.7
  TOP w0.076: 73.06,134.16 73.39,133.83 73.61,133.83 73.8,133.64 73.8,132.73 74.43,132.1 UCPU1.E37
  TOP w0.112: 73.06,134.16 73.06,135.1 72.95,135.22 72.95,136.17 73.63,136.86 v2(74.12,136.86) 74.43,137.17 RC380.1
XTAL24_IN_RU: length 4.7
  TOP w0.076: UCPU1.E3 55.1,132.55 54.79,132.86 53.34,132.86
  TOP w0.112: 53.34,132.86 53.25,132.95 51.28,132.95 50.94,132.6 RC377.2
XTAL24_OUT: length 6.1
  TOP w0.074: UCPU1.E35 73.75,132.37 73.62,132.37 73.22,132.77 73.22,133.33 73.06,133.5 72.84,133.5 72.65,133.69 72.65,133.98
  TOP w0.112: 72.65,133.98 72.84,134.17 72.84,134.97 72.72,135.09 72.72,136.24 73.25,136.78 RC381.1
XTAL24_OUT_RU: length 7.6
  TOP w0.076: 53.34,133.19 53.44,133.19 53.75,133.49 54.22,133.49 54.38,133.33 54.72,133.33 54.89,133.49 55.07,133.49 55.26,133.3 55.26,132.98 55.36,132.88 55.75,132.88 56.08,133.21 56.95,133.21 57.26,133.52 UCPU1.C7
  TOP w0.112: 53.34,133.19 RC378.2
N04830: length 3.6
  TOP w0.112: v7(136.08,123.57) v2(136.75,123.57)
  TOP w0.508: PR318.1 PC341.1 135.71,123.94 v7(136.08,123.57)
  BOTTOM w0.203: PU300.3 135.98,123.67 v7(136.08,123.57)
N16784922: length 3.6
  BOTTOM w0.112: RA9.2 RA30.1 CA13.1 CA14.1 25.27,152.9 CA48.1 25.73,153.35 RA28.2
N17750417: length 1.8
  BOTTOM w0.112: RR10.2 69.16,29.41 UR1.28
N19378299: length 3.7
  TOP w0.112: JNGFF1.63 17.38,111.59 T25.1
N19378306: length 3.3
  TOP w0.112: JNGFF1.65 16.88,111.92 T24.1
N20151644: length 35.1
  TOP w0.254: PR300.3 122.18,99.57 v7(122.3,99.45)
  IN4 w0.254: v7(122.3,99.45) 122.29,99.45 121.67,100.07 121.67,104.84 122.89,106.06 122.89,114.25 124.41,115.77 124.41,124.4 125.83,125.82 127.98,125.82 v1(128.59,126.43)
  BOTTOM w0.112: PR302.1 128.77,127.64 128.77,126.61 v1(128.59,126.43) ; v7(122.3,99.45) 122,99.45 v2(121.59,99.86)
N20151664: length 33.6
  TOP w0.254: PR300.2 122.83,99.57 122.31,100.08 v7(122.3,100.08)
  IN4 w0.254: v1(129.21,127.19) 129.21,126.49 128.19,125.46 125.98,125.46 124.76,124.25 124.76,115.62 123.24,114.1 123.24,105.91 122.02,104.69 122.02,100.36 v7(122.3,100.08)
  BOTTOM w0.112: v7(122.3,100.08) 122.94,100.08 v2(123.2,99.82)
N20422204: length 1.1
  TOP w0.508: PR400.2 PC407.1
N21436900: length 10.3
  TOP w0.112: R65.1 62.05,84.01 61.53,83.49 61.53,77.29 62.75,76.06 JNGFF2.68
N21618504: length 1.7
  BOTTOM w0.112: PR502.1 v2(120.92,114.78)
  vias: v7(118.87,115.64) v7(119.51,115.64)
N21618541: length 1.5
  BOTTOM w0.112: v2(117.83,116.19) 118.12,116.49 PR502.2
N21619867: length 2.3
  TOP w0.254: PU500.6 117.16,117.04 116.87,117.34 PC505.2 PR519.2
N21620615: length 2.8
  TOP w0.254: PU500.12 121.16,118.54 121.49,118.87 v2(121.49,119.86) 121.59,119.97 122.28,119.97 PR500.2
N21622453: length 2.4
  TOP w0.112: v2(122.78,113.04) 123.27,113.53 PC500.1
  TOP w0.508: PR501.2 123.27,115.24 PC500.1
N21624147: length 2.3
  TOP w0.112: 46.8,157.84 v2(49.1,157.84)
  vias: v7(46.35,156.4) v7(46.35,155.77)
N21624438: length 3.5
  TOP w0.254: PR506.2 43.26,151.32 43.26,152.58 43.97,153.29 PU501.12
N21624470: length 11.6
  TOP w0.112: v2(50.98,154.54) 50.76,154.32 v3(48.9,154.32)
  TOP w0.254: PU501.9 43.51,154.79 43.04,154.32 v3(42.67,154.32)
  IN2 w0.254: v3(48.9,154.32) 48.9,153.74 48.51,153.35 45.87,153.35 44.62,154.61 42.96,154.61 v3(42.67,154.32)
N21628470: length 2.4
  BOTTOM w0.112: PC601.1 105.87,119.64 v2(105.69,119.46)
  BOTTOM w0.508: PC601.1 107.15,120.46 PR602.2
N21628480:
  vias: v2(106.65,115.77) v7(106.43,117.6) v7(107,117.98)
N21628542: length 3.5
  TOP w0.254: PU600.13 110.91,119.2 PR603.2 ; PR603.2 PC602.2 ; PR603.2 PR604.1
N21628589: length 1.5
  TOP w0.112: PC607.1 107.77,125.15 v2(107.18,125.74)
N21630461: length 4.5
  TOP w0.112: v2(104.47,123.55) PR610.1
  TOP w0.254: PR610.1 PR606.2 PC614.1 104.48,120.7 PU600.3
N21632067: length 2.8
  TOP w0.254: PU600.7 105.58,118.7 v7(105.35,118.94)
  BOTTOM w0.112: v7(105.35,118.94) v2(105.35,118.06)
  BOTTOM w0.254: v7(105.35,118.94) 104.84,119.45 PC612.1
N21803574:
  vias: v7(39.75,21.02) v7(39.75,20.39)
N22437505: length 2.5
  BOTTOM w0.112: UT1.F1 32.96,64.84 31.81,63.69 RT22.2
N22440570: length 2.5
  BOTTOM w0.076: 38.73,64.58 38.49,64.33 UT1.E11
  BOTTOM w0.112: RT24.1 38.99,64.84 38.73,64.58
N22441485: length 3.5
  IN4 w0.066: v1(35.8,68.95) 36.45,68.3 36.45,67.88
  IN4 w0.076: 36.45,67.88 36.45,66.74 36.19,66.48 v1(36.19,65.84)
N22441497: length 6.6
  IN3 w0.066: v5(37.69,64.84) v5(42.34,64.84)
  BOTTOM w0.112: v5(42.34,64.84) RT19.1 42.34,66.78 RT16.1
N22441511: length 2.8
  BOTTOM w0.066: UT1.G2 33.44,65.09 32.93,65.09 32.84,65 32.68,65
  BOTTOM w0.112: 32.68,65 32.26,64.58 RT21.1
N22442963: length 1.2
  BOTTOM w0.112: TC6.1 41.35,67.96 RT17.2
N22450757: length 0.9
  BOTTOM w0.112: R100.2 152.36,146.15 C62.2
N22450864: length 0.9
  BOTTOM w0.112: C52.1 153,148.62 R95.2
N22451929: length 2.2
  BOTTOM w0.254: U12.B7 149.51,143.52 148.83,143.52 R102.1
N22451931: length 3.4
  BOTTOM w0.254: U12.H4 150.75,140.84 151.09,140.5 152.55,140.5 152.97,140.08 R113.1
N22451933: length 2.1
  BOTTOM w0.254: U12.D7 148.47,142.76 R106.1
N22452420: length 1.9
  BOTTOM w0.254: U12.C7 147.93,143.16 R105.1
N22452424: length 2
  BOTTOM w0.254: R98.1 149.98,144.66 149.98,143.99 U12.A6
N22483897: length 4.5
  BOTTOM w0.112: v2(139.97,137.43) R77.1 R78.2 C43.2 142.75,137.92 142.95,138.12 U9.2
N23252533: length 1.8
  TOP w0.112: JNGFF1.67 16.38,112.89 T20.1
N23877759: length 4.8
  BOTTOM w0.112: R92.1 155.79,149.02 R447.2 ; R92.1 R93.2 ; R92.1 155.79,147.21 155.59,147 Q9.2 155.08,147 154.75,146.67 154.75,146.19 R99.2
N23878175: length 3.4
  BOTTOM w0.112: R97.1 157.7,147 Q9.5 156.57,147 156.35,147.22 156.35,148.38 R92.2 R91.2
N23878217: length 0.9
  BOTTOM w0.112: R97.2 157.69,146.5 Q9.6
N24116145: length 5.1
  BOTTOM w0.112: U12.C1 152.82,143.16 153.29,142.69 153.72,142.69 153.83,142.57 153.83,142 154.36,141.47 R107.2 153.57,140.91 v2(153.33,140.67)
N24402677: length 9.3
  IN3 w0.066: v5(27.19,65.57) 27.19,65.85 28.72,67.37 29.53,67.37 30.54,66.36 31.56,66.36 32.68,65.24 34.59,65.24 v5(34.69,65.34)
N24402691: length 10.6
  IN3 w0.066: v5(34.69,64.84) 34.45,65.07 32.61,65.07 31.49,66.19 30.47,66.19 29.46,67.2 28.79,67.2 27.51,65.93 27.51,65 v5(26.85,64.34)
N25217210: length 2.2
  TOP w0.254: PC510.1 121.97,116.26 121.79,116.44 121.79,116.78 121.53,117.04 PU500.9
N25410508: length 4.8
  TOP w0.112: v2(151.1,120.5) 150.44,121.16 PQ280.1
  TOP w0.254: PQ280.1 149.62,121.16 PR280.2 149.17,120.22 149.03,120.08 149.03,119.38 149.23,119.19 PU280.3
N25410589: length 12.1
  TOP w0.112: PD280.1 v2(147.19,123.94)
  TOP w0.254: PR281.1 145.91,117.16 145.67,117.4 PR282.1 145.69,117.78 146.1,118.19 PU280.8 148.03,118.19 148.26,118.42 PR280.1 147.81,121.16 PD280.1
N25410879: length 3.9
  TOP w0.112: v2(151.35,119.03) 151.01,118.69 PU280.2
  TOP w0.254: PU280.2 149.23,118.69 149.05,118.51 PR281.2
N25411106: length 3.3
  TOP w0.254: PQ280.2 150.89,123.88 v2(150.65,124.12) 150.62,124.14 PR284.1 PR283.2
N25958709: length 2.5
  TOP w0.254: PU600.14 109.98,119.7 110.44,120.16 110.44,120.72 110.69,120.97 PR609.1
N25961009: length 4
  TOP w0.112: v2(143.61,119.64) 143.61,119.5 144.41,118.7 PC280.1
  TOP w0.254: PU280.7 146.12,118.69 146.11,118.7 PR282.2 PC280.1
N27076067: length 2.1
  BOTTOM w0.112: PC349.1 140.58,125.85 140.97,126.24 v2(141.24,126.24)
  BOTTOM w0.203: PC349.1 PR327.2
N28344853: length 1.6
  TOP w0.112: v7(60.72,115.6) 61.08,115.96 UCPU1.AT13
  BOTTOM w0.112: T36.1 61.19,115.14 v7(60.72,115.6)
N28375965: length 7.8
  IN1 w0.066: v8(80.42,130.8) 80.95,130.8 81.82,131.67 82.42,131.67 82.67,131.92 82.67,132.31 82.37,132.61 82.37,133.75 82.55,133.92 82.55,135.76 v8(83.3,136.51)
N28375966: length 9.3
  IN1 w0.066: v8(83.26,137.83) 83.26,137.43 82.87,137.03 82.87,136.32 81.98,135.43 81.98,134.05 82.19,133.83 82.19,132.55 82.51,132.24 82.51,131.99 82.35,131.84 81.45,131.84 81.2,132.09 80.78,132.09 80.42,131.72 v8(80.42,131.45)
N28424999: length 5.1
  TOP w0.076: 95.89,113.53 95.05,113.53 94.8,113.78 94.79,113.78 UCPU1.AW71
  TOP w0.112: T23.1 97.8,115.52 96.52,114.24 96.52,114.16 95.89,113.53 95.89,113.53
N28425002: length 6.2
  TOP w0.076: UCPU1.AW70 94.49,112.97 95.89,112.97
  TOP w0.112: 95.89,112.97 96.01,112.97 98.6,115.56 T29.1
N28563008: length 4.6
  TOP w0.112: RC35.2 RC380.2 CC2.1 73.55,138.58 73.55,140.04 YC1.3
N28563023: length 2.8
  TOP w0.112: RC381.2 RC35.1 72.67,137.76 73.15,138.24 CC1.1 73.15,138.7 YC1.1
N28769860: length 3.5
  TOP w0.254: PR807.2 PR810.1 121.97,125.41 122.77,125.41 123.03,125.67 PU800.5
N28769975: length 2.5
  TOP w0.254: PU800.6 123.53,125.63 123.35,125.45 123.35,125.44 122.94,125.03 PR812.1 PR811.1
N28771761: length 5.3
  TOP w0.112: PR800.1 123.19,132.23 v2(123.7,132.74)
  TOP w0.254: PR800.1 122.3,130.82 PR801.2 122.78,130.32 123.37,130.32 124.03,129.66 PU800.14
N28842863: length 7.7
  TOP w0.112: CC14.1 47.45,119.45 47.99,118.9 50.2,118.9 50.6,118.51 v2(51.04,118.51) 51.58,118.51 51.98,118.9 54.12,118.9 UCPU1.AL1
N28843886: length 2
  TOP w0.112: UCPU1.BB10 59.54,111.55 v7(59.44,111.44)
  BOTTOM w0.112: CC81.1 59.72,111.72 v7(59.44,111.44)
N28846534: length 15.2
  IN3 w0.254: v5(59.22,121.99) 59.09,122.11 56.51,122.11 55.79,122.84 50.95,122.84 50.72,123.06 49.87,123.06 v5(49.71,122.91)
  BOTTOM w0.112: CC53.1 57.85,122.53 v2(57.47,122.15)
  BOTTOM w0.254: RC186.2 RC185.2 49.34,122.53 v5(49.71,122.91) ; CC53.1 58.92,122.53 L23.1 v5(59.22,121.99)
N28846574: length 7.5
  TOP w0.254: UCPU1.AJ19 64.71,120.13 v7(64.36,119.78)
  IN4 w0.254: v7(64.36,119.78) 64.36,119.99 64.06,120.28 63.16,120.28 62.86,120.59 62.86,121.66 62.54,121.99 61.37,121.99 61.24,121.86 v1(60.42,121.86)
  BOTTOM w0.127: v7(64.36,119.78) 64.36,119.7 v2(63.88,119.23)
  BOTTOM w0.254: v7(64.36,119.78) 64.36,119.78 64.91,119.78 CC64.1
N28856399: length 8.2
  TOP w0.076: 95.89,112.46 95.76,112.33 94.49,112.33 94,112.82 UCPU1.BA70
  TOP w0.112: 95.89,112.46 97.46,114.04 97.83,114.04 99.48,115.69 T31.1
N28856402: length 9.6
  TOP w0.076: 95.89,111.95 95.76,111.95 95.63,111.83 93.98,111.83 93.85,111.95 93.85,112.3 UCPU1.BA68
  TOP w0.112: T28.1 100.2,116.07 96.09,111.95 95.89,111.95
N28857231: length 7.8
  TOP w0.076: UCPU1.BB68 92.84,112.19 92.84,111.95 92.96,111.83 92.96,111.3 93.71,110.56 95.89,110.56
  TOP w0.112: 95.89,110.56 96.55,110.56 T27.1
N28857234: length 10.4
  TOP w0.076: UCPU1.BB69 93.7,111.99 93.7,111.89 93.92,111.67 95.89,111.67
  TOP w0.112: 95.89,111.67 96.23,111.67 100.23,115.67 101.79,115.67 T30.1
N28857237: length 1.3
  TOP w0.112: v7(60.94,119.89) 60.94,119.88 61.26,119.56 UCPU1.AK13
  BOTTOM w0.112: v7(60.94,119.89) 60.94,119.88 60.83,119.99 T33.1
N28857240: length 1.6
  TOP w0.112: v7(60.75,118.72) 60.74,118.72 60.77,118.75 60.77,119 60.61,119.16 UCPU1.AK12
  BOTTOM w0.112: T34.1 60.58,118.9 v7(60.75,118.72)
N28861827: length 5.9
  TOP w0.076: UCPU1.C64 90.37,133.94 90.37,135.13 91.44,136.2 91.44,138.14 91.54,138.24 91.54,138.61
  TOP w0.112: 91.54,138.61 RC24.1
N28891648: length 3.6
  TOP w0.112: RC72.2 60.71,109.69 v2(60.67,109.72) 60.21,110.19 60.21,112.09 UCPU1.BB11
N28938912: length 2
  BOTTOM w0.112: v2(49.49,101.53) CC91.2 RC169.1
N29263363: length 3.8
  TOP w0.112: v2(48.22,140.48) 48.4,140.65 PR824.1
  TOP w0.254: 49.25,141.75 49.24,141.73 PR824.1 ; 49.25,141.75 PR825.1 ; 49.25,141.75 49.25,142 48.78,142.47 PU801.5
N29436789: length 1.1
  TOP w0.112: v2(91.91,155.55) 91.54,155.92 91.54,156.47
N29436793: length 6.6
  TOP w0.635: PR1106.1 88.72,157.29 88.6,157.16 87.22,157.16 ; PC1110.2 79.88,156.07 80.44,155.51 83.29,155.51
N29708559: length 4.3
  TOP w0.112: UCPU1.AY4 56.2,113.29 56.2,112.12 55.91,111.83 55.91,110.89 T40.1
N29708561: length 7.4
  TOP w0.076: UCPU1.BB3 55.09,111.88 v7(54.67,111.46)
  BOTTOM w0.112: T41.1 50.8,112.5 52.53,110.77 53.98,110.77 v7(54.67,111.46)
N29708599: length 7.4
  TOP w0.076: 52.45,114.25 52.49,114.29 52.6,114.29 53.7,115.39 53.7,115.5 53.86,115.67 56.28,115.67 UCPU1.AU5
  TOP w0.112: 52.45,114.25 51.32,113.12 T22.1
N29708601: length 1.2
  TOP w0.076: UCPU1.AT5 56.8,115.96 v7(57.12,115.64)
  BOTTOM w0.112: v7(57.12,115.64) 57.51,116.03 T37.1
N29708639: length 2.4
  TOP w0.112: UCPU1.BB5 56.51,111.87 56.18,111.55 56.18,110.96 56.76,110.39 T39.1
N30248348: length 6.2
  TOP w0.254: PR310.2 140.59,119.06 v7(140.97,118.68)
  BOTTOM w0.254: PR323.1 137.35,120.64 137.35,120.02 v2(137.85,119.52) 138.56,118.81 140.84,118.81 v7(140.97,118.68)
N30249106: length 5.4
  TOP w0.254: 141.86,119.06 141.29,119.06 v7(140.97,119.38)
  BOTTOM w0.254: PR324.1 137.79,120.7 137.79,120.14 138.68,119.25 v2(140.41,119.25) 140.84,119.25 v7(140.97,119.38)
N30252391: length 2.6
  BOTTOM w0.112: PR311.2 v2(132.44,121.16)
  BOTTOM w0.635: PC336.2 PR311.2
N30256954: length 2.2
  TOP w0.112: v2(137.66,128.3) 137.62,128.26 v3(136.73,128.26) PR341.2
  IN2 w0.203: v3(136.73,128.26) 136.73,128.21 v4(136.96,127.98)
  IN3 w0.203: v4(136.96,127.98) 137.13,128.16 v5(137.13,128.31)
  BOTTOM w0.203: v5(137.13,128.31) 136.84,128.61 PU300.24
N30258320: length 2.8
  BOTTOM w0.112: v2(130.26,123.38) 129.73,123.92 PC330.1
  BOTTOM w0.635: PR306.1 PC330.1
N30277718: length 5.8
  TOP w0.127: v2(138.54,134.04) 138.32,134.04 137.6,133.33 PD300.1
  TOP w0.508: PR309.1 135.95,132.01 135.57,132.39 PD301.1 136.74,133.03 136.87,132.9 PD300.1
N30656673: length 1.6
  BOTTOM w0.112: 118.36,141.53 v2(119.94,141.53)
  vias: v7(118.11,142.38) v7(118.75,142.38)
N30656764: length 2.1
  TOP w0.254: PR511.2 122.53,146.29 122.28,146.04 122.28,145.78 121.97,145.48 PU502.12
N30656777: length 11.9
  TOP w0.254: v8(123,142.66) 122.43,142.66 122.22,142.86 122.22,143.8 122.04,143.98 PU502.9
  IN1 w0.254: v8(117.5,148.17) 117.65,148.02 117.65,145.68 118.82,144.51 121.15,144.51 v8(123,142.66)
N30656793: length 2.2
  TOP w0.112: PC526.1 v2(123.52,139.54)
  TOP w0.508: PR512.2 123.95,140.88 PC526.1
N30656795:
  vias: v2(121.28,142.43)
N30663743: length 3.8
  TOP w0.203: PU400.15 71.22,81.7 PC417.1
  TOP w0.254: PR416.1 PR419.1 PC417.1
N30664458: length 3.6
  TOP w0.203: PU400.14 72.71,83.07 72.21,83.57 PC415.1
  TOP w0.254: PC415.1 PR418.1 PR417.1
N30667395: length 1.4
  BOTTOM w0.112: PR508.2 47.21,157.52 v2(47.18,157.55)
N30667598: length 2.7
  BOTTOM w0.112: v2(119.91,143.35) 119.9,143.33 PR513.2
  BOTTOM w0.635: PC537.1 PR513.2
N30668208: length 2
  TOP w0.203: PU400.17 71.4,80.9 70.57,81.73 PR415.1
N30669197: length 5.4
  TOP w0.112: v2(70.47,77.97) 70.47,78.46 70.31,78.63 PR410.2
  TOP w0.203: PR412.1 PR410.2 70.8,79.06 71.88,77.98 72.58,77.98 72.71,78.11 PU400.22
N30669308: length 4.8
  TOP w0.112: v2(78.63,84.57) 78.41,84.57 77.71,83.87 PR404.1
  TOP w0.203: PR404.1 76.81,82.7 76.81,81.76 76.35,81.3 PU400.6
N30669341: length 2.9
  TOP w0.203: PU400.5 76.41,80.9 77.18,81.68 77.18,82.18 PR402.1
N30670358: length 6.3
  TOP w0.112: v2(81.41,82.01) 81.23,81.83 PR401.2
  TOP w0.203: PR401.2 79.87,81.29 77.71,81.29 76.52,80.1 PU400.3
N30670363: length 2
  TOP w0.203: PR403.2 77.36,80.35 76.71,79.7 PU400.2
N30671219: length 2.4
  TOP w0.203: PU400.4 76.44,80.5 77.71,81.78 PC402.1
N30672425: length 3.5
  TOP w0.203: PU400.28 75.11,78.18 75.31,77.98 75.95,77.98 76.66,78.69 PR406.2
N30672977: length 1.8
  TOP w0.203: PR414.1 70.66,80.84 71,80.5 PU400.18
N30673276: length 3.7
  TOP w0.203: PU400.27 74.71,78.01 75.06,77.66 76.2,77.66 76.45,77.92 PR405.2
N30674980: length 13.5
  TOP w0.203: PU400.25 v3(73.91,77.79)
  IN2 w0.066: v3(70.31,87.06) 70.31,86.87 68.96,85.52 68.96,82.58 70.77,80.77 72.21,80.77 72.34,80.65 72.34,79.36 v3(73.91,77.79)
N31973375: length 3
  TOP w0.112: UZ1.4 69.12,98.8 69.11,98.79 RZ1.2 67.83,98.57 v2(67.7,98.69)
N33626933: length 1.6
  TOP w0.112: 31.67,101.68 v2(30.04,101.68)
N33627020: length 2.6
  TOP w0.112: US1.16 33.39,97.94 33.29,97.84 R56.1 33.29,96.01 v2(33.2,95.92)
N34282781: length 2.1
  BOTTOM w0.112: v2(116.04,156.99) RS1.2
  BOTTOM w0.254: RS1.2 117.08,157.38 117.2,157.5 U1.C2
N34283012: length 1.2
  BOTTOM w0.254: U1.C1 117.61,157.72 117.97,157.36 RS2.2
N35110163: length 8.2
  TOP w0.381: PQ126.1 18.09,45.54 18.86,46.31 PU101.4 18.86,47.47 18.47,47.87 v7(17.65,47.87)
  BOTTOM w0.381: v7(17.65,47.87) 18.49,48.71 PR149.2 19.33,48.68 PC131.1 PR153.1
N35110226: length 5.8
  IN1 w0.508: v8(23.27,44.55) 24.47,44.55 25.15,43.88 28.52,43.88 v3(28.7,44.06)
N35113641: length 6.5
  TOP w0.381: PQ100.4 15.55,37.18 PC109.2 15.39,37.02 v8(14.48,37.02) ; PR106.1 13.11,34.38 PQ133.1 13.41,35.52 13.41,36.21 v8(13.54,36.34)
  IN1 w0.381: v8(13.54,36.34) 13.79,36.34 v8(14.48,37.02)
N35114956: length 1.1
  TOP w0.112: v2(17.7,30.1) 18.1,30.5 PQ141.1
N35119332: length 7.8
  TOP w0.381: PQ104.1 24.77,39.17 PR109.1 27.24,39.17 v2(27.79,38.62) PC111.2 PR103.2 26.16,37.63 25.67,37.14 PQ101.4
N35124847: length 2.1
  TOP w0.112: PR109.2 v2(26.64,40.08)
  TOP w0.381: PQ108.1 25.72,41.22 PR109.2
N35126885: length 0.8
  TOP w0.381: PR107.2 21.01,41.6 PQ109.6
N35128375: length 2.1
  TOP w0.112: PQ109.5 20.42,42.25 20.29,42.13 PR176.1 19.93,42.91 PR123.2
N35129437: length 2.8
  TOP w0.112: v2(23.88,41.45) 23.94,41.52 PR115.2 23.56,42.44 23.37,42.25 PQ109.2 PQ109.3
N35130312: length 3
  TOP w0.112: PR101.2 21.01,40.15 v2(20.75,39.89)
  TOP w0.381: PR101.2 PR107.1 21.79,40.76 22.34,40.21 PQ104.2
N35131434: length 9
  TOP w0.381: PR133.1 14.48,20.77 13.46,21.78 13.46,22.04 PQ135.1 13.34,23.15 14.35,24.17 PC123.2 PR128.2 15.47,24.68 16.01,25.22 v2(16.27,25.22) 16.7,25.22 17.13,24.79 PQ113.4
N35131606: length 2.8
  TOP w0.381: PQ118.2 14.74,17.97 PR172.1 PR263.2 16.08,18.66 PQ142.1
N35132002: length 17.9
  TOP w0.112: v2(23.14,31.79) 22.91,31.56 v8(22.91,29.72)
  TOP w0.381: PQ115.1 27.09,22.12 25.73,23.48 PR130.2 25.37,23.46 v8(24.54,23.46) 24.54,22.57 PR134.1
  IN1 w0.381: v8(22.91,29.72) 22.91,30.37 23.27,30.72 25.55,30.72 25.93,30.34 25.93,25.29 24.54,23.89 v8(24.54,23.46)
N35132051: length 8.2
  TOP w0.112: v2(27.14,25.05) 27.96,24.23 v8(27.96,23.73)
  TOP w0.381: PR129.2 23.16,24.12 PR118.1
  IN1 w0.381: v8(27.96,23.73) 27.03,22.8 24.13,22.8 23.15,23.78 v8(23.15,24.07)
N35132981: length 3
  TOP w0.381: PQ119.1 25.65,19.94 25.65,21.91 25.48,22.09 PR134.2
N35133273: length 3.1
  TOP w0.381: PR139.2 20.77,21.93 PQ121.3 22.07,21.93 22.28,22.14 22.28,22.37 22.06,22.58 PQ121.2
N35133295: length 1.4
  TOP w0.381: PQ121.6 22.85,23.23 22.53,23.55 PR118.2
N35133673: length 4.2
  TOP w0.381: PR136.2 22.81,21.15 24.3,21.15 PR177.1 23.98,21.97 23.98,22.34 23.74,22.58 PQ121.5
N35136432: length 15.6
  TOP w0.112: v8(28.8,34.61) v2(28.8,35.59)
  TOP w0.508: PQ102.4 28.75,33.67 PC112.2 v8(28.8,34.61)
  IN1 w0.508: v8(32.21,25.08) 31.14,25.08 27.91,28.31 27.91,33.72 v8(28.8,34.61)
N35140615: length 10.8
  TOP w0.112: v8(35.14,29.4) v2(33.85,29.4)
  TOP w0.508: PR110.1 35.48,28.2 35.14,28.54 v8(35.14,29.4) ; v8(37.72,33.36) PC110.2 36.55,33.21 PQ103.4
  IN1 w0.508: v8(35.14,29.4) 35.08,29.47 35.08,30.72 v8(37.72,33.36)
N35180205: length 4.2
  TOP w0.112: PR160.2 28.32,17.46 PQ111.1 28,18.42 28.19,18.61 29.03,18.61 PR161.2
N35180386: length 1.3
  TOP w0.381: PR121.1 28.91,19.94 PQ111.2
N35223686: length 2.4
  TOP w0.112: PQ119.2 24.75,17.99 24.09,18.65 PR179.2 PR135.1
N35624566: length 1.6
  BOTTOM w0.112: v2(143.74,146.71) 143.83,146.8 R94.1
N35624658: length 1.7
  BOTTOM w0.112: C51.1 143.43,149.03 U11.6
N35660943: length 1.2
  BOTTOM w0.112: TC16.1 57.4,25.82 RT52.2
N35661018: length 6.3
  IN3 w0.066: v5(56.13,20.1) 56.13,24.12 v5(56.39,24.37)
  BOTTOM w0.112: RT55.1 54.44,24.37 RT54.1 v5(56.39,24.37)
N35661105: length 8.5
  IN4 w0.066: v1(55.63,17.1) 55.36,16.83 54.73,16.83 54.04,16.13 53.47,16.13 52.2,14.86 52.2,12.1 52.86,11.44 v1(52.86,10.99)
N35661109: length 9.6
  IN4 w0.066: v1(56.13,17.1) 55.7,16.66 54.8,16.66 54.11,15.96 53.54,15.96 52.36,14.79 52.36,13.04 53.02,12.38 53.02,11.81 53.94,10.9 v1(54.25,10.9)
N35661245: length 4.9
  BOTTOM w0.112: RT96.1 56.01,11.3 56.58,11.88 56.58,14.16 56.13,14.61 UT2.F1
N35662475: length 2
  BOTTOM w0.112: RT58.1 56.63,22.22 UT2.E11
N35662526: length 3.3
  IN4 w0.066: v1(51.99,18.99) 52.11,18.87 54.6,18.87 54.87,18.6 v1(55.13,18.6)
N35662534: length 2.4
  IN4 w0.066: v1(55.63,16.1) 55.63,14.92 56.11,14.44 v1(56.11,13.86)
N35662625: length 3
  BOTTOM w0.112: RT60.2 53.8,23.94 52.26,23.94 TC12.1
N35882361: length 3.9
  TOP w0.112: PQ108.2 26.3,42.77 PR114.1 27.36,41.35 27.27,41.26 PR178.2 27.27,40.73 v2(27.93,40.07)
N35974919: length 2.9
  BOTTOM w0.203: PR332.2 138.35,128.59 138.35,128 137.91,127.56 PU300.26
N35975325: length 4.5
  BOTTOM w0.112: PR325.2 139.41,130.53 139.41,131.37 v2(139.43,131.4)
  BOTTOM w0.203: PR325.2 139.24,130.3 138.55,129.61 138.55,129.22 138.05,128.72 138.05,128.21 137.8,127.96 PU300.25
N36019742: length 1.8
  TOP w0.254: PR733.1 110.93,97.22 110.35,96.64 PU721.7
N36023370:
  vias: v2(105.49,91.29)
N36145369: length 2.4
  TOP w0.381: PR213.2 16.03,35.02 PR214.1 15.02,34.25 PQ133.2
N36146502: length 4.6
  TOP w0.112: 20.45,35.12 20.62,35.12 21.6,34.14 v2(21.6,33.82)
  TOP w0.381: PQ134.3 19.06,35.61 18.89,35.43 18.89,35.13 19.05,34.96 PQ134.2 19.91,34.96 20.07,35.12 20.45,35.12
N36147287: length 3.9
  TOP w0.381: PR228.1 16.78,34.96 PQ134.5 18.26,34.96 18.78,34.44 PR217.2
N36148155: length 2.7
  TOP w0.381: PR222.2 20.24,23 PQ136.3 19.3,22.45 19.1,22.24 19.1,21.99 19.29,21.8 PQ136.2
N36148188: length 2.9
  TOP w0.381: v8(16.89,21.74) 17.36,21.74 17.41,21.8 PQ136.5
  IN1 w0.381: v8(16.89,21.74) 16.89,21.66 17.27,21.27 17.27,20.8 v8(16.62,20.16)
N36161939: length 2.3
  TOP w0.381: PQ118.1 13.56,19.34 PR133.2
N36235793: length 3.8
  BOTTOM w0.203: 28.56,149.79 27.96,149.18 UA1.38
  BOTTOM w0.254: CA17.1 29.54,151.36 CA16.1 29.38,150.67 v2(28.93,150.23) 28.56,149.86 28.56,149.79
N36236376: length 6.1
  BOTTOM w0.203: UA1.39 27.98,148.79 28.74,149.54 28.87,149.54
  BOTTOM w0.254: 28.87,149.54 29.82,150.5 29.82,150.74 30.11,151.03 RA10.2 32.16,151.03 CA20.1
N36237197: length 4.1
  IN4 w0.203: v1(19.98,148.27) 19.61,147.91 19.61,146.25 v1(19.88,145.99)
  BOTTOM w0.203: UA1.21 20.68,148.39 20.57,148.27 v1(19.98,148.27)
N36239979:
  vias: v2(33.76,148.31)
N36240770:
  vias: v2(30.96,144.49)
N36262747: length 2.5
  BOTTOM w0.203: UA1.13 20.84,145.18 20.66,145.01 20.66,144.49 CA32.1
N36265856: length 2.4
  BOTTOM w0.203: UA1.17 20.54,146.79
  BOTTOM w0.254: CA28.1 19.29,146.97 CA27.1 20.36,146.97 20.54,146.79
N36266417: length 2.2
  BOTTOM w0.203: UA1.24 20.91,149.58 20.7,149.8 20.7,150.12 CA18.1
N36266424: length 1.6
  BOTTOM w0.203: CA21.2 20.23,149.18 UA1.23
N36266433: length 3.1
  BOTTOM w0.203: CA21.1 18.88,149.42 19.53,148.77 20.82,148.77 20.83,148.79 UA1.22
N36267340: length 2.5
  BOTTOM w0.112: CA15.1 24.45,152.43 24.71,152.16 UA1.31
N36486549: length 1.2
  TOP w0.112: C47.2 109.4,166.18 U10.2
N36486567: length 1.3
  TOP w0.112: L80.2 109,166.11 U10.1
N36486588: length 3.4
  TOP w0.112: v2(110.85,170.66) 110.54,170.36 110.54,169.72 109.96,169.15 L14.1 109.4,168.64 U10.8
N36486790: length 1.2
  TOP w0.112: U10.6 110.5,168.21 L17.1
N36486804: length 1.2
  TOP w0.112: L16.1 110.8,167.07 110.36,167.51 U10.5
N36486942: length 6.6
  TOP w0.203: U10.10 108.57,167.51
  TOP w0.406: JANT7.1 103.98,168.29 104.37,167.9 107.6,167.9 107.99,167.51 v2(108.08,167.51) 108.57,167.51
N36486969: length 3.3
  TOP w0.112: v2(109.39,171.01) 109.39,169.72 108.89,169.23 L13.1 109,169.04 U10.9
N36486975: length 1.2
  TOP w0.112: U10.4 110.2,166.63 110.3,166.53 R81.2
N36508056: length 3.9
  TOP w0.112: PR137.2 31.27,22.9 30.12,22.9 PQ110.2
N36512614: length 3.4
  TOP w0.112: PQ139.5 33.86,25.85 v2(33.58,26.13)
  TOP w0.381: PQ139.5 34.8,25.85 34.92,25.72 34.92,25.34 34.8,25.21 34.5,25.21 PQ139.6 33.68,25.2 PR252.2
N36516654: length 1.9
  TOP w0.381: PR250.1 37.9,28.93 PR251.2 36.97,28.98 PQ138.2
N36517432: length 3.8
  TOP w0.112: PQ139.2 35.69,25.15 35.69,25.08 35.22,24.62 34.06,24.62 PR253.2
N36723920: length 2.7
  BOTTOM w0.203: RA31.2 RA12.2 28.79,144.73 27.94,145.58 UA1.47
N36849615: length 16.2
  IN3 w0.066: v5(28.13,44.39) 28.13,44.17 27.86,43.91 27.86,43 24.78,39.92 19.1,39.92 18.87,40.15 18.87,41.29 v5(19.18,41.6)
  BOTTOM w0.112: v2(29.72,44.22) 29.38,43.88 RV67.1 28.64,43.88 v5(28.13,44.39) ; v5(19.18,41.6) UV1.38
N36849628: length 10.2
  IN3 w0.066: v5(25.35,43.45) 25.35,43.38 22.05,40.09 19.42,40.09 v5(19.18,40.32)
  BOTTOM w0.112: v5(25.35,43.45) 25.35,43.78 25.63,44.06 RV88.1 RV68.1 ; UV1.35 19.57,40.4 19.49,40.32 v5(19.18,40.32)
N36872279: length 2.3
  TOP w0.112: UCPU1.V1 53.4,125.35 53.09,125.03 TC1.1
N37047752: length 7.2
  TOP w0.112: U7.3 69.79,56.77 70.45,56.11 R74.2 70.45,53.24 71.12,52.57 v2(72.06,52.57)
N37304443: length 1.5
  BOTTOM w0.112: UZ4.12 73.84,25.31 C200.1
N37304446: length 1.5
  BOTTOM w0.112: UZ4.10 73.04,25.38 C201.1
N37731575: length 1.8
  TOP w0.112: JUFC1.26 125.68,172.39 RS26.1
N37731577: length 1.8
  TOP w0.112: RS27.1 125.87,171.99 JUFC1.24
N37731579: length 2
  TOP w0.112: RS25.1 125.54,170.88 124.83,171.59 JUFC1.22
N37841352: length 8
  BOTTOM w0.112: v9(17.93,76.42) 18.75,75.6 SW5.3 19.97,76.39 21.23,76.39 SW5.4 23.65,75.6 23.89,75.36 RE123.2 R490.1
N37999674: length 3.3
  TOP w0.112: PQ125.2 26.39,45.14 26.54,44.98 26.54,43.96 27.09,43.41 PC130.1 PR151.2
N38000200:
  vias: v3(23.11,48.96) v3(23.42,48.94) v3(28.7,45.4) v3(28.68,45.15)
N38000578: length 3.3
  TOP w0.381: PR150.1 24,44.29 23.69,43.97 PC125.1 PR148.1 21.56,43.97 PQ123.2
N38004921: length 1
  TOP w0.381: PQ125.3 24.95,44.49 PR150.2
N38544513: length 1.9
  BOTTOM w0.112: R155.1 C137.1 40.54,76.47 v2(40.12,76.05)
N38872026: length 2.8
  TOP w0.254: PU700.15 130.69,141.05 130.87,141.23 PR709.2 131.94,141.62 131.76,141.8 PC713.1
N38877032: length 4
  TOP w0.254: PU700.14 131.07,140.6 v7(131.19,140.72)
  BOTTOM w0.112: v2(130.58,140.72) v7(131.19,140.72)
  BOTTOM w0.254: PR704.2 PC707.2 ; PC707.2 PR706.1 ; PC707.2 131.75,140.72 v7(131.19,140.72)
N38894882: length 2.4
  BOTTOM w0.112: PR806.2 v2(122.36,124.88)
  BOTTOM w0.508: PC808.1 PR806.2
N38989784: length 1.1
  BOTTOM w0.112: RT97.2 TC17.1
N38989867: length 1.1
  BOTTOM w0.112: RT98.2 59.44,26.16 TC18.1
N39725320: length 1.8
  BOTTOM w0.112: C91.1 31.4,136.38 U13.12
N39725481: length 1.8
  BOTTOM w0.112: U13.10 31.31,135.58 C92.1
N39731522: length 2.4
  BOTTOM w0.112: RT28.2 41.35,64.1 41.08,64.37 39.59,64.37 TC20.1
N39731534: length 4.1
  BOTTOM w0.112: TC21.1 56.31,26.3 56.9,25.72 56.9,23.89 RT57.2
N40373298: length 1
  TOP w0.112: CD67.2 104.97,99.43 105.02,99.38 RD17.1
N40373501: length 2
  BOTTOM w0.127: RD3.1 v2(69.53,100.14)
  BOTTOM w0.508: CD20.2 RD3.1
N40376778: length 2
  BOTTOM w0.112: CD46.2 90.28,109.02 v2(90.51,109.25)
  BOTTOM w0.508: RD9.1 90.27,108.26 CD46.2
N40520768: length 1.1
  BOTTOM w0.112: U4245.4 29.58,127.16 29.39,127.34 R427.1
N40551947: length 3.9
  BOTTOM w0.112: R5774.2 29.87,128.59 29.71,128.42 29.22,128.42 28.85,128.06 28.85,127.32 28.68,127.14 Q25.1 28.38,126.96 28.61,126.72 28.61,126.42 RC92.1
N40701409: length 38.7
  IN4 w0.066: v1(154.32,147.8) 153.58,147.8 152.48,146.71 148.06,146.71 147.82,146.95 145.34,146.95 140.85,151.44 136.33,151.44 129.73,151.44 126.97,154.19 v1(126.97,156.28)
  BOTTOM w0.112: R431.2 R429.1 124.5,155.42 124.59,155.51 Q26.2 ; R431.2 123.91,156.11 v2(123.2,156.82) ; R431.2 124.34,156.11 124.59,156.36 126.89,156.36 v1(126.97,156.28)
N40701429: length 7.8
  BOTTOM w0.112: v2(123.22,155.47) 123.85,154.84 R429.2 124.5,154.42 127.61,154.42 127.72,154.53 127.72,155.31 127.61,155.42 R428.1 ; R428.1 R430.2 ; R428.1 127.09,155.42 127,155.51 Q26.5
N40701445: length 1
  BOTTOM w0.112: Q26.6 127.21,155.01 R428.2
N40769084: length 3.6
  BOTTOM w0.112: QZ9.2 33.45,102.76 v2(33.83,102.38) 33.83,101.94 33.66,101.77 C1133.1 R5778.1
N40913230: length 2.9
  TOP w0.508: PR266.2 v2(36.47,23.97) 37.58,25.07 PQ112.2
N40915054: length 2
  BOTTOM w0.112: U16.4 18.87,126.5 R215.1 R214.1
N40922663: length 7.3
  IN1 w0.066: v7(79.36,20.99) 80.18,20.99 81.82,22.64 84.66,22.64 v8(85.1,22.2)
  BOTTOM w0.112: R421.2 v7(79.36,20.99)
N40922742: length 9.9
  IN1 w0.066: v8(85.1,22.7) 84.84,22.7 84.51,23.03 81.57,23.03 80.43,21.88 v7(79.34,21.88)
  BOTTOM w0.112: v2(79.39,24.33) 79.88,23.84 79.88,22.43 v7(79.34,21.88) R420.2
N40924684: length 6.8
  IN2 w0.066: v4(85.03,32.58) 85.03,36.36 85.1,36.44 v3(85.1,36.7)
  IN3 w0.066: v5(82.54,32.92) 84.68,32.92 v4(85.03,32.58)
N40928090: length 1.7
  TOP w0.381: PQ106.1 13.77,32.91 PR106.2
N40945196: length 1.4
  TOP w0.112: R11.1 125.26,161.81 125.18,161.74 JWFC1.30
N41064828: length 3.1
  BOTTOM w0.112: C206.1 23.17,126.5 U16.3 ; C206.1 R217.1 ; C206.1 R218.2
N41228936: length 2.5
  BOTTOM w0.203: PU300.27 138.01,127.16 138.68,127.83 138.68,128.03 PR322.1
N41258423: length 11.6
  IN4 w0.254: v1(39.37,55.5) 39.37,56.37 39.65,56.64 39.65,58.63 38.96,59.32 38.71,59.32 38.51,59.53 38.51,59.86 37.53,60.83 37.53,61.49 v1(36.69,62.33)
  BOTTOM w0.112: v2(37.78,55.91) 38.25,55.91 38.66,55.5 v1(39.37,55.5)
  BOTTOM w0.254: v1(36.69,62.33) UT1.A7 ; UT1.A7 UT1.B7 ; UT1.A7 UT1.A6
N41259108: length 8.9
  IN3 w0.254: v5(58.63,19.1) 59.86,19.1 60.52,19.75 63.28,19.75 63.47,19.56 v5(64.14,19.56)
  BOTTOM w0.112: v2(65.42,20.21) 64.77,19.56 v5(64.14,19.56)
  BOTTOM w0.254: v5(58.63,19.1) UT2.A7 ; UT2.A7 UT2.A6 ; UT2.A7 UT2.B7
N41312056: length 1.6
  TOP w0.203: JWFC1.33 124.7,162.94
  TOP w0.254: R435.1 125.44,162.4 124.89,162.94 124.7,162.94
N41704672: length 5.1
  TOP w0.112: L81.1 C9.1 38.41,166.5 JANT3.1
N41704676: length 11.5
  TOP w0.112: JANT2.1 52.15,167.05 51.99,166.89 44.83,166.89 44.44,166.5 C1039.1 L81.2
N41804763: length 3.9
  TOP w0.112: R29.1 152.78,134.95 D22.1 v2(154.21,135.1) 154.67,135.56 JFAN1.2
N41804779: length 6.5
  TOP w0.127: v2(155.08,141.49) 153.94,140.35
  TOP w0.508: R438.2 154.64,140.35 155.18,139.8 155.18,138.74 154.69,138.25 154.69,137.69 154.82,137.56 JFAN1.4
N41946502: length 10.5
  TOP w0.076: v8(55.02,124.4) 54.99,124.43 54.99,124.68 54.96,124.71 UCPU1.V2
  TOP w0.112: RC198.2 47.56,123.86 47.56,123.42 47.83,123.15 48.11,123.15 v8(48.13,123.13)
  IN1 w0.066: 53.85,123.74 53.23,123.12 52.92,123.12 52.7,122.9 50.95,122.9 50.81,122.9 50.67,122.9 50.66,122.89 50.65,122.89 50.59,122.82 49.61,122.82 49.47,122.96 49.47,122.96 49.43,123 48.28,123 48.16,123.13 v8(48.13,123.13)
  IN1 w0.076: 53.85,123.74 53.95,123.74 54.48,124.26 54.87,124.26 v8(55.02,124.4)
N42195540: length 25.9
  TOP w0.112: v7(85.03,6.61) 84.26,6.61 83.75,6.09 JSPK.5
  IN3 w0.066: v5(68,21.4) 82.79,6.61 v7(85.03,6.61)
N43237751: length 1.2
  TOP w0.254: PR216.1 37.38,46.8 PQ130.1
N43238317: length 1.3
  TOP w0.254: PR125.2 38.71,49.47 37.98,49.47 PQ130.2
N43294004: length 2.3
  TOP w0.112: PR225.1 34.19,47.65 PQ131.1
N43294007: length 1.3
  TOP w0.112: PR146.2 31.85,49.42 PQ131.2
N43294016: length 2.4
  TOP w0.112: v2(29.24,40.24) 29.51,40.51 PR165.1 29.7,41.4 PQ132.2
N43396886: length 3.5
  BOTTOM w0.112: R450.2 34.06,93.92 34.98,93.92 35.36,93.54 U4246.29
N43397013: length 2.8
  BOTTOM w0.112: R451.1 35.43,91.7 36.27,92.54 U4246.27
N43502333: length 8.1
  TOP w0.112: PU103.4 29.36,47.19 29.82,46.72 PR117.1 31.18,45.67 PD110.2 31.21,45.63 PR182.2
  IN2 w0.066: v4(32.13,47.06) 32.13,45.76 v3(32.26,45.63)
  IN3 w0.066: v4(32.13,47.06) 31.88,47.31 v5(31.88,47.36)
  BOTTOM w0.112: v5(31.88,47.36) PR163.2 32.77,46.53 v2(32.92,46.38)
N43502350: length 15.4
  TOP w0.112: PQ132.1 30.35,44.79 PD110.1 29.46,45.68 29.46,46.17 29.16,46.47 27.99,46.47 v3(27.38,47.08) 27.28,47.19 PU103.3
  IN2 w0.066: v4(27.67,46.79) v3(27.38,47.08)
  IN3 w0.066: v4(27.67,46.79) 27.7,46.79 v5(27.94,46.55)
  BOTTOM w0.112: v2(32.77,49.37) PR163.1 33.43,47.61 33.43,46.45 32.98,46 32.12,46 PR111.2 PR256.1 PC281.1 28.24,46.24 v5(27.94,46.55)
N43507801: length 5.9
  TOP w0.381: v3(28.28,48.91) 28.11,49.09 PU103.1
  IN2 w0.381: v4(28.28,48.54) v3(28.28,48.91)
  IN3 w0.381: v5(28.57,48.83) v4(28.28,48.54)
  BOTTOM w0.508: PR255.1 PR183.2 29.74,48.27 29.36,47.89 v2(28.88,47.89) 28.57,48.2 v5(28.57,48.83)
N43518647: length 3.7
  BOTTOM w0.112: v2(30.52,151.89) 30.52,152.3 29.69,153.13 RA8.2 29.17,153.09 CA46.1 27.95,153.09 RA27.1
N43518650: length 1.5
  BOTTOM w0.112: RA27.2 CA47.1 RA28.1
N43524087: length 24.3
  TOP w0.254: PU104.3 37.31,44.13 38.02,44.13 PC282.1 PR258.1 PR113.2 38.02,41.97 38.53,41.47 38.53,41.16 38.53,38.85 38,38.32 34.81,38.32 PD111.1 v2(31.93,41.2) 31.93,44.24 32.83,45.14 33.27,45.14 33.9,44.52 34.77,44.52 36.04,45.79 PQ140.1 37.07,45.79 PR164.1
N43524117: length 10.4
  TOP w0.112: PU104.4 34.2,43.75 33.23,44.72 v2(33.08,44.72)
  TOP w0.254: PD111.2 PR184.2 33.32,43.22 33.79,43.22 PU104.4 34.94,43.75 36.2,45.01 PR164.2 PR120.1 38.47,44.64 39.4,44.64 PC149.1
N43524149: length 2.1
  TOP w0.112: PC148.1 37.17,38.93 36.73,39.37 35.64,39.37 v2(35.38,39.63)
N43524263: length 1.9
  TOP w0.112: PQ140.2 34.89,46.44 35.26,46.8 PR167.1
N44373987: length 5
  BOTTOM w0.112: RT109.1 41.83,68.53 39,68.53 38.19,67.72 UT1.L11
N44375634: length 3.4
  BOTTOM w0.076: UT2.L11 53.41,20.82 53.33,20.82 53.09,21.07
  BOTTOM w0.112: 53.09,21.07 52.79,21.36 51.68,21.36 51.09,21.95 RT111.1
N44998008: length 4.5
  GND1 w0.066: v12(85.1,27.7) v4(85.46,27.7)
  GND3 w0.066: v4(85.46,27.7) v13(85.05,27.7)
  BOTTOM w0.112: R464.2 82.7,25.8 83.82,26.91 84.49,26.91 85.05,27.47 v13(85.05,27.7)
N44998011: length 3.3
  GND1 w0.066: v12(85.1,27.2) v4(84.75,27.2)
  GND3 w0.066: v13(84.51,27.43) 84.74,27.2 v4(84.75,27.2)
  BOTTOM w0.112: R465.2 82.99,26.68 83.74,27.43 v13(84.51,27.43)
N44998014: length 4.4
  GND1 w0.066: v12(85.1,26.2) 85.25,26.2 v4(85.5,26.44)
  GND3 w0.066: v4(85.5,26.44) 85.06,26.44 v13(85.01,26.39)
  BOTTOM w0.112: v13(85.01,26.39) 84.26,26.39 82.78,24.91 R466.2
N44998017: length 3.6
  GND1 w0.066: v12(85.1,25.2) v4(84.76,25.2)
  GND3 w0.066: v4(84.76,25.2) v13(84.42,25.2)
  BOTTOM w0.112: R467.2 82.74,24.02 83.92,25.2 v13(84.42,25.2)
N44998020: length 3.9
  GND1 w0.066: v4(84.75,24.6) 84.85,24.7 v12(85.1,24.7)
  GND3 w0.066: v4(84.75,24.6) v13(84.34,24.6)
  BOTTOM w0.112: R468.2 82.87,23.13 v13(84.34,24.6)
N45241794: length 21.9
  TOP w0.076: v8(57.81,135.68) 57.81,134.48 57.5,134.18 UCPU1.B7
  IN1 w0.066: v8(57.81,135.68) 58.19,135.68 59.66,134.2 59.66,132.68 59.48,132.5 59.26,132.5 58.98,132.22 58.98,131.26
  IN1 w0.076: v10(58.98,129.94) 58.98,131.26
  IN2 w0.066: v10(58.98,129.94) 58.92,129.99 v4(58.6,129.99)
  IN3 w0.066: v4(58.6,129.99) 58.6,129.94 58.09,129.43 57.76,129.43 57.23,129.96 56.63,129.96 v6(56.1,129.43)
  IN4 w0.066: v1(48.77,125.93) 48.76,125.94 48.76,126.59 48.93,126.76 49.28,126.76 49.69,127.17 52.56,127.17 53.92,128.54 53.92,128.69 54.5,129.26 55.93,129.26 v6(56.1,129.43)
  BOTTOM w0.112: RC197.1 48.82,125.87 48.77,125.92 v1(48.77,125.93)
