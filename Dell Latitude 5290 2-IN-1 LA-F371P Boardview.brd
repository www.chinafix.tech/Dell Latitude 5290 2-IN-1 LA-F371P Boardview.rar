# Allegro board Dell Latitude 5290 2-IN-1 LA-F371P Boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CPU_DP2_CTRL_CLK: length 12.2
  TOP w0.076: UCPU1.N7 57.33,127.94 57.33,128.26 57.07,128.51 56.57,128.51 56.44,128.64 56.44,128.74 56.21,128.97 56.21,129.42 56.04,129.59 55.6,129.59 54.95,128.94 53.34,128.94
  TOP w0.112: RC43.1 48.63,127.98 v2(48.63,127.85) 48.81,127.67 51.81,127.67 53.09,128.94 53.34,128.94
CPU_DP2_CTRL_DATA: length 12.2
  TOP w0.076: 53.34,128.39 54.74,128.39 55,128.64 55,128.76 55.16,128.93 56.04,128.93 56.29,128.68 56.29,128.41 56.49,128.21 56.9,128.21 57.05,128.06 57.05,127.75 57.18,127.62 57.71,127.62 57.99,127.91 UCPU1.N8
  TOP w0.112: 53.34,128.39 52.98,128.39 v2(52.26,127.66) 52.05,127.46 48.26,127.46 RC45.1
CPU_DP2_HPD: length 194.9
  TOP w0.076: 53.34,129.67 53.41,129.74 55.43,129.74 55.66,129.98 55.66,130.1 55.82,130.25 56.04,130.25 56.36,129.93 56.36,129.4 56.65,129.12 57.07,129.12 v12(57.07,129.12) UCPU1.L7
  TOP w0.112: RC46.2 51.92,128.11 52.25,128.43 52.25,128.59 53.34,129.67
  GND1 w0.066: v12(57.07,129.12) 57.07,129.5 v4(57.02,129.55)
  IN3 w0.066: v6(58.35,94.78) 57.49,95.65 54.13,95.65 52.94,96.83 51.45,96.83 50.78,97.5 47.78,97.5 45.66,99.61 45.22,99.61 42.73,102.11 37.16,102.11 v5(36.58,101.53) ; v6(59.54,62.09) 43.46,62.09 43.26,61.89 v5(43.26,61.79) ; v4(57.02,129.55) 56.79,129.33 v6(56.59,129.33) ; v6(59.94,41.7) 59.82,41.57 58.25,41.57 58.14,41.45 45.83,41.45 45.4,41.02 41.92,41.02 40.97,41.97 35.15,41.97 34.47,41.29 29.62,41.29 28.5,40.17 25.75,40.17 24.28,38.7 19.8,38.7 19.47,39.03 17.42,39.03 16.89,38.5 v5(16.89,38.29)
  IN4 w0.066: v6(56.59,129.33) 56.46,129.33 56.23,129.09 54.56,129.09 54.2,128.73 54.2,128.58 52.53,126.91 52.28,126.91 51.61,126.24 51.61,122.81 52.83,121.59 52.83,118.94 53.65,118.11 53.65,116.42 53.4,116.16 53.4,113.56 53.42,113.54 53.42,113.43 54.58,112.26 54.58,111.9 54.08,111.39 54.08,110.83 55.04,109.87 55.04,106.56 55.77,105.83 55.77,102.14 55.94,101.97 55.94,99.93 58.34,97.52 58.34,94.78 ; 58.34,94.78 v6(58.35,94.78) ; 58.34,94.78 58.34,92.37 59.31,91.4 59.31,90.46 59,90.16 59,88.41 59.56,87.86 59.56,86.37 59.21,86.02 59.21,84.01 59.46,83.76 59.46,62.17 v6(59.54,62.09) 59.54,52.74 59.43,52.63 59.43,45.11 59.84,44.69 59.84,41.79 v6(59.94,41.7)
  BOTTOM w0.112: v5(16.89,38.29) 16.75,38.29 15.9,39.14 v2(15.9,39.33) ; v5(36.58,101.53) 35.79,101.53 D106.1
CPU_ID: length 12.4
  IN4 w0.066: v1(24.16,120.07) 24.16,120.08 24.26,119.98 24.56,119.98 25.34,120.75 25.34,121.16 26.02,121.84 26.26,121.84 26.7,122.28 26.7,122.52 27.26,123.08 27.71,123.08 27.91,123.28 27.91,123.73 28.32,124.14 v1(28.32,124.4)
  BOTTOM w0.076: 23.69,119.32 23.62,119.24 23.62,118.23 23.8,118.05 23.89,118.05 24.21,117.72 24.21,116.29 UE3.J10
  BOTTOM w0.112: 23.69,119.32 23.76,119.38 23.76,119.58 24.16,119.98 v1(24.16,120.07) ; RE196.1 v1(28.32,124.4)
CPU_POPIRCOMP: length 1.5
  TOP w0.254: v7(62.56,115.63) 62.65,115.63 62.98,115.96 UCPU1.AT16
  BOTTOM w0.508: RC160.1 63.18,115.63 v7(62.56,115.63)
CPU_XDP_PRDY#: length 83
  IN1 w0.066: v10(105.94,132.5) 105.63,132.5 103.42,130.29 101.14,130.29 100.38,129.53 96.57,129.53 95.66,130.45 95.66,130.73 94.87,131.52 90.23,131.52 88.33,133.42 86.43,133.42 v8(85.89,132.87)
  IN2 w0.066: v4(112.22,134.3) 110.41,132.5 v10(105.94,132.5)
  IN3 w0.066: v5(153.21,119.5) 153.1,119.39 150.09,119.39 149.96,119.52 149.96,122.69 146.13,126.52 142.04,126.52 141.53,126.01 140.19,126.01 137.34,128.86 135.39,128.86 134.92,128.39 131.37,128.39 131,128.02 128.65,128.02 127.95,127.32 127.13,127.32 126.56,127.89 126.56,128.35 126.08,128.83 125.8,128.83 124.15,130.47 113.16,130.47 113.03,130.6 113.03,133.31 112.22,134.13 v4(112.22,134.3)
CPU_XDP_PREQ#: length 89.1
  TOP w0.076: UCPU1.D61 87.85,132.87 87.44,132.46 86.42,132.46 86.25,132.64 86.25,134.56 86.29,134.65 86.29,135.4 v3(86.28,135.42)
  IN2 w0.066: v3(86.28,135.42) 86.62,135.07 87.45,135.07 87.63,135.26 88.13,135.26 88.52,134.86 93.26,134.86 94.01,135.61 98.75,135.61 99.54,134.82 99.54,132.86 101.6,130.81 106.73,130.81 107.53,131.6 112.05,131.6 v4(112.52,132.07)
  IN3 w0.066: v4(112.52,132.07) 112.52,130.72 112.94,130.3 123.44,130.3 125.5,128.25 125.5,127.37 126.43,126.44 129.76,126.44 133,123.2 137.76,123.2 139.84,125.28 141.41,125.28 142.48,126.35 146.06,126.35 149.79,122.62 149.79,118.45 v5(150.32,117.92)
  BOTTOM w0.112: JXDP1.3 151.3,118.9 v5(150.32,117.92)
CS_CORE1: length 24.7
  TOP w0.254: PU1005.12 81.48,159.78 81.28,159.98 81.28,160.59 v3(81.31,160.62)
  IN2 w0.254: v4(60.76,158.48) 60.76,158.61 61.15,159.01 65.62,159.01 67.23,160.62 v3(81.31,160.62)
  IN3 w0.254: v5(60.29,158.47) 60.64,158.47 60.66,158.48 v4(60.76,158.48)
  BOTTOM w0.203: PU900.5 60.16,157.88
  BOTTOM w0.254: v5(60.29,158.47) 60.16,158.34 60.16,157.88
CS_CORE2: length 10.2
  TOP w0.112: v3(64.47,160.64) 63.84,160.64 v2(63.69,160.8)
  TOP w0.203: PU1006.12 64.59,159.81 64.47,159.93 v3(64.47,160.64)
  IN2 w0.254: v4(59.41,158.84) 59.41,159.5 59.96,160.05 62.33,160.05 62.93,160.64 v3(64.47,160.64)
  IN3 w0.254: v4(59.41,158.84) 59.42,158.83 v5(59.42,158.47)
  BOTTOM w0.203: PU900.4 59.76,157.72
  BOTTOM w0.254: 59.76,157.72 59.76,158.14 v5(59.42,158.47)
CS_GT: length 41.2
  TOP w0.254: PU1107.12 94.21,157.06 93.9,157.37 v3(93.9,158.28)
  IN2 w0.254: v4(60.76,157.44) 61.14,157.44 61.95,158.26 66.43,158.26 67.52,159.35 73.43,159.35 74.9,157.88 78.36,157.88 79.55,159.07 92.15,159.07 92.94,158.28 v3(93.9,158.28)
  IN3 w0.254: v4(60.76,157.44) 59.27,157.44 58.56,158.15 v5(58.56,158.47)
  BOTTOM w0.254: PU900.1 58.56,158.47 v5(58.56,158.47)
CS_SA: length 5.5
  IN2 w0.254: v3(55.19,156.28) 55.32,156.15 57.15,156.15 v4(57.33,156.33)
  IN3 w0.254: v5(57.71,156.37) 57.37,156.37 v4(57.33,156.33)
  BOTTOM w0.254: v5(57.71,156.37) 57.38,156.37 57.04,156.71 57.04,157.36 57.7,158.01 PR913.1
CSI2_COMP: length 1.2
  TOP w0.305: v7(60.81,132.42) 61.13,132.1 UCPU1.E13
  BOTTOM w0.305: v7(60.81,132.42) 60.88,132.35 RC114.1
CSSUMA: length 7.6
  IN4 w0.254: v1(63.81,154.37) 62.43,155.74 62.43,157.7 60.74,159.39 v1(60.29,159.39)
  BOTTOM w0.254: v1(60.29,159.39) PR911.2
CSSUMB: length 8.6
  IN4 w0.254: v1(63.81,153.97) 63.65,153.97 62.05,155.56 62.05,157.47 60.6,158.92 59.03,158.92 v1(58.56,159.39)
CSSUMC: length 10.3
  IN4 w0.254: v1(58.12,158.95) 58.12,158.36 58.43,158.05 60.91,158.05 61.7,157.27 61.7,155.42 62.36,154.76 62.36,154.09 62.88,153.57 v1(63.8,153.57)
  BOTTOM w0.254: v1(58.12,158.95) 57.7,159.38 PR913.2
DAT_SMB: length 8.4
  IN2 w0.066: v3(145.33,96.84) 145.33,97.3 145.26,97.37 143.92,97.37 143.64,97.65 143.64,98.48 141.22,100.89 140.36,100.89 140.17,101.08 140.17,101.29 140.11,101.36 v3(139.7,101.36)
DCIN1_EN: length 100.1
  TOP w0.112: v2(22.9,33.78) 22.59,33.48 20.82,33.48 v3(20.57,33.72)
  IN2 w0.066: v3(20.57,33.72) 21.79,34.94 21.79,41.85 22.61,42.66 22.61,43.35 21.49,44.46 21.49,46.11 16.36,51.24 16.36,75.76 v4(16.15,75.96)
  IN3 w0.066: v6(26.64,76.57) 18.9,76.57 18.29,75.96 v4(16.15,75.96)
  IN4 w0.066: v6(26.64,76.57) 26.64,76.87 26.02,77.5 26.02,77.7 21.59,82.13 21.59,86.59 21.74,86.74 21.74,89.03 22,89.29 22,94.34 21.13,95.2 21.13,97.47 18.99,99.61 18.99,100.2 18.77,100.42 18.77,102.49 19.15,102.87 19.15,104.32 18.79,104.68 18.79,105.09 19.6,105.89 19.6,106.28 19.35,106.52 v1(19.35,106.57) 19.35,106.69 20.52,107.86 20.52,108.4 21.03,108.9 21.56,108.9 22.06,109.4 22.06,110.51 22.33,110.77 22.5,110.77 22.93,111.2 v1(23.13,111.2)
DCIN2_EN: length 149.3
  TOP w0.112: v3(18.39,21.17) 18.39,20.99 PR132.1
  IN2 w0.066: v3(18.39,21.17) v4(18.39,21.53)
  IN3 w0.066: v6(46.23,24.97) 46.16,25.03 41.5,25.03 41.26,24.79 38.84,24.79 35.55,21.5 28.88,21.5 28.4,21.02 25.27,21.02 24.64,21.66 24.64,23.03 24.38,23.28 19.86,23.28 18.39,21.81 v4(18.39,21.53)
  IN4 w0.066: v6(46.23,24.97) 46.01,25.19 46.01,36.8 45.8,37.01 45.8,40.52 45.23,41.09 45.23,41.83 45.24,41.84 45.24,41.84 45.24,42.06 45.24,42.06 45.24,42.51 45.24,42.51 45.24,42.6 45.49,42.85 45.49,45.88 41.3,50.08 36.54,50.08 35.29,51.33 35.29,55.89 35.51,56.11 35.51,57.29 34.62,58.18 34.62,59.02 32.78,60.86 32.65,60.86 32.5,61.01 31.25,61.01 29.54,62.72 29.54,67.12 29.36,67.31 29.36,69.87 29.47,69.99 29.47,71.35 28.83,71.99 28.83,72.56 26.51,74.87 26.12,74.87 25.15,75.85 24.95,75.85 22.53,78.27 22.53,79.39 21.49,80.43 20.61,80.43 18.17,82.88 18.17,89.31 18.66,89.81 18.66,94.01 17.25,95.42 17.25,96.01 15.36,97.89 15.36,103.44 15.64,103.71 15.64,107.16 15.81,107.33 15.81,107.51 18.53,110.23 18.53,111.54 18.53,111.54 18.53,113.44 18.95,113.86 18.95,115.79 19.61,116.45 20.78,116.45 20.96,116.63 20.96,117.61 21.22,117.87 21.68,117.87 21.91,117.64 22.3,117.64 v1(22.33,117.62)
  BOTTOM w0.076: UE3.L12 v1(22.33,117.62)
DDI1_P2_TXN0: length 157.7
  IN2 w0.081: v4(29.63,25.62) 29.86,25.85 37.22,25.85 58.83,47.46 58.83,71.55 59.73,72.45 59.73,76.37 61.92,78.55 61.92,85.17 64.28,87.54 64.28,89.94 59.11,95.11 59.11,95.91 56.32,98.71 56.32,107.53 57.21,108.42 57.95,108.42 58.52,109 58.52,111.66 58.48,111.7 58.48,113.43 59.32,114.26 60.68,114.26 61.3,114.89 61.3,118.38 61.9,118.98 63.13,118.98 63.36,119.21 64.79,119.21 65.15,119.57 65.15,119.88 65.53,120.26 67.69,120.26 68.33,120.89 79.63,120.89 79.93,120.59 82.7,120.59 84.98,122.88 84.98,129.18 85.11,129.3 85.11,130.14 85.48,130.51 85.48,131.67 85.28,131.87 85.21,131.87 v3(84.99,132.1)
  IN3 w0.081: v5(26.58,27.88) 27.22,27.88 29.3,25.8 29.45,25.8 v4(29.63,25.62)
DDI1_P2_TXN0_C: length 2
  BOTTOM w0.112: UV2.10 24.67,27.65 24.77,27.74 25.1,27.74 25.46,28.11 25.77,28.11 CV47.2
DDI1_P2_TXN1: length 161.8
  IN2 w0.081: v4(31.93,23.62) 32.05,23.75 32.86,23.75 33.51,24.4 37.43,24.4 60,46.97 60,71.06 61.53,72.59 61.53,76.5 63.1,78.06 63.1,79.93 63.75,80.58 63.75,85.34 65.46,87.05 65.46,90.43 60.29,95.6 60.29,96.4 57.65,99.05 57.65,105.29 58.45,106.09 58.45,107.2 59.7,108.45 59.7,109.98 61.3,111.58 61.3,112.44 62.74,113.88 63.07,113.88 63.42,114.23 65.55,114.23 65.74,114.42 67.39,114.42 67.71,114.73 67.71,116.57 67.79,116.65 68.45,116.65 68.83,116.27 69.34,116.27 69.72,116.65 69.72,118.05 70.33,118.65 71.33,118.65 71.96,119.29 72.22,119.29 72.86,118.65 86.3,118.65 87.58,119.93 87.58,120.61 87.28,120.91 87.28,128.62 87.5,128.84 87.5,131.52 86.93,132.1 v3(86.82,132.1)
  IN3 w0.081: v5(26.58,26.61) 26.68,26.7 26.89,26.7 26.99,26.8 27.36,26.8 30.42,23.74 31.81,23.74 v4(31.93,23.62)
DDI1_P2_TXN1_C: length 2
  BOTTOM w0.112: CV50.2 25.77,26.84 25.5,26.84 25.2,26.54 24.96,26.54 24.86,26.45 UV2.13
DDI1_P2_TXN2: length 157.3
  IN2 w0.081: v4(27.06,25.4) 27.19,25.53 28.74,25.53 29.11,25.9 29.11,26.37 29.27,26.54 37.07,26.54 58.24,47.7 58.24,71.79 59.14,72.7 59.14,76.61 61.33,78.8 61.33,85.42 63.69,87.78 63.69,89.69 58.52,94.86 58.52,95.67 55.73,98.47 55.73,106.23 55.73,107.21 54.82,108.11 54.82,109.18 55.99,110.35 55.99,111.04 56.84,111.89 56.84,114.09 57.06,114.31 58.21,114.31 58.54,114.64 58.54,118.29 58.56,118.31 60.51,120.26 61.09,120.26 61.11,120.25 64.55,120.25 65.16,120.85 67.11,120.85 68.41,122.14 69.74,122.14 70.39,121.49 78.85,121.49 79.01,121.64 82.89,121.64 84.39,123.15 84.39,130.31 84.71,130.62 84.71,131.1 84.44,131.37 84.15,131.37 v3(84.07,131.45)
  IN3 w0.081: v4(27.06,25.4) 26.92,25.55 26.79,25.55 v5(26.58,25.34)
DDI1_P2_TXN2_C: length 1.8
  BOTTOM w0.112: CV52.2 25.9,25.25 UV2.16
DDI1_P2_TXN3: length 159
  IN2 w0.081: v4(27.08,23.47) 27.26,23.65 29.44,23.65 30.81,25.02 37.22,25.02 59.42,47.21 59.42,71.31 60.32,72.21 60.32,76.12 62.51,78.31 62.51,84.93 64.87,87.29 64.87,90.18 59.7,95.35 59.7,96.16 57.06,98.8 57.06,105.62 57.86,106.42 57.86,107.5 59.11,108.75 59.11,110.23 60.7,111.82 60.71,112.29 60.71,112.68 60.71,113.45 61.73,114.47 62.83,114.47 63.2,114.85 63.56,114.85 63.73,114.85 64.01,115.13 64.01,116.46 64.08,116.54 64.08,116.75 64.08,117.02 63.98,117.12 63.98,117.82 64.34,118.18 65.54,118.18 66.61,119.24 71.08,119.24 71.71,119.88 72.47,119.88 73.09,119.26 85.32,119.26 85.93,119.87 85.93,120.3 86.09,120.46 86.3,120.46 86.69,120.85 86.69,128.75 86.44,129 86.05,129.39 86.05,130.15 86.56,130.66 86.56,131 86.25,131.32 86.03,131.32 v3(85.9,131.45)
  IN3 w0.081: v5(26.58,23.43) 26.7,23.55 27,23.55 v4(27.08,23.47)
DDI1_P2_TXN3_C: length 2.1
  BOTTOM w0.112: CV55.2 25.79,23.64 25.52,23.64 25.02,24.14 24.71,24.14 24.62,24.05 UV2.19
DDI1_P2_TXP0: length 157.4
  IN2 w0.081: v3(84.99,131.45) 84.99,131.59 85.07,131.67 85.2,131.67 85.28,131.59 85.28,130.6 84.9,130.22 84.9,129.39 84.78,129.26 84.78,122.96 82.61,120.79 80.02,120.79 79.71,121.1 68.24,121.1 67.61,120.46 65.45,120.46 64.95,119.96 64.95,119.66 64.7,119.41 63.27,119.41 63.04,119.18 61.82,119.18 61.1,118.47 61.1,114.97 60.6,114.47 59.23,114.47 58.28,113.51 58.28,111.61 58.32,111.58 58.32,109.08 57.86,108.62 57.13,108.62 56.11,107.61 56.11,98.63 58.91,95.83 58.91,95.02 64.08,89.85 64.08,87.62 61.71,85.26 61.71,78.64 59.53,76.45 59.53,72.54 58.62,71.63 58.62,47.54 37.13,26.05 29.73,26.05 v4(29.63,26.15)
  IN3 w0.081: v5(26.58,28.51) 26.58,28.26 26.76,28.08 27.3,28.08 29.38,26 29.55,26 29.63,26.08 v4(29.63,26.15)
DDI1_P2_TXP0_C: length 2
  BOTTOM w0.112: UV2.9 24.67,28.05 24.77,27.95 25.01,27.95 25.37,28.32 25.81,28.32 CV45.2
DDI1_P2_TXP1: length 161.9
  IN2 w0.081: v4(31.93,24.15) 31.93,24.09 32.07,23.95 32.77,23.95 33.43,24.6 37.35,24.6 59.8,47.05 59.8,71.15 61.33,72.67 61.33,76.59 62.89,78.15 62.89,80.01 63.55,80.66 63.55,85.42 65.26,87.13 65.26,90.34 60.09,95.51 60.09,96.32 57.44,98.96 57.44,105.38 58.24,106.18 58.24,107.28 59.5,108.54 59.5,110.07 61.09,111.66 61.09,112.52 62.65,114.09 62.99,114.09 63.33,114.43 65.47,114.43 65.66,114.62 67.31,114.62 67.51,114.82 67.51,116.65 67.71,116.85 68.54,116.85 68.92,116.47 69.26,116.47 69.52,116.74 69.52,118.13 70.24,118.86 71.24,118.86 71.88,119.49 72.31,119.49 72.94,118.86 86.22,118.86 87.38,120.02 87.38,120.52 87.08,120.82 87.08,128.7 87.3,128.93 87.3,131.44 86.95,131.79 86.84,131.79 86.78,131.73 86.78,131.49 v3(86.82,131.45)
  IN3 w0.081: v5(26.58,27.24) 26.58,27.02 26.7,26.91 26.81,26.91 26.91,27 27.44,27 30.5,23.94 31.8,23.94 31.93,24.07 v4(31.93,24.15)
DDI1_P2_TXP1_C: length 2
  BOTTOM w0.112: CV49.2 25.81,27.05 25.41,27.05 25.11,26.75 24.96,26.75 24.86,26.85 UV2.12
DDI1_P2_TXP2: length 157.3
  IN2 w0.081: v3(84.07,130.8) 84.02,130.8 83.93,130.88 83.93,131.09 84.01,131.17 84.36,131.17 84.51,131.02 84.51,130.71 84.19,130.39 84.19,123.23 82.81,121.85 78.92,121.85 78.77,121.69 70.47,121.69 69.82,122.34 68.32,122.34 67.03,121.05 65.07,121.05 64.47,120.45 61.19,120.45 61.18,120.46 60.43,120.46 58.69,118.73 58.69,118.73 58.35,118.39 58.34,118.38 58.34,114.72 58.13,114.51 56.97,114.51 56.64,114.17 56.64,111.97 55.79,111.13 55.79,110.44 55.57,110.22 54.62,109.27 54.62,108.03 55.52,107.13 55.52,106.32 55.52,98.38 58.32,95.59 58.32,94.78 63.49,89.61 63.49,87.87 61.13,85.5 61.13,78.88 58.94,76.69 58.94,72.78 58.03,71.88 58.03,47.79 36.99,26.74 29.19,26.74 28.91,26.46 28.91,25.98 28.65,25.73 27.17,25.73 27.06,25.84 v4(27.06,25.93)
  IN3 w0.081: v4(27.06,25.93) 27.06,25.85 26.96,25.75 26.8,25.75 v5(26.58,25.97)
DDI1_P2_TXP2_C: length 1.9
  BOTTOM w0.112: UV2.15 25.44,25.65 25.77,25.97 CV51.2
DDI1_P2_TXP3: length 158.9
  IN2 w0.081: v3(85.9,130.8) 85.88,130.82 85.88,131 85.98,131.11 86.17,131.11 86.36,130.92 86.36,130.75 85.85,130.24 85.85,129.3 86.36,128.79 86.49,128.67 86.49,120.93 86.22,120.66 86,120.66 85.72,120.39 85.72,119.95 85.23,119.46 73.17,119.46 72.55,120.08 71.63,120.08 70.99,119.45 66.52,119.45 65.46,118.38 64.42,118.38 64.25,118.38 63.78,117.9 63.78,117.03 63.88,116.93 63.88,116.67 63.88,116.67 63.88,116.62 63.78,116.52 63.78,115.19 63.64,115.05 63.64,115.05 63.48,115.05 63.48,115.05 63.12,115.05 62.74,114.67 61.64,114.67 60.5,113.53 60.5,111.9 58.91,110.31 58.91,108.84 57.65,107.58 57.65,106.51 56.85,105.71 56.85,98.72 59.5,96.07 59.5,95.27 64.67,90.1 64.67,87.38 62.3,85.01 62.3,78.39 60.12,76.21 60.12,72.29 59.21,71.39 59.21,47.3 37.14,25.22 30.72,25.22 29.35,23.85 27.16,23.85 27.08,23.94 v4(27.08,24)
  IN3 w0.081: v5(26.58,24.07) 26.58,23.83 26.66,23.75 26.87,23.75 27.08,23.95 v4(27.08,24)
DDI1_P2_TXP3_C: length 2.1
  BOTTOM w0.112: CV53.2 25.79,23.86 25.61,23.86 25.11,24.35 24.73,24.35 24.64,24.45 UV2.18
DDI2_P1_AUXN_C: length 2.5
  BOTTOM w0.112: UV1.25 21.9,36.55 22,36.45 22,35.52 CV64.2 21.25,35.37 RV16.2
DDI2_P1_AUXP_C: length 2.6
  BOTTOM w0.112: RV15.2 23.08,35.37 CV63.2 22.21,35.64 22.21,36.46 22.3,36.55 UV1.24
DDI2_P1_TXN0_C: length 2
  BOTTOM w0.112: CV25.2 25.69,42.41 25.2,42.41 24.88,42.09 24.6,42.09 24.51,42 UV1.10
DDI2_P1_TXN1_C: length 2
  BOTTOM w0.112: UV1.13 24.56,40.8 24.66,40.89 24.85,40.89 25.12,41.16 25.67,41.16 CV28.2
DDI2_P1_TXN2_C: length 1.9
  BOTTOM w0.112: UV1.16 24.55,39.6 24.64,39.69 25.02,39.69 25.2,39.87 25.69,39.87 CV32.2
DDI2_P1_TXN3_C: length 2.1
  BOTTOM w0.112: UV1.19 24.53,38.4 24.62,38.49 25.01,38.49 25.45,38.05 25.61,38.05 CV35.2
DDI2_P1_TXP0_C: length 2
  BOTTOM w0.112: CV24.2 25.63,42.62 25.11,42.62 24.79,42.3 24.65,42.3 24.56,42.4 UV1.9
DDI2_P1_TXP1_C: length 2
  BOTTOM w0.112: UV1.12 24.55,41.2 24.64,41.1 24.76,41.1 25.03,41.38 25.65,41.38 CV26.2
DDI2_P1_TXP2_C: length 1.9
  BOTTOM w0.112: UV1.15 24.56,40 24.65,39.9 24.93,39.9 25.11,40.08 25.63,40.08 CV30.2
DDI2_P1_TXP3_C: length 2
  BOTTOM w0.112: CV34.2 25.71,38.26 25.54,38.26 25.1,38.71 24.63,38.71 24.54,38.8 UV1.18
DDR_A0_ZQ0: length 3.6
  BOTTOM w0.076: 91.26,92.01 91.26,92.36 91.56,92.66 91.91,92.66 92.15,92.9 92.39,92.9 UD4.B3
  BOTTOM w0.112: 91.26,92.01 RD20.1
DDR_A0_ZQ1: length 3.7
  BOTTOM w0.076: 92.08,92 92.08,92.42 92.3,92.64 92.93,92.64 UD4.B4
  BOTTOM w0.112: 92.08,92 92.08,90.61 RD19.1
DDR_A1_ZQ0: length 5.1
  TOP w0.076: UD2.B3 92.15,102.07 91.82,102.4 91.44,102.4 91.17,102.67 v2(91.17,104.58) 91.17,104.95 91.44,105.22 RD1.1
DDR_A1_ZQ1: length 5.1
  TOP w0.076: RD2.1 92.33,105.28 v2(92.28,105.23) 92.08,105.03 92.08,102.55 92.25,102.38 92.63,102.38 92.94,102.07 UD2.B4
DDR_A_CA1_0: length 27.8
  TOP w0.076: UCPU1.BA51 83.19,112.86 83.19,111.73 83.11,111.65 83.11,111.25 v7(83.52,110.84)
  IN3 w0.094: v7(83.52,110.84) 83.75,110.84 83.85,110.93 83.85,111.51 83.94,111.6 84.19,111.6 84.28,111.69 84.28,112.9 84.38,112.99 84.56,112.99 84.66,112.9 84.66,112.75 84.75,112.66 85.18,112.66 85.28,112.57 85.28,112.38 85.18,112.28 84.75,112.28 84.66,112.19 84.66,111.69 84.75,111.6 84.94,111.6 85.03,111.51 85.03,111.32 84.94,111.22 84.32,111.22 84.22,111.13 84.22,110.24 88.85,105.61 88.85,105.48 88.56,105.19 88.56,105.05 88.69,104.92 88.82,104.92 89.12,105.22 89.25,105.22 89.46,105 89.46,104.87 89.09,104.49 89.09,104.13 89.32,103.89 89.32,103.2 89.43,103.09 89.43,102.16 90.17,101.42 v5(90.55,101.42)
  BOTTOM w0.076: UD4.R2 v5(90.55,101.42) 89.77,102.2 89.77,102.78 RD21.1
DDR_A_CA1_1: length 26.8
  TOP w0.076: v7(85.4,110.64) 84.57,111.47 UCPU1.BB54
  IN3 w0.094: v7(85.4,110.64) 85.1,110.94 84.6,110.94 84.51,110.85 84.51,110.36 89.87,105 89.87,104.87 89.37,104.38 89.37,104.24 89.5,104.11 89.64,104.11 90.13,104.6 90.26,104.6 90.4,104.47 90.4,104.34 89.95,103.89 89.95,103.76 90.08,103.62 90.21,103.62 90.66,104.07 90.8,104.07 90.93,103.93 90.93,103.15 90.84,103.06 89.81,103.06 89.71,102.96 89.71,102.77 89.81,102.68 90.84,102.68 90.93,102.59 90.93,102.4 90.84,102.3 90.07,102.3 89.97,102.21 89.97,102.02 90.07,101.93 90.84,101.93 90.93,101.83 90.93,101.02 v5(90.94,101.01)
  BOTTOM w0.076: RD23.1 88.85,103.33 89.54,102.64 89.54,102.02 90.55,101.01 v5(90.94,101.01) 91.06,101.01 91.31,100.77 UD4.P2
DDR_A_CA1_2: length 25.9
  TOP w0.076: v7(83.47,111.51) 83.8,111.83 83.8,112.7 83.65,112.85 UCPU1.BA52
  IN3 w0.094: v7(83.47,111.51) 83.47,111.38 82.92,110.84 82.92,109.55 83.47,109 83.61,109 83.87,109.26 84,109.26 84.13,109.13 84.13,108.99 83.87,108.73 83.87,108.6 84,108.47 84.17,108.47 84.42,108.71 84.55,108.71 84.67,108.59 84.67,108.46 84.4,108.2 84.4,108.07 84.54,107.93 84.67,107.93 84.93,108.19 85.06,108.19 85.2,108.06 85.2,107.93 84.94,107.67 84.94,107.53 85.07,107.4 85.21,107.4 85.47,107.66 85.6,107.66 85.73,107.52 85.73,107.39 85.47,107.13 85.47,107 85.82,106.65 85.82,105.6 87.27,104.15 87.27,103.11 87.57,102.81 87.57,102.67 87.36,102.47 87.36,102.34 87.5,102.2 87.63,102.2 87.84,102.41 87.97,102.41 89.54,100.83 89.54,100.7 89.19,100.34 89.19,100.15 89.52,99.82 89.96,99.82 v5(90.26,100.12)
  BOTTOM w0.076: RD25.1 90.26,100.58 v5(90.26,100.12) UD4.N2
DDR_A_CA1_3: length 28.9
  TOP w0.076: v7(83.55,110.2) 83.96,110.62 83.96,112.91 83.44,113.43 UCPU1.AY52
  IN3 w0.094: v7(83.55,110.2) 83.86,110.2 87.1,106.96 87.1,106.78 86.7,106.38 86.7,106.25 86.83,106.11 86.96,106.11 87.37,106.52 87.5,106.52 87.63,106.38 87.63,106.25 87.49,106.1 87.49,105.97 87.62,105.84 87.75,105.84 87.91,106 88.05,106 88.18,105.87 88.18,105.73 87.9,105.45 87.77,105.45 87.36,105.05 87.36,104.87 87.59,104.64 88.7,104.64 88.8,104.54 88.8,104.34 88.71,104.25 87.93,104.25 87.84,104.15 87.84,103.96 87.93,103.87 88.92,103.87 89.03,103.76 89.03,103.59 88.93,103.49 88.06,103.49 87.97,103.4 87.97,103.21 88.06,103.12 88.99,103.12 89.13,102.97 89.13,102.05 90.66,100.52 v5(90.93,100.52)
  BOTTOM w0.076: UD4.N3 92.13,100.45 91,100.45 v5(90.93,100.52) 90.73,100.52 89.22,102.04 89.22,102.42 88.88,102.76 RD27.1
DDR_A_CA1_4: length 29.5
  TOP w0.076: v7(83.44,114.65) UCPU1.AW52
  IN3 w0.094: v5(90.17,99.54) 89.4,99.54 88.73,100.21 88.73,100.34 88.97,100.58 88.97,100.72 88.84,100.85 88.71,100.85 88.46,100.61 88.33,100.61 88.2,100.74 88.2,100.87 88.44,101.12 88.44,101.25 88.31,101.38 88.17,101.38 87.93,101.14 87.8,101.14 87.66,101.27 87.66,101.4 87.91,101.65 87.91,101.78 87.77,101.91 87.64,101.91 87.4,101.67 87.27,101.67 86.98,101.95 86.98,104.04 85.53,105.49 85.53,106.53 82.58,109.48 82.58,110.9 83.05,111.37 83.05,112.21 82.92,112.34 82.92,112.48 83.05,112.61 83.18,112.61 83.64,112.16 83.77,112.16 83.9,112.29 83.9,112.42 83.59,112.73 83.59,112.94 84.23,113.58 84.23,113.94 83.83,114.35 83.75,114.35 v7(83.44,114.65)
  BOTTOM w0.076: RD29.1 89.94,100.33 89.94,99.77 v5(90.17,99.54) 90.41,99.78 92.15,99.78 UD4.M3
DDR_A_CA1_5: length 28.3
  TOP w0.076: UCPU1.AY55 85.61,114.1 85.61,114.86 v7(85.5,114.97)
  IN3 w0.094: v7(85.5,114.97) 85.73,114.74 85.73,113.47 87.35,111.85 87.35,110.82 91.65,106.52 91.65,106.15 92.49,105.32 92.49,98.88 92.74,98.63 92.74,98.62 93.06,98.3 93.06,96.17 v5(92.46,95.57)
  BOTTOM w0.076: RD31.1 90.03,94.92 90.37,95.26 92.15,95.26 92.45,95.57 v5(92.46,95.57)
DDR_A_CA1_6: length 30.8
  TOP w0.076: v7(83.52,109.57) 84.14,110.19 84.14,112.82 84.47,113.15 84.72,113.15 84.95,113.38 84.95,113.87 UCPU1.AW54
  IN3 w0.094: v7(83.52,109.57) 84.09,109.57 86.1,107.56 86.1,105.72 87.55,104.27 87.55,103.23 90.6,100.18 90.6,99.67 90.54,99.6 90.54,94.94 91.52,93.96 91.98,93.96 92.46,94.44 92.46,94.92 v5(92.46,94.92)
  BOTTOM w0.076: v5(92.46,94.92) 92.31,94.92 92.08,94.68 91.82,94.68 91.69,94.55 90.78,94.55 90.01,93.78 RD33.1
DDR_A_CA1_7: length 28.6
  TOP w0.076: UCPU1.BA54 84.31,112.58 84.31,111.09 v7(85.4,110)
  IN3 w0.094: v5(91.66,94.92) 91.66,95.3 91.53,95.43 91.35,95.43 91.23,95.3 91.23,95.06 91.1,94.93 90.97,94.93 90.82,95.08 90.82,96.33 90.91,96.42 92.13,96.42 92.23,96.52 92.23,96.7 92.13,96.8 90.91,96.8 90.82,96.89 90.82,99.48 91.23,99.89 91.23,104.17 v7(85.4,110)
  BOTTOM w0.076: v5(91.66,94.92) 90.42,94.92 89.85,94.35 RD35.1
DDR_A_CA1_8: length 27.3
  TOP w0.076: UCPU1.BA55 85.23,113.14 84.98,112.88 84.98,111.67 v7(85.4,111.25)
  IN3 w0.094: v5(91.66,94.27) 92.17,94.77 92.17,95.87 92.74,96.44 92.74,96.89 92.52,97.11 91.25,97.11 91.1,97.25 91.1,99.37 91.51,99.77 91.51,104.29 86.22,109.58 86.22,110.43 v7(85.4,111.25)
  BOTTOM w0.076: RD37.1 89.92,93.21 90.98,94.27 v5(91.66,94.27)
DDR_A_CA1_9: length 29.4
  TOP w0.076: v7(83.85,113.81) 84.16,113.81 84.47,113.5 UCPU1.AY54
  IN3 w0.094: v5(91.66,93.62) 91.33,93.62 90.18,94.76 90.18,96.58 89.25,97.52 89.25,99.29 86.7,101.83 86.7,103.92 85.25,105.37 85.25,106.42 82.3,109.37 82.3,112.26 v7(83.85,113.81)
  BOTTOM w0.076: RD39.1 89.9,92.64 90.88,93.62 v5(91.66,93.62)
DDR_A_CA2_0: length 32.4
  TOP w0.076: v3(91.66,93.62) 90.3,93.62 89.37,92.7 RD41.1
  IN2 w0.094: v3(91.66,93.62) 91.49,93.62 87.98,97.12 87.66,97.12 87.56,97.22 87.56,97.4 87.66,97.5 88.2,97.5 88.29,97.59 88.29,97.78 88.2,97.87 87.64,97.87 87.55,97.97 87.55,98.16 87.64,98.25 88.08,98.25 88.18,98.34 88.18,98.53 88.08,98.63 87.31,98.63 86.52,99.41 86.52,103.28 83.74,106.07 83.74,106.97 82.37,108.33 82.37,110.86 82.13,111.1 82.13,111.86 80.77,113.22 80.77,114.95 v3(80.42,115.31)
DDR_A_CA2_1: length 30.7
  TOP w0.076: v3(91.66,94.27) 90.28,94.27 89.27,93.26 RD43.1
  IN2 w0.094: v3(91.66,94.27) 91.24,94.27 88.62,96.89 88.62,98.58 88.29,98.91 87.43,98.91 87.33,99 87.33,99.19 87.43,99.29 87.85,99.29 87.95,99.38 87.95,99.57 87.85,99.66 87.43,99.66 86.84,100.25 86.84,103.37 84.02,106.19 84.02,107.09 82.66,108.45 82.66,110.95 82.33,111.29 82.33,112.05 81.03,113.35 81.03,115.01 v3(81.33,115.31)
DDR_A_CA2_2: length 30.6
  TOP w0.076: RD45.1 89.32,94.41 89.82,94.92 v3(91.66,94.92)
  IN2 w0.076: 82.72,113.6 82.72,113.94 82.14,114.52 82.14,114.84 81.32,115.67 80.71,115.67 v3(80.42,115.96)
  IN2 w0.094: v3(91.66,94.92) 90.99,94.92 89.65,96.26 89.65,97.16 89.24,97.56 89.24,99.27 90.1,100.13 90.1,101.75 89.7,102.15 89.26,102.15 88.02,103.39 88.02,103.84 85.47,106.38 85.47,108.1 84.98,108.6 84.98,109.4 84.46,109.92 84.46,111.86 82.72,113.6
DDR_A_CA2_3: length 30
  TOP w0.076: RD47.1 89.27,93.83 90.02,94.58 92.07,94.58 92.41,94.92 v3(92.46,94.92)
  IN2 w0.076: 83.81,112.84 83.81,113.19 82.54,114.46 82.54,115.02 v3(82.24,115.31)
  IN2 w0.094: 83.81,112.84 84.75,111.89 84.75,109.91 85.26,109.4 85.26,108.71 85.76,108.22 85.76,107.41 86.89,106.28 86.89,105.39 88.31,103.97 88.31,103.5 89.38,102.44 89.85,102.44 90.39,101.9 90.39,100.01 90.03,99.65 90.03,96.28 90.95,95.36 92.02,95.36 v3(92.46,94.92)
DDR_A_CA2_4: length 29.2
  TOP w0.076: RD49.1 89.27,94.98 89.52,95.24 92.13,95.24 v3(92.46,95.57) ; UCPU1.AU52 83.16,115.28 v3(82.94,115.06)
  IN2 w0.094: v3(82.94,115.06) 82.94,114.66 83.42,114.18 83.98,114.18 84.38,113.78 84.38,112.74 85.04,112.08 85.04,109.87 85.55,109.36 85.55,108.83 86.04,108.34 86.04,107.53 88.42,105.15 88.42,104.26 88.63,104.05 88.63,103.58 89.48,102.73 89.96,102.73 90.67,102.01 90.67,99.89 90.32,99.54 90.32,96.73 90.69,96.36 91.35,96.36 91.83,95.87 92.15,95.87 v3(92.46,95.57)
DDR_A_CA2_5: length 25.5
  TOP w0.076: UCPU1.AY51 82.49,113.82 v3(82.48,113.81) ; RD51.1 89.56,100.36 v3(89.65,100.27) 90.13,99.79 92.14,99.79 UD2.F3
  IN2 w0.094: v3(82.48,113.81) 82.48,113.49 84.18,111.79 84.18,109.95 84.69,109.44 84.69,108.48 85.19,107.98 85.19,107.63 84.88,107.32 84.88,107.16 85.02,107.02 85.02,106.84 84.88,106.69 84.88,106.54 87.72,103.7 87.72,102.94 87.82,102.84 88.14,102.84 88.24,102.75 88.24,102.57 88.14,102.47 87.82,102.47 87.72,102.37 87.72,102.18 87.87,102.04 88.14,102.04 88.23,101.96 88.23,101.74 88.06,101.58 88.06,101.41 88.18,101.29 88.67,101.29 89.25,101.87 89.58,101.87 89.82,101.63 89.82,100.8 89.72,100.7 89.42,100.7 89.23,100.51 89.23,100.03 89.32,99.94 89.5,99.94 89.65,100.09 v3(89.65,100.27)
DDR_A_CA2_6: length 29.2
  TOP w0.076: UD2.E3 92.13,100.45 91.26,100.45 v3(91.25,100.46) 90.89,100.46 90.49,100.87 89.35,100.87 RD53.1
  IN2 w0.076: 84.07,115 83.81,115.26 83.47,115.26 82.84,115.89 81.4,115.89 v3(81.33,115.96)
  IN2 w0.094: v3(91.25,100.46) 91.25,102.24 90.12,103.37 90.12,103.55 90.7,104.13 90.7,104.26 90.56,104.39 90.43,104.39 89.88,103.85 89.75,103.85 89.62,103.98 89.62,104.11 90.16,104.66 90.16,104.79 90.03,104.92 89.9,104.92 89.3,104.32 89.17,104.32 89,104.49 89,104.79 89.5,105.3 89.5,105.68 86,109.18 86,112.12 85.74,112.38 85.22,112.38 84.75,112.85 84.75,114.32 84.07,115
DDR_A_CA2_7: length 28.2
  TOP w0.076: UD2.E2 v3(91.08,100.12) 90.65,100.12 90.12,100.64 89,100.64 RD55.1 ; v3(82.61,115.62) UCPU1.AT50
  IN2 w0.094: v3(91.08,100.12) 90.96,100.24 90.96,102.12 90.04,103.05 89.57,103.05 88.98,103.64 88.98,104.11 88.72,104.37 88.72,104.91 89.22,105.41 89.22,105.55 89.08,105.68 88.95,105.68 88.69,105.42 88.56,105.42 88.42,105.55 88.42,105.68 88.69,105.95 88.69,106.08 88.55,106.21 88.42,106.21 88.16,105.95 88.02,105.95 87.89,106.08 87.89,106.22 88.15,106.48 88.15,106.61 88.02,106.74 87.89,106.74 87.63,106.48 87.49,106.48 87.36,106.61 87.36,106.75 87.62,107.01 87.62,107.14 87.49,107.28 87.36,107.28 87.09,107.01 86.96,107.01 86.83,107.15 86.83,107.28 87.09,107.54 87.09,107.67 86.96,107.81 86.82,107.81 86.56,107.55 86.43,107.55 86.33,107.65 86.33,108.45 85.83,108.95 85.83,111.97 85.63,112.17 85.19,112.17 84.58,112.78 84.58,114.01 83.56,115.03 83.42,115.03 82.83,115.62 v3(82.61,115.62)
DDR_A_CA2_8: length 24.8
  TOP w0.076: v3(82.53,112.19) UCPU1.BB50 ; UD2.D2 91.24,101.19 v3(89.51,101.19) 89.14,101.56 89.14,101.65 RD57.1
  IN2 w0.094: v3(82.53,112.19) 82.93,112.19 83.03,112.09 83.03,109.25 83.12,109.16 83.52,109.16 83.62,109.06 83.62,108.87 83.52,108.77 83.11,108.77 83.02,108.68 83.02,108.49 83.11,108.4 83.52,108.4 83.62,108.3 83.62,107.89 84.31,107.2 84.31,106.31 87.15,103.46 87.15,100.59 87.78,99.96 88.14,99.96 88.24,99.86 88.24,99.46 88.33,99.36 88.52,99.36 88.61,99.46 88.61,99.86 88.71,99.96 88.83,99.96 88.93,100.05 88.93,100.22 88.81,100.33 88.17,100.33 88.08,100.43 88.08,100.61 88.17,100.71 89.03,100.71 v3(89.51,101.19)
DDR_A_CA2_9: length 23.9
  TOP w0.076: UD2.C2 91.49,101.58 90.63,101.58 90.63,101.58 89.5,101.58 v3(89.49,101.56) 89.49,101.58 89.38,101.68 89.38,101.98 RD59.1
  IN2 w0.094: v3(82.22,113.5) 82.22,113.23 82.34,113.11 82.34,112.8 82.52,112.62 83.11,112.62 83.9,111.83 83.9,109.51 83.99,109.42 84.36,109.42 84.45,109.32 84.45,109.14 84.36,109.04 83.99,109.04 83.9,108.95 83.9,108.76 83.99,108.67 84.32,108.67 84.41,108.57 84.41,108.38 84.32,108.29 83.99,108.29 83.9,108.2 83.9,108.06 84.23,107.74 84.36,107.74 84.63,108.01 84.76,108.01 84.9,107.87 84.9,107.74 84.59,107.44 84.59,106.42 87.44,103.58 87.44,101.92 87.53,101.83 87.66,101.83 87.75,101.74 87.75,101.55 87.66,101.45 87.53,101.45 87.44,101.36 87.44,101.12 87.56,100.99 88.79,100.99 89.35,101.56 v3(89.49,101.56)
DDR_A_CKE0: length 39.3
  TOP w0.076: v7(86.42,110.84) 85.79,111.46 85.79,111.91 85.63,112.08 85.63,112.62 85.86,112.85 UCPU1.BA56
  IN4 w0.069: v1(92.46,98.17) 92.82,98.17 93.15,98.5 93.22,98.5 93.84,99.11 94.16,99.11 94.33,99.28 94.33,100.38 93.67,101.04 93.67,101.54 93.47,101.74 92.34,101.74 92.05,102.04 92.05,102.2 91.91,102.34 91.55,102.34 91.32,102.57 91.32,103.06 92.09,103.83 92.09,106.95 89.56,109.47 87.26,109.47 86.86,109.07 84.34,109.07 84.19,109.22 84.19,110.61 84.25,110.68 84.39,110.68 84.46,110.61 84.46,109.42 84.53,109.35 84.67,109.35 84.73,109.42 84.73,110.61 84.8,110.68 84.94,110.68 85.01,110.61 85.01,109.42 85.08,109.35 85.9,109.35 86.04,109.49 86.04,110.46 v7(86.42,110.84)
  BOTTOM w0.076: RD65.1 89.16,99.84 89.16,97.77 89.34,97.6 90.53,97.6 91.4,98.46 91.8,98.46 92.1,98.17 v1(92.46,98.17)
DDR_A_CKE1: length 38.7
  TOP w0.076: v7(86.42,111.45) 86.42,111.68 UCPU1.BB56
  IN4 w0.069: v1(93.26,98.17) 93.94,98.85 94.27,98.85 94.59,99.17 94.59,102.09 94.32,102.36 92.26,102.36 92.12,102.5 92.12,103.01 92.44,103.33 92.44,105.41 92.51,105.48 93.06,105.48 93.13,105.55 93.13,105.69 93.06,105.75 92.5,105.75 92.43,105.82 92.43,105.96 92.5,106.03 93.06,106.03 93.13,106.1 93.13,106.23 93.06,106.3 92.51,106.3 92.44,106.37 92.44,106.96 87.84,111.56 87.74,111.56 87.64,111.47 87.64,111.37 89.04,109.97 89.04,109.88 88.94,109.78 88.84,109.78 87.58,111.04 87.49,111.04 87.39,110.94 87.39,110.85 88.28,109.95 88.28,109.86 88.19,109.76 88.09,109.76 87.38,110.47 87.28,110.47 87.19,110.37 87.19,110.28 87.52,109.94 87.52,109.84 87.43,109.74 87.33,109.74 86.87,110.2 86.87,111.32 86.75,111.45 v7(86.42,111.45)
  BOTTOM w0.076: RD67.1 89.97,95.49 91.06,96.59 91.54,96.59 91.54,96.58 91.78,96.58 91.78,96.59 91.82,96.59 92.08,96.84 92.08,96.97 92.34,97.23 92.62,97.23 92.98,97.59 92.98,97.82 93.26,98.1 v1(93.26,98.17)
DDR_A_CKE2: length 37.9
  TOP w0.076: UCPU1.AW56 86.19,114.15 v3(86.24,114.19) ; v3(92.46,96.87) 92.4,96.87 91.95,97.32 91.95,97.67 91.76,97.86 91.36,97.86 90.83,98.39 89.81,98.39 89.8,98.4 89.48,98.4 89.47,98.39 89.06,98.39 RD69.1
  IN2 w0.076: 87.36,109.01 87.36,109.21 87.28,109.29 86.94,109.29 86.87,109.36 86.87,109.6 86.94,109.67 87.43,109.67 87.5,109.75 87.5,109.9 87.43,109.98 87.07,109.98 87,110.05 87,110.22 86.76,110.46 86.76,111.64 86.24,112.16 86.24,112.6 86.16,112.67 85.17,112.67 85.09,112.75 85.09,112.9 85.17,112.98 86.16,112.98 86.24,113.05 86.24,113.21 86.16,113.28 85.17,113.28 85.09,113.36 85.09,113.51 85.17,113.59 86.16,113.59 86.26,113.68 86.26,113.82 86.18,113.89 85.22,113.89 85.1,114.01 85.1,114.38 85.34,114.62 85.47,114.62 85.78,114.31 86.12,114.31 v3(86.24,114.19)
  IN2 w0.094: 87.36,109.01 87.36,108.79 91.04,105.11 91.35,105.11 91.55,105.31 91.68,105.31 91.93,105.06 91.93,104.85 91.84,104.76 91.48,104.76 91.39,104.66 91.39,104.47 91.48,104.38 91.84,104.38 91.93,104.29 91.93,104.1 91.84,104 91.48,104 91.39,103.91 91.39,103.72 91.48,103.63 91.84,103.63 91.93,103.53 91.93,103.35 91.84,103.25 91.58,103.25 91.48,103.16 91.48,102.97 91.58,102.88 91.84,102.88 91.93,102.78 91.93,99.79 91.04,98.89 91.04,97.2 91.2,97.04 91.63,97.04 92.09,96.59 92.33,96.59 92.46,96.71 v3(92.46,96.87)
DDR_A_CKE3: length 38.9
  TOP w0.066: 92.16,97.8 92.07,97.89
  TOP w0.076: 92.16,97.8 92.16,97.39 92.34,97.2 92.56,97.2 92.75,97.02 92.75,96.56 v3(92.76,96.56) 92.95,96.56 UD2.K4 ; 92.07,97.89 92.06,97.9 92.06,98.25 91.83,98.48 91.39,98.48 91.15,98.72 88.82,98.72 RD71.1 ; UCPU1.AY56 86.14,113.25 86.14,112.46 87.41,111.19 87.41,110.89 87.49,110.81 87.64,110.81 87.72,110.89 87.72,111.24 87.79,111.32 87.94,111.32 88.02,111.24 88.02,110.89 88.1,110.81 88.25,110.81 88.33,110.89 88.33,111.49 88.4,111.57 88.55,111.57 88.63,111.49 88.63,110.89 88.71,110.81 88.86,110.81 88.94,110.89 88.94,111.52 89.01,111.59 89.16,111.59 89.24,111.52 89.24,110.89 89.32,110.81 89.47,110.81 89.54,110.89 89.54,111.21 89.62,111.28 89.79,111.28 89.87,111.21 89.87,110.43 89.86,110.43
  TOP w0.173: 89.86,110.43 89.74,110.31 v2(87.4,110.31) v3(86.44,110.31)
  IN2 w0.076: v3(86.44,110.31) 86.27,110.14 86.27,109.48 86.74,109.01
  IN2 w0.094: 86.74,109.01 86.74,109.01 89.95,105.8 89.95,105.57 91.09,104.42 91.09,103.96 90.75,103.61 90.75,103.31 91.65,102.41 91.65,99.91 90.75,99.01 90.75,97.03 91.02,96.76 91.51,96.76 91.97,96.3 92.45,96.3 92.71,96.56 v3(92.76,96.56)
DDR_A_CLK0: length 33.7
  TOP w0.076: UCPU1.AT53 84.24,115.96 v7(84.51,115.69)
  IN3 w0.094: v5(92.46,97.52) 92.29,97.52 92.14,97.66 92.14,98.06 91.95,98.25 91.75,98.25 91.66,98.34 91.66,98.62 91.75,98.72 91.87,98.72 92.08,98.92 92.08,104.51 91.58,105 91.58,105.14 91.7,105.26 91.7,105.52 91.41,105.81 91.15,105.81 91.03,105.69 90.9,105.69 90.7,105.89 90.7,106.02 91.01,106.33 91.01,106.59 90.72,106.88 90.46,106.88 90.15,106.57 90.01,106.57 89.81,106.77 89.81,106.91 90.12,107.22 90.12,107.48 89.83,107.77 89.57,107.77 89.26,107.46 89.13,107.46 88.93,107.66 88.93,107.79 89.24,108.1 89.24,108.36 88.95,108.65 88.69,108.65 88.38,108.34 88.24,108.34 88.04,108.54 88.04,108.68 88.35,108.99 88.35,109.25 88.06,109.54 87.8,109.54 87.49,109.23 87.36,109.23 87.15,109.44 87.15,110.1 86.95,110.3 86.95,111.68 85.03,113.6 85.03,113.94 85.4,114.31 85.4,114.57 85.11,114.86 84.85,114.86 84.47,114.49 84.34,114.49 84.2,114.63 84.2,115.38 v7(84.51,115.69)
  BOTTOM w0.076: v5(92.46,97.52) 92.25,97.52 91.96,97.23 91.2,97.23 90.23,96.26 88.72,96.26 RD75.1
DDR_A_CLK1: length 32.3
  TOP w0.076: v8(89.57,99.7) 89.43,99.57 88.91,99.57 RD79.1
  IN1 w0.107: v8(89.57,99.7) 89.71,99.56 90.98,99.56 92.16,98.38 92.16,97.62 92.27,97.52 v3(92.46,97.52)
  IN2 w0.094: v3(92.46,97.52) 92.22,97.52 92.14,97.6 92.14,97.99 91.92,98.21 91.73,98.21 91.61,98.33 91.61,98.68 91.77,98.84 92.27,98.84 92.49,99.06 92.49,105.29 91.75,106.03 91.49,106.03 91.26,105.8 91.13,105.8 90.9,106.04 90.9,106.17 91.12,106.4 91.12,106.66 90.83,106.95 90.57,106.95 90.34,106.72 90.21,106.72 90.01,106.92 90.01,107.06 90.24,107.28 90.24,107.54 89.95,107.83 89.69,107.83 89.46,107.61 89.33,107.61 89.13,107.81 89.13,107.94 89.35,108.17 89.35,108.43 89.06,108.72 88.8,108.72 88.57,108.49 88.44,108.49 88.22,108.71 88.22,108.89 88.6,109.27 88.6,109.58 87.12,111.06 87.12,111.83 86.57,112.38 86.57,113.59 86.64,113.66 86.64,114.97 86.23,115.38 86.23,115.73 86.05,115.92 85.03,115.92 v3(84.99,115.96)
DDR_A_CLK#0: length 32.9
  TOP w0.076: UCPU1.AU53 83.98,115.31 v7(83.65,115.64)
  IN3 w0.094: v5(91.66,97.52) 91.86,97.52 91.98,97.64 91.98,98 91.89,98.09 91.69,98.09 91.5,98.28 91.5,98.69 91.69,98.87 91.81,98.87 91.92,98.99 91.92,104.45 91.43,104.94 91.43,105.2 91.55,105.32 91.55,105.45 91.35,105.65 91.22,105.65 91.1,105.53 90.84,105.53 90.54,105.82 90.54,106.09 90.85,106.39 90.85,106.53 90.65,106.73 90.52,106.73 90.21,106.42 89.95,106.42 89.66,106.71 89.66,106.97 89.97,107.28 89.97,107.41 89.77,107.61 89.64,107.61 89.33,107.3 89.07,107.3 88.77,107.59 88.77,107.86 89.08,108.16 89.08,108.3 88.88,108.5 88.75,108.5 88.44,108.19 88.18,108.19 87.89,108.48 87.89,108.74 88.2,109.05 88.2,109.18 88,109.38 87.87,109.38 87.56,109.07 87.3,109.07 87,109.37 87,110.04 86.79,110.24 86.79,111.62 84.87,113.54 84.87,114 85.24,114.37 85.24,114.51 85.04,114.71 84.91,114.71 84.54,114.33 84.28,114.33 84.05,114.56 84.05,115.24 v7(83.65,115.64)
  BOTTOM w0.076: RD77.1 88.72,96.44 90.15,96.44 91.23,97.52 v5(91.66,97.52)
DDR_A_CLK#1: length 32
  TOP w0.076: RD81.1 88.91,99.38 89.42,99.38 v8(89.57,99.24)
  IN1 w0.107: v3(91.66,97.52) 91.85,97.52 91.96,97.62 91.96,98.3 90.9,99.36 89.69,99.36 v8(89.57,99.24)
  IN2 w0.094: v3(91.66,97.52) 91.9,97.52 91.98,97.6 91.98,97.92 91.86,98.05 91.67,98.05 91.45,98.27 91.45,98.74 91.7,98.99 92.2,98.99 92.33,99.12 92.33,105.23 91.68,105.88 91.55,105.88 91.33,105.65 91.06,105.65 90.74,105.97 90.74,106.23 90.97,106.46 90.97,106.59 90.77,106.79 90.63,106.79 90.41,106.57 90.15,106.57 89.86,106.86 89.86,107.12 90.08,107.35 90.08,107.48 89.88,107.68 89.75,107.68 89.52,107.45 89.26,107.45 88.97,107.74 88.97,108 89.2,108.23 89.2,108.36 89,108.56 88.86,108.56 88.64,108.34 88.38,108.34 88.07,108.65 88.07,108.96 88.45,109.34 88.45,109.52 86.97,111 86.97,111.76 86.42,112.32 86.42,113.65 86.49,113.72 86.49,114.91 86.08,115.32 86.08,115.67 85.98,115.76 85.31,115.76 85.18,115.64 85.18,115.51 v3(84.99,115.31)
DDR_A_CS#0: length 45.1
  TOP w0.076: UD2.L3 92.46,96.28 92.06,96.68 92.06,96.92 91.82,97.16 90.5,97.16 v7(89.64,98.02) ; v7(79.96,115.47) 79.96,115.47 79.8,115.31 UCPU1.AU45
  IN4 w0.069: v7(79.96,115.47) 79.96,115.1 80.03,115.04 81.04,115.04 81.11,114.96 81.11,114.83 81.04,114.76 80.03,114.76 79.96,114.69 79.96,113.93 81.94,111.95 81.94,110.64 83.88,108.7 89.81,108.7 91.71,106.79 91.71,104.17 90.42,102.87 90.42,101.98 90.64,101.75 91.76,101.75 91.96,101.56 91.96,101.4 92.27,101.09 92.92,101.09 93.64,100.36 93.64,99.45 93.33,99.14 93.15,99.14 92.56,98.55 91.14,98.55 90.83,98.24 89.87,98.24 v7(89.64,98.02)
  BOTTOM w0.076: UD4.L3 92.24,98.82 91.9,99.17 90.79,99.17 v7(89.64,98.02) 89.64,100 RD61.1
DDR_A_CS#1: length 45.1
  TOP w0.076: UD2.L4 92.95,95.9 92.26,95.9 92,96.16 92,96.36 91.83,96.53 91.58,96.53 91.33,96.79 89.27,96.79 v7(89.17,96.89) 88.73,97.33 RD63.1 ; UCPU1.AU43 78.75,115.47 v7(79.04,115.47)
  IN4 w0.069: v7(89.17,96.89) 89.42,97.13 93.39,97.13 93.66,97.4 93.66,98.04 94.1,98.48 94.93,98.48 95.15,98.69 95.15,102.52 95.22,102.6 95.22,103.09 93.52,104.79 93.52,106.41 87.98,111.95 86.17,111.95 85.67,112.45 84.23,112.45 80.84,115.83 79.4,115.83 v7(79.04,115.47)
  BOTTOM w0.076: v7(89.17,96.89) 89.54,97.25 90.61,97.25 91.19,97.84 92.54,97.84 92.79,98.08 92.79,98.34 UD4.L4
DDR_A_D0: length 35.9
  IN2 w0.094: v3(94.61,119.02) 94.62,119.03 99.69,119.03 106.48,112.24 106.48,108.93 103.05,105.5 103.05,100.92 99.89,97.76 97.89,97.76 97.26,98.38 v3(97.26,99.47)
DDR_A_D1: length 35.5
  IN2 w0.076: 95.41,118.54 93.14,118.54 v3(92.66,119.02)
  IN2 w0.094: v3(98.06,99.47) 97.81,99.22 97.81,98.53 98.15,98.19 99.52,98.19 102.49,101.16 102.49,105.73 105.85,109.1 105.85,112.06 99.45,118.46 95.49,118.46 95.41,118.54
DDR_A_D2: length 32.7
  IN2 w0.094: v3(92.66,117.79) 92.66,114.83 95.83,111.65 95.97,111.65 97.6,113.28 97.73,113.28 97.96,113.05 97.96,112.92 96.33,111.29 96.33,111.15 96.55,110.93 96.69,110.93 97.97,112.22 98.11,112.22 98.33,111.99 98.33,111.86 97.12,110.64 97.12,110.37 99.36,108.13 99.36,107.25 99.45,107.15 100.14,107.15 100.23,107.06 100.23,106.87 100.14,106.78 99.45,106.78 99.36,106.68 99.36,104.35 99.79,103.91 99.79,101.35 98.82,100.37 97.35,100.37 97.26,100.46 v3(97.26,100.77)
DDR_A_D3: length 33.6
  IN2 w0.094: v3(93.31,117.79) 93.31,115.04 94.76,113.58 96.23,113.58 96.32,113.67 96.32,114.58 96.42,114.68 96.61,114.68 96.7,114.58 96.7,113.67 96.79,113.58 96.98,113.58 97.08,113.67 97.08,114.3 97.17,114.39 97.36,114.39 97.45,114.3 97.45,113.67 97.55,113.58 97.73,113.58 97.83,113.67 97.83,114.26 97.92,114.35 98.11,114.35 98.2,114.26 98.2,113.67 98.62,113.26 98.62,109.27 100.52,107.37 100.52,106.49 100.42,106.4 99.73,106.4 99.64,106.3 99.64,106.12 99.73,106.02 100.42,106.02 100.52,105.93 100.52,105.74 100.42,105.65 99.73,105.65 99.64,105.55 99.64,105.36 99.73,105.27 100.42,105.27 100.52,105.18 100.52,104.99 100.42,104.89 99.73,104.89 99.64,104.8 99.64,104.61 99.73,104.52 100.42,104.52 100.52,104.42 100.52,103.77 100.42,103.68 100.17,103.68 100.08,103.58 100.08,103.39 100.17,103.3 100.42,103.3 100.52,103.21 100.52,101.34 99.39,100.21 98.96,100.21 v3(98.86,100.12)
DDR_A_D4: length 36
  IN2 w0.094: v3(93.96,119.02) 94.23,118.74 99.57,118.74 106.14,112.18 106.14,108.98 102.77,105.62 102.77,101.04 99.71,97.98 97.98,97.98 97.54,98.43 97.54,99.84 v3(97.26,100.12)
DDR_A_D5: length 38.7
  IN2 w0.094: v3(96.46,99.47) 97.09,98.84 97.09,98.31 97.82,97.59 100.12,97.59 103.34,100.81 103.34,105.38 106.77,108.81 106.77,112.35 99.81,119.31 96.66,119.31 96.64,119.3 93.59,119.3 v3(93.31,119.02)
DDR_A_D6: length 33.5
  TOP w0.076: UCPU1.AN70 93.96,117.6 v3(94.16,117.39)
  IN2 w0.094: v3(98.06,100.12) 98.31,99.87 99.04,99.87 99.19,100.01 99.59,100.01 100.8,101.23 100.8,107.49 98.9,109.39 98.9,114.55 98.81,114.64 97.5,114.64 97.41,114.73 97.41,114.92 97.5,115.02 98.81,115.02 98.9,115.11 98.9,115.3 98.81,115.39 97.5,115.39 97.41,115.49 97.41,115.67 97.5,115.77 98.81,115.77 98.9,115.86 98.9,116.05 98.81,116.14 97.49,116.14 97.4,116.24 97.4,116.42 97.49,116.52 98.81,116.52 98.9,116.61 98.9,116.91 98.6,117.22 94.34,117.22 v3(94.16,117.39)
DDR_A_D7: length 33.7
  TOP w0.076: UD2.F11 v3(99.28,99.69)
  IN2 w0.094: v3(94.61,117.69) 94.8,117.5 98.72,117.5 99.19,117.03 99.19,115.29 99.28,115.19 100.11,115.19 100.2,115.1 100.2,114.91 100.11,114.82 99.28,114.82 99.19,114.72 99.19,114.53 99.28,114.44 100.11,114.44 100.2,114.35 100.2,114.16 100.11,114.06 99.28,114.06 99.19,113.97 99.19,113.78 99.28,113.69 100.11,113.69 100.2,113.59 100.2,113.41 100.11,113.31 99.28,113.31 99.19,113.22 99.19,109.51 101.09,107.61 101.09,107.51 101.18,107.42 102.45,107.42 102.54,107.32 102.54,107.14 102.45,107.04 101.18,107.04 101.09,106.95 101.09,106.76 101.18,106.67 101.69,106.67 101.79,106.57 101.79,106.38 101.69,106.29 101.18,106.29 101.09,106.2 101.09,101.11 99.67,99.69 v3(99.28,99.69)
DDR_A_D8: length 43.1
  TOP w0.076: UD2.N9 96.91,94.56 96.91,94.31 96.55,93.95 96.34,93.95 v7(95.39,93) ; v7(96.42,116.42) 95.83,117.01 94.47,117.01 94.12,116.66 UCPU1.AR70
  IN4 w0.069: v7(95.39,93) 95.61,93 96.6,92.01 99.11,92.01 99.3,91.83 101.65,91.83 104.53,94.71 104.53,104.76 101.94,107.35 101,107.35 98.47,109.87 98.47,115.61 97.28,116.8 96.8,116.8 v7(96.42,116.42)
DDR_A_D9: length 42.4
  TOP w0.076: UD2.M9 96.95,95.88 96.19,95.88 95.87,95.56 95.87,95.27 v7(95.4,94.8) ; UCPU1.AR68 92.76,116.56 93.05,116.28 93.67,116.28 93.7,116.31 95.05,116.31 v7(95.16,116.41)
  IN4 w0.069: v7(95.16,116.41) 95.53,116.04 97.31,116.04 97.95,115.39 97.95,109.66 100.78,106.83 101.73,106.83 103.33,105.22 103.33,97.98 104.01,97.3 104.01,94.92 101.91,92.82 100.76,92.82 100.64,92.71 97.92,92.71 97.34,93.29 97.19,93.29 96.51,93.97 96.22,93.97 v7(95.4,94.8)
DDR_A_D10: length 37.1
  TOP w0.076: UD2.N10 98.39,94.59 99.01,94.59 99.27,94.33 99.27,94.1 99.45,93.92 100.6,93.92 v7(100.74,94.06) ; UCPU1.AU71 94.91,115.34 95.09,115.16 95.58,115.16 v7(95.99,114.75)
  IN4 w0.069: v7(100.74,94.06) 100.88,94.06 101.19,94.37 101.19,94.47 100.74,94.92 100.64,94.92 100.38,94.65 100.38,94.56 100.5,94.44 100.5,94.34 100.4,94.24 100.3,94.24 100.19,94.36 100.09,94.36 99.97,94.24 99.97,94.05 100.31,93.7 101.55,93.7 103.14,95.29 103.14,96.94 102.36,97.71 102.36,102.8 101.74,103.42 101.74,103.79 101.6,103.93 101.6,104.03 101.74,104.18 101.74,104.27 101.65,104.37 101.55,104.37 101.4,104.22 101.31,104.22 100.39,105.14 100.39,105.45 100.46,105.52 100.78,105.52 100.85,105.59 100.85,105.72 100.78,105.79 100.46,105.79 100.39,105.86 100.39,105.98 97.08,109.29 97.08,111.08 97.01,111.15 96.51,111.15 96.44,111.22 96.44,111.36 96.51,111.42 97.01,111.42 97.08,111.49 97.08,111.65 97,111.72 96.55,111.72 96.43,111.85 96.43,114.49 96.16,114.75 v7(95.99,114.75)
DDR_A_D11: length 39
  TOP w0.076: UD2.M11 99.18,95.88 101.26,95.88 v7(101.37,95.99) ; UCPU1.AU68 92.96,115.06 93.25,115.06 93.61,114.7 93.61,114.56 93.93,114.24 94.88,114.24 v7(95.15,113.98)
  IN4 w0.069: v7(95.15,113.98) 94.72,113.98 94.65,114.04 94.65,117 94.58,117.07 94.45,117.07 94.38,117 94.38,113.68 94.45,113.61 95.01,113.61 95.08,113.54 95.08,113.4 95.01,113.34 94.45,113.34 94.38,113.27 94.38,113.13 94.45,113.06 95.01,113.06 95.08,112.99 95.08,112.86 95.01,112.79 94.45,112.79 94.38,112.72 94.38,112.58 94.45,112.51 95.01,112.51 95.08,112.44 95.08,112.31 95.01,112.24 94.45,112.24 94.38,112.17 94.38,112.03 94.45,111.96 94.9,111.96 94.97,111.9 94.97,111.76 94.9,111.69 94.45,111.69 94.38,111.62 94.38,110.89 95.18,110.09 95.28,110.09 95.43,110.24 95.53,110.24 95.63,110.15 95.63,110.05 95.47,109.89 95.47,109.8 99.52,105.76 99.52,104.21 101.59,102.14 101.59,96.21 v7(101.37,95.99)
DDR_A_D12: length 43.3
  TOP w0.076: v7(95.38,92.41) 96.25,93.28 96.77,93.28 96.88,93.38 96.88,93.88 UD2.P9 ; v7(95.8,116.44) 95.37,116.86 94.81,116.86 UCPU1.AR71
  IN4 w0.069: v7(95.38,92.41) 95.84,92.41 96.5,91.75 98.96,91.75 99.15,91.57 101.76,91.57 104.79,94.6 104.79,104.87 102.05,107.6 101.1,107.61 98.73,109.98 98.73,115.71 97.39,117.06 96.42,117.06 v7(95.8,116.44)
DDR_A_D13: length 42.8
  TOP w0.076: UCPU1.AR69 93.39,116.56 93.86,117.03 94.19,117.03 94.44,117.29 96.19,117.29 v2(96.61,116.87) 97.02,116.46 v7(97.02,116.43) ; 95.44,94.26 96.09,94.91 96.09,95.2 UD2.M8
  TOP w0.173: 95.44,94.26 v7(95.36,94.18)
  IN4 w0.069: v7(97.02,116.43) 97.28,116.43 98.21,115.5 98.21,109.77 100.89,107.09 101.84,107.09 104.27,104.65 104.27,94.82 101.54,92.09 99.4,92.09 99.22,92.27 96.71,92.27 96.03,92.95 96.03,93.5 v7(95.36,94.18)
DDR_A_D14: length 38
  TOP w0.076: v7(95.36,114.75) 95.11,114.99 94.86,114.99 94.82,115.04 94.41,115.04 94.12,115.34 UCPU1.AU70 ; UD2.N11 99.16,94.92 99.47,94.61 100.85,94.61 v7(101.4,94.06)
  IN4 w0.069: v7(101.4,94.06) 101.67,94.34 101.82,94.34 102.88,95.39 102.88,95.48 102.81,95.55 102.34,95.55 102.27,95.62 102.27,95.75 102.34,95.82 102.79,95.82 102.86,95.89 102.86,96.03 102.79,96.1 102.18,96.1 102.11,96.17 102.11,96.3 102.18,96.37 102.81,96.37 102.87,96.44 102.87,96.58 102.81,96.65 102.18,96.65 102.11,96.71 102.11,96.85 102.18,96.92 102.49,96.92 102.56,96.99 102.56,97.13 102.49,97.19 102.17,97.19 102.1,97.26 102.1,102.69 101.48,103.31 101.48,103.68 100.09,105.07 100.09,105.91 96.75,109.26 96.75,109.72 96.68,109.79 96.24,109.79 96.17,109.86 96.17,110 96.24,110.06 96.75,110.06 96.81,110.13 96.81,110.27 96.75,110.34 96.24,110.34 96.17,110.41 96.17,110.54 96.24,110.61 96.75,110.61 96.81,110.68 96.81,110.82 96.75,110.89 96.24,110.89 96.17,110.96 96.17,114.14 95.95,114.36 94.98,114.36 94.91,114.43 94.91,115.59 95.03,115.7 95.24,115.7 95.36,115.59 v7(95.36,114.75)
DDR_A_D15: length 38
  TOP w0.076: v7(95.8,113.96) 95.39,114.38 95.17,114.38 94.95,114.6 94.95,114.67 94.75,114.87 94.32,114.87 94.12,115.07 93.8,115.07 93.53,115.34 UCPU1.AU69 ; v7(101.36,95.41) 101.21,95.26 98.37,95.26 UD2.M10
  IN4 w0.069: v7(101.36,95.41) 101.56,95.41 101.85,95.69 101.85,102.25 101.69,102.41 101.69,102.51 101.75,102.58 101.75,102.67 101.66,102.77 101.56,102.77 101.49,102.7 101.39,102.7 101.3,102.8 101.3,102.9 101.37,102.97 101.37,103.06 101.27,103.16 101.17,103.16 101.1,103.09 101.01,103.09 100.91,103.19 100.91,103.28 101.16,103.53 101.16,103.63 101.06,103.73 100.97,103.73 100.71,103.48 100.62,103.48 100.43,103.67 100.43,103.85 100.6,104.02 100.6,104.2 100.24,104.56 100.06,104.56 99.98,104.49 99.89,104.49 99.79,104.58 99.79,104.68 99.9,104.8 99.9,104.89 99.79,105 99.79,105.84 95.91,109.73 95.91,110.44 95.84,110.51 95.14,110.51 95.07,110.58 95.07,110.71 95.14,110.78 95.84,110.78 95.91,110.85 95.91,110.99 95.84,111.06 94.71,111.06 94.64,111.12 94.64,111.26 94.71,111.33 95.84,111.33 95.91,111.4 95.91,111.54 95.84,111.6 95.31,111.6 95.24,111.67 95.24,111.81 95.31,111.88 95.84,111.88 95.91,111.95 95.91,112.08 95.84,112.15 95.4,112.15 95.34,112.22 95.34,112.36 95.4,112.43 95.84,112.43 95.91,112.5 95.91,112.63 95.84,112.7 95.4,112.7 95.34,112.77 95.34,112.91 95.4,112.98 95.84,112.98 95.91,113.04 95.91,113.18 95.84,113.25 95.4,113.25 95.34,113.32 95.34,113.46 95.4,113.52 95.84,113.52 95.91,113.59 95.91,113.85 v7(95.8,113.96)
DDR_A_D16: length 36.3
  TOP w0.076: UCPU1.AF65 90.71,121.61 v7(90.51,121.81)
  IN4 w0.069: v1(98.06,94.92) 98.32,94.66 99.85,94.66 100.98,95.78 100.98,96.26 101.21,96.49 101.21,101.99 99.14,104.06 99.14,105.6 94,110.74 94,120.67 92.47,122.2 90.9,122.2 v7(90.51,121.81)
DDR_A_D17: length 34.3
  TOP w0.076: UCPU1.AF64 89.88,121.54 v7(89.88,121.83)
  IN4 w0.069: v1(98.51,95.24) 99.34,96.07 99.34,96.67 98.6,97.41 98.6,97.59 99.06,98.05 99.38,98.05 100.44,99.1 100.44,101.67 98.37,103.74 98.37,105.28 93.23,110.42 93.23,119.29 92.65,119.87 92.65,120.16 91.71,121.1 91.5,121.1 91.23,121.37 90.34,121.37 v7(89.88,121.83)
  BOTTOM w0.076: UD4.F10 98.39,95.24 v1(98.51,95.24)
DDR_A_D18: length 33
  TOP w0.076: v7(90.41,119.11) 90.71,119.41 UCPU1.AK65
  IN4 w0.069: 96.11,95.95 96.11,96.28 97.03,97.2 97.03,97.88 96.85,98.06 96.85,98.3 97.04,98.48 97.3,98.48 97.52,98.71 97.52,101.59 97.35,101.76 96.99,101.76 96.87,101.89 96.87,102.22 96.7,102.39 96.7,104.95 96.53,105.12 96.44,105.12 96.18,104.87 96.09,104.87 95.99,104.97 95.99,105.06 96.24,105.32 96.24,105.41 96.15,105.51 96.05,105.51 95.77,105.23 95.67,105.23 95.57,105.33 95.57,105.42 95.86,105.71 95.86,105.8 90,111.66 90,112.12 90.06,112.19 90.56,112.19 90.63,112.26 90.63,112.39 90.56,112.46 90.06,112.46 90,112.53 90,112.67 90.06,112.74 90.78,112.74 90.85,112.8 90.85,112.97 90.78,113.04 90.06,113.04 90,113.11 90,113.3 90.28,113.58 90.28,118.98 v7(90.41,119.11)
  IN4 w0.076: v1(96.11,95.92) 96.11,95.95
  BOTTOM w0.076: UD4.F8 v1(96.11,95.92)
