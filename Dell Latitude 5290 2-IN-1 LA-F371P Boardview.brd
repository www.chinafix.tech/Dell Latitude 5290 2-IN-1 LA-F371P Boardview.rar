# Allegro board Dell Latitude 5290 2-IN-1 LA-F371P Boardview.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3V_5105 on BOTTOM (solid shape): 16.94,119.98 16.94,117.9 17.04,117.79 17.6,117.79 17.68,117.87 17.68,117.95 17.86,118.12 18.22,118.12 18.3,118.05 18.3,117.06 18.21,116.97 18.21,116.17 18.28,116.1 18.28,115.46 18.25,115.43 17.79,115.43 17.63,115.43 17.58,115.49 17.58,116.08 17.21,116.44 17.21,116.73 17.12,116.82 16.1,116.82 16.01,116.91 16.01,119.99 16.1,120.08 16.84,120.08
+3V_5105 on IN3 (solid shape): 15.88,106.84 18.74,106.84 19.14,106.44 22.27,106.44 22.53,106.18 22.53,105.82 22.38,105.68 19.67,105.68 19.32,105.33 18.59,105.33 18.58,105.32 17.6,105.32 16.87,106.06 16.33,106.06 16.18,105.91 14.38,105.91 14.25,106.03 14.25,106.77 14.43,106.95 15.77,106.95
+3V_5105 on IN3 (solid shape): 29.4,102.89 29.5,102.89 29.51,102.88 30.41,102.88 30.56,102.83 30.7,102.88 31.06,102.88 31.1,102.85 32.73,102.85 33.21,103.33 33.73,103.85 33.74,103.85 35.1,103.85 35.43,104.18 35.76,104.18 36.23,103.71 36.23,103.47 36.14,103.39 35.89,103.39 35.49,102.99 34.28,102.99 33.16,101.87 31.24,101.87 31.06,101.95 30.89,101.87 29.3,101.87 27.14,104.02 25.61,104.02 25.4,104.23 25.4,104.94 25.42,104.96 27.33,104.96
+3V_5105 on IN3 (solid shape): 25.6,122.11 25.86,122.11 26.78,121.2 28.45,121.2 28.91,120.74 30.91,120.74 31.14,120.97 31.14,121.2 30.99,121.35 30.99,121.43 31.11,121.55 31.42,121.55 31.85,121.12 31.85,119.67 31.53,119.36 30.51,119.36 29.84,120.03 27.24,120.03 27.23,120.1 27.15,120.25 27,120.31 26.93,120.33 26.9,120.39 26.72,120.58 26.48,120.49 25.76,120.49 24.87,121.38 20.31,121.38 19.4,120.47 18.38,120.47 18.36,120.46 17.5,119.6 17.48,119.6 17.14,119.27 16.23,119.27 16.12,119.38 16.12,119.99 16.41,120.28 16.59,120.28 17.51,121.21 18.2,121.21 19.23,122.24 25.47,122.24
+3V_5105 on IN4 (solid shape): 44.51,104.4 44.51,102.34 44.38,102.21 44.09,102.21 43.99,102.31 43.98,102.36 43.96,102.41 43.96,104.46 44.05,104.55 44.36,104.55
+3V_5105 on IN4 (solid shape): 31.47,119.39 31.47,118.78 32.59,117.67 32.59,117.21 33.38,116.42 33.38,116.09 33.1,115.81 32.46,115.81 30.91,117.36 30.91,118.56 30.78,118.68 30.78,119.55 30.9,119.66 31.08,119.66 31.09,119.67 31.19,119.67
+3V_5105 on IN4 (solid shape): 20.07,124.74 20.07,123.91 19.82,123.66 19.82,123 19.94,122.89 19.94,122.8 19.9,122.79 19.74,122.63 19.79,122.42 19.74,122.2 19.9,122.04 19.94,122.03 19.94,121.38 19.84,121.27 19.27,121.27 19.08,121.46 19.08,124.77 19.18,124.87 19.94,124.87
+3V_5105 on IN4 (solid shape): outline of 283 points within 14.12,105.63 18.57,116.89
+3V_5105 on IN4: 25.02,106.62 25.68,105.96 25.68,104.48 25.6,104.41 25.5,104.41 25.49,104.41 25.2,104.41 25.07,104.54 25.07,104.81 24.83,105.06 24.42,105.06 23.77,105.71 23.74,105.79 23.77,105.86 23.67,106.26 23.41,105.95 23.4,105.85 23.32,105.81 21.31,105.81 21.18,105.93 21.18,106.31 21.26,106.39 21.77,106.39 22.63,107.25 24.38,107.25 24.83,106.8
+3V_LDO on IN2 (solid shape): 22.47,43.29 22.47,42.81 21.72,42.05 21.44,42.05 21.44,42.43 21.89,42.89 21.89,43.37 22.02,43.5 22.26,43.5
+3V_LDOP on TOP (solid shape): 21.42,47.45 21.42,46.63 21.34,46.55 21.06,46.55 20.52,46.01 20.52,44.69 20.33,44.5 19.33,44.5 19.17,44.66 19.18,44.71 19.17,44.75 19.17,45.32 19.66,45.81 19.66,47.44 19.81,47.59 21.28,47.59
+3V_PRIM on TOP (solid shape): 48.82,101.23 48.82,100.86 48.33,100.37 46.92,100.37 46.77,100.51 46.77,101.04 46.81,101.08 47.96,101.08 48.28,101.39 48.66,101.39
+3V_PRIM on TOP (solid shape): 48.95,126.53 48.95,126.13 48.77,125.95 48.56,125.95 48.44,125.82 48.44,125.41 48.55,125.31 48.96,125.31 49.07,125.2 49.07,124.88 49.17,124.78 49.76,124.78 49.91,124.93 49.91,125.69 49.98,125.76 50.67,125.76 50.67,123.43 50.6,123.36 50.16,123.36 49.95,123.15 48.96,123.15 48.85,123.27 48.85,123.66 48.51,123.99 48.51,124.47 48.09,124.89 47.79,124.89 47.65,125.03 47.65,125.06 47.57,125.13 47.37,125.13 47.37,125.72 47.42,125.77 47.93,125.77 48.13,125.97 48.13,126.56 48.29,126.71 48.77,126.71
+3V_PRIM on BOTTOM (solid shape): 49.02,139.92 49.02,139.51 48.9,139.39 47.89,139.39 47.89,139.38 45.36,139.38 45.16,139.59 45.16,139.92 45.29,140.04 48.9,140.04
+3V_PRIM on BOTTOM (solid shape): 31.47,128 31.47,126.68 31.17,126.38 30.76,126.38 30.61,126.53 30.61,127.01 30.84,127.24 30.84,127.8 30.81,127.83 30.81,127.95 30.89,128.03 31.45,128.03
+3V_PRIM on BOTTOM (solid shape): 65.34,125.92 65.34,125.03 64.9,124.59 64.2,124.59 64.14,124.65 64.14,125.03 64.01,125.16 63.75,125.16 63.69,125.22 63.69,125.99 63.75,126.05 65.21,126.05
+3V_PRIM on BOTTOM (solid shape): 47.59,90.19 47.59,88.5 47.48,88.4 45.81,88.4 45.64,88.56 45.64,89.53 45.67,89.65 45.64,89.77 45.64,90.21 45.72,90.29 47.49,90.29
+3V_PRIM on BOTTOM (solid shape): 140.56,148.6 140.56,147.7 140.82,147.45 141.35,147.45 141.48,147.32 141.48,146.37 141.41,146.31 139.95,146.31 139.66,146.6 139.66,147.3 139.06,147.89 139.06,148.46 139.3,148.7 140.47,148.7
+3V_PRIM on IN1 (solid shape): 55.69,108.91 55.69,108.68 55.11,108.1 55.04,108.1 54.67,108.47 54.67,108.65 55.11,109.09 55.51,109.09
+3V_PRIM on IN1 (solid shape): 48.96,101.98 48.96,101.89 48.92,101.85 48.86,101.77 48.86,101.17 48.18,100.5 47.92,100.5 47.75,100.66 47.75,101.13 48.07,101.45 48.07,102.02 48.35,102.3 48.36,102.3 48.64,102.3
+3V_PRIM on IN2 (solid shape): 48.01,89.6 48.01,88.86 47.82,88.67 46.58,88.67 46.45,88.81 46.45,89.53 46.69,89.78 47.83,89.78
+3V_PRIM on IN3 (solid shape): 33.68,131.23 33.68,130.9 33.45,130.67 30.07,130.67 30,130.75 30,131.28 30.1,131.38 33.53,131.38
+3V_PRIM on IN3 (solid shape): 48.44,89.55 48.44,88.73 48.32,88.61 47.14,88.61 46.89,88.86 46.89,89.42 47.07,89.59 48.4,89.59
+3V_PRIM on IN4 (solid shape): 47.94,141.09 45.84,138.99 45.72,138.99 45.42,139.3 45.42,139.69 47.02,141.29 47.74,141.29
+3V_PRIM on IN4 (solid shape): 49.2,101.64 49.2,100.5 49.07,100.37 47.95,100.37 47.76,100.57 47.76,101.02 48.52,101.78 49.06,101.78
+3V_PRIM on IN4 (solid shape): 30.48,128.51 30.48,127.95 31.22,127.22 31.22,126.51 31.04,126.33 30.84,126.33 29.9,127.27 29.9,128.59 29.95,128.64 30.35,128.64
+3V_PRIM on IN4 (solid shape): 49.17,139.7 49.17,139.46 49.07,139.36 48.69,139.36 48.09,138.77 47.52,138.77 47.35,138.94 47.35,138.99 48.22,139.86 48.33,139.86 48.33,139.87 49.01,139.87
+3V_PRIM on IN4 (solid shape): 49.66,97.22 49.66,95.96 49.6,95.9 48.95,95.9 48.85,95.99 48.85,96.26 48.79,96.32 48.56,96.32 48.43,96.45 48.43,96.91 48.46,96.94 48.47,96.94 48.5,96.97 48.79,96.97 48.87,97.05 48.87,97.2 48.93,97.26 49.62,97.26
+3V_PRIM on IN4 (solid shape): outline of 358 points within 63.13,118.62 67.23,126.23
+3V_PRIM_R on BOTTOM (solid shape): 50.8,89.8 50.8,88.19 50.74,88.13 49.66,88.13 49.31,88.48 48.47,88.48 48.4,88.56 48.4,89.99 48.48,90.07 50.53,90.07
+3V_RF on TOP (solid shape): 113.71,166.71 113.71,164.83 113.36,164.48 110.17,164.48 110.02,164.63 110.02,165.58 110.07,165.63 112.79,165.63 113.12,165.97 113.12,166.7 113.2,166.78 113.65,166.78
+3V_SKYCAM on BOTTOM (solid shape): 143.95,145.04 143.95,142.81 143.76,142.62 143.51,142.62 143.38,142.75 143.38,145.04 143.45,145.1 143.89,145.1
+3V_SKYCAM on BOTTOM (solid shape): 148.31,149.33 148.31,145.65 148.04,145.38 147.6,145.38 147.52,145.46 147.52,149.27 147.65,149.4 148.23,149.4
+3V_SKYCAM on BOTTOM (solid shape): 153.03,142.48 153.58,142.48 153.67,142.39 153.67,141.97 153.58,141.87 152.77,141.87 152.44,142.2 152.44,142.44 152.3,142.58 151.88,142.58 151.78,142.68 151.78,142.86 151.82,142.91 152.61,142.91
+3V_SKYCAM on BOTTOM (solid shape): 150.5,141.25 150.5,140.73 150.8,140.44 150.83,140.44 151,140.27 152.02,140.27 152.22,140.07 152.22,139.05 152.12,138.95 151.56,138.95 151.37,138.76 151.03,138.76 151,138.8 151,138.9 150.99,138.91 150.99,139.17 151.06,139.24 151.06,139.69 150.8,139.95 150.51,139.95 150.22,140.24 150.22,141.28 150.24,141.3 150.45,141.3
+3VALW on TOP (solid shape): 118.11,104.64 118.2,104.64 118.2,104.16 118.85,104.16 118.85,104.64 119.4,104.64 119.4,104.16 120.05,104.16 120.05,104.64 120.14,104.64 120.14,104.65 120.97,104.65 121.16,104.46 121.16,102.43 120.78,102.05 117.73,102.05 117.35,102.43 117.35,104.52 117.47,104.65 118.11,104.65
+3VALW on BOTTOM (solid shape): 23.75,135.19 23.75,133.99 23.62,133.86 21.97,133.86 21.8,134.03 21.8,135.23 21.89,135.32 23.62,135.32
+3VALW on BOTTOM (solid shape): 53.43,90.01 53.43,88.49 53.08,88.14 52.13,88.14 52.06,88.21 52.06,89.96 52.2,90.1 53.35,90.1
+3VALW on BOTTOM (solid shape): 17.42,115.99 17.42,114.19 17.35,114.11 16.33,114.11 16.13,114.31 16.13,116.04 16.18,116.09 17.32,116.09
+3VALW on BOTTOM (solid shape): 23.95,128.89 23.95,128.44 23.88,128.36 23.06,128.36 22.73,128.03 22.1,128.03 21.92,128.21 21.92,128.49 22.43,129 23.85,129
+3VALW on BOTTOM (solid shape): 28.33,100.53 28.33,99.03 28.26,98.95 27.58,98.95 27.46,99.08 27.46,100.47 27.66,100.67 28.19,100.67
+3VALW on BOTTOM (solid shape): 75.5,21.72 75.5,20 75.31,19.81 74.55,19.81 74.49,19.88 74.49,20.51 74.13,20.87 74.13,22.15 74.21,22.23 74.99,22.23
+3VALW on BOTTOM (solid shape): 17.4,96.66 17.4,96.2 17.27,96.08 17.27,93.23 17.02,92.98 16.64,92.98 16.57,93.05 16.57,96.29 17.12,96.84 17.22,96.84
+3VALW on BOTTOM (solid shape): 21.08,123.13 21.08,121.91 20.95,121.78 20.47,121.78 20.42,121.83 20.42,122.82 20.22,123.03 19.58,123.03 19.51,123.1 19.51,123.48 19.63,123.61 20.6,123.61
+3VALW on BOTTOM (solid shape): 52.96,86.65 53.4,86.65 53.46,86.58 53.46,85 53.85,84.61 53.85,83.79 53.76,83.71 51.61,83.71 51.44,83.89 51.44,84.2 52.06,84.83 52.06,86.68 52.13,86.75 52.86,86.75
+3VALW on BOTTOM (solid shape): 72.13,22.22 72.14,22.23 72.69,22.23 72.75,22.17 72.75,21.33 72.86,21.21 72.86,20.7 72.76,20.6 71.64,20.6 71.52,20.72 71.52,22.3 71.62,22.4 71.96,22.4
+3VALW on BOTTOM (solid shape): 141.96,92.19 142.67,92.19 142.98,91.89 142.98,91.56 142.85,91.43 142.62,91.43 142.39,91.66 141.94,91.66 141.68,91.4 141,91.4 140.87,91.53 140.87,92.52 141.02,92.67 141.48,92.67
+3VALW on BOTTOM (solid shape): 35.41,135.32 35.46,135.28 35.52,135.25 35.53,135.25 35.99,134.79 36.5,134.79 36.6,134.69 36.6,133.72 36.35,133.47 34.92,133.47 34.91,133.48 34.66,133.48 34.49,133.64 34.49,134.09 34.23,134.35 34.23,135.26 34.29,135.32
+3VALW on BOTTOM (solid shape): 35.82,124.27 35.82,123.52 36.23,123.11 36.73,123.11 36.9,122.94 36.9,121.82 36.71,121.63 36.31,121.63 36.12,121.83 36.12,122.05 35.52,122.65 35.52,122.83 35.4,122.96 35.35,123.03 35.28,123.08 35,123.36 34.62,123.36 34.39,123.59 34.39,124.07 34.52,124.19 34.52,124.6 34.72,124.8 35.28,124.8
+3VALW on BOTTOM (solid shape): outline of 226 points within 15.76,78.67 26.29,87.95
+3VALW on IN2 (solid shape): 121.64,103.74 121.64,102.58 121.06,102 116.84,102 116.42,102.41 116.42,103.91 116.88,104.37 121.01,104.37
+3VALW on IN2 (solid shape): 27.94,51.14 27.94,48.13 30.17,45.9 30.17,44.96 30.11,44.91 29.43,44.91 29.29,45.05 29.29,45.45 27.98,46.76 27.89,47.01 27.65,47.09 27.6,47.14 27.54,47.25 27.43,47.31 27.18,47.56 25.15,47.56 24.64,48.07 24.64,48.45 24.77,48.58 25.88,48.58 26.47,49.16 26.47,51.04 26.75,51.32 27.76,51.32
+3VALW on IN3 (solid shape): 20.84,84.86 20.84,83.3 20.63,83.09 18.63,83.09 18.48,83.25 18.48,85.02 18.69,85.23 20.46,85.23
+3VALW on IN3 (solid shape): 26.25,82.21 26.25,80.49 26.04,80.28 22.74,80.28 22.23,80.79 22.23,82.52 22.45,82.73 25.72,82.73
+3VALW on IN3 (solid shape): 28.52,99.62 28.52,97.6 28.42,97.5 28.04,97.5 27.94,97.6 27.94,99.74 28.04,99.85 28.3,99.85
+3VALW on IN3 (solid shape): 14.22,105.7 16.21,105.7 16.46,105.96 16.74,105.96 16.84,105.86 16.84,105.3 16.54,104.99 13.82,104.99 13.49,105.32 13.49,105.86 13.59,105.96 13.97,105.96
+3VALW on IN3 (solid shape): 21.13,123.02 21.13,122.54 20.98,122.39 19.05,122.39 18.14,121.48 17.37,121.48 17.27,121.58 17.27,122.49 17.35,122.57 17.89,122.57 18.5,123.18 20.97,123.18
+3VALW on IN4 (solid shape): 17.07,93.49 17.07,92.98 17.02,92.93 16.74,92.93 15.8,93.87 15.8,94.22 16.33,94.22
+3VALW on IN4 (solid shape): 30.12,51.2 30.12,50.87 29.89,50.64 28.02,50.64 27.84,50.81 27.84,51.09 28.02,51.27 30.05,51.27
+3VALW on IN4 (solid shape): 48.29,144.11 48.29,143.17 48.13,143.02 47.55,143.02 47.42,143.14 47.42,144.08 47.6,144.26 48.13,144.26
+3VALW on IN4 (solid shape): 35.31,124.58 35.31,123.08 35.18,122.95 34.8,122.95 34.37,123.38 34.37,124.8 34.59,125.03 34.85,125.03
+3VALW on IN4 (solid shape): 39.09,98.36 39.09,96.81 39.01,96.74 38.53,96.74 38.18,97.09 38.18,97.88 38.18,97.88 38.18,98.43 38.3,98.56 38.89,98.56
+3VALW on IN4 (solid shape): 23.64,129.14 23.64,128.51 23.24,128.11 23.24,127.67 23.17,127.6 22.83,127.6 22.61,127.83 22.61,129.16 22.53,129.24 22.53,129.45 22.71,129.63 23.15,129.63
+3VALW on IN4 (solid shape): outline of 156 points within 14.81,114.37 17.63,122.19
+3VALW on IN1: outline of 84 points within 68.1,89.92 121.54,107.47
+3VALW on VCC: outline of 115 points within 22.99,1.02 161.88,136.97 ; 1 cut-out
+3VALW_TPM on BOTTOM (solid shape): 37.6,97.54 38.62,97.54 38.7,97.46 38.7,96.72 38.46,96.48 37.9,96.48 37.65,96.24 37.65,95.47 37.56,95.38 36.85,95.38 36.51,95.72 35.28,95.72 35.23,95.78 35.23,96.38 35.43,96.59 36.07,96.59 36.45,96.97 36.45,97.62 36.65,97.83 37.31,97.83
+3VALW_USH on TOP (solid shape): 137.92,93.54 137.92,93.09 137.79,92.96 137.79,92.14 137.72,92.06 136.78,92.06 136.7,92.14 136.7,92.65 136.53,92.83 136.53,93.59 136.67,93.73 137.73,93.73
+3VALW_USH on BOTTOM (solid shape): 142.45,90.28 142.45,90.01 142.32,89.88 141.83,89.88 141.6,89.65 141.6,88.51 141.5,88.41 141,88.41 140.87,88.53 140.87,89.96 141.3,90.39 142.34,90.39
+3VALW_USH on IN4 (solid shape): 141.07,90.54 142.03,90.54 142.18,90.49 142.32,90.54 142.34,90.54 142.52,90.36 142.52,90.03 142.32,89.83 140.51,89.83 137.82,92.52 136.8,92.52 136.47,92.85 136.47,93.16 136.73,93.41 138.2,93.41
+3VALWP on TOP (solid shape): 120.9,110.3 120.9,105.03 120.71,104.84 119.94,104.84 119.94,104.27 119.5,104.27 119.5,104.82 118.75,104.82 118.75,104.27 118.31,104.27 118.31,104.84 117.6,104.84 117.54,104.9 117.54,110.43 117.79,110.68 120.52,110.68
+3VALWP on BOTTOM (solid shape): 120.78,107.51 120.78,106.49 120.65,106.36 117.79,106.36 117.67,106.49 117.67,107.51 117.79,107.63 120.65,107.63
+3VS on TOP (solid shape): 25.86,90.68 25.86,90.3 25.73,90.17 25.46,90.17 24.84,90.8 24.84,90.99 25.09,91.25 25.29,91.25
+3VS on TOP (solid shape): 58.82,96.47 58.92,96.36 58.92,95.92 58.78,95.77 56.38,95.77 55.5,96.65 54.05,96.65 53.89,96.81 53.89,97.42 54,97.54 56.83,97.54
+3VS on TOP (solid shape): 30.34,109.67 30.98,109.67 31.05,109.6 31.05,109.24 31.01,109.21 28.75,109.21 28.57,109.03 28.57,107.89 28.7,107.76 28.7,107.25 28.61,107.16 28.06,107.16 27.94,107.28 27.94,109.41 28.44,109.91 30.09,109.91
+3VS on TOP (solid shape): 47.22,129.22 47.22,125.97 46.99,125.74 46.56,125.74 46.35,125.95 46.35,128.41 46.22,128.55 45.53,128.55 45.36,128.39 45.36,126.89 45.25,126.77 44.54,126.77 43.51,127.8 43.51,128.21 44.65,129.35 46.08,129.35 46.09,129.36 47.08,129.36
+3VS on BOTTOM (solid shape): 42.88,140.45 42.88,139.59 42.72,139.43 42.14,139.43 41.73,139.84 41.73,140.4 41.94,140.6 42.72,140.6
+3VS on BOTTOM (solid shape): 143.51,90.24 143.51,89.14 143.33,88.97 142.75,88.97 142.47,89.24 141.94,89.24 141.86,89.32 141.86,89.68 141.96,89.78 142.39,89.78 142.56,89.95 142.56,90.26 142.64,90.34 143.41,90.34
+3VS on BOTTOM (solid shape): 28.07,136.34 28.07,135.57 28.38,135.26 30.1,135.26 30.16,135.19 30.16,133.73 29.97,133.54 28.32,133.54 27.05,134.81 27.05,135.54 26.73,135.85 26.64,135.85 26.42,136.08 26.42,136.84 26.54,136.97 27.43,136.97
+3VS on BOTTOM (solid shape): 120.2,162.5 120.2,160.95 119.91,160.66 119.87,160.66 119.47,160.25 119.42,160.2 119.42,159.72 119.33,159.63 119.13,159.63 119.06,159.7 119.06,160.44 119.44,160.82 119.44,161.91 119.34,162.02 118.33,162.02 118.14,162.09 117.96,162.02 117.67,162.02 117.47,161.81 117.47,161.34 117.43,161.3 116.89,161.3 116.85,161.34 116.85,162.42 117.2,162.78 119.92,162.78
+3VS on BOTTOM (solid shape): 119.4,158.53 119.4,157.89 119.22,157.71 119.22,157.02 119.04,156.84 119.04,155.77 119.4,155.41 119.4,154.6 119.19,154.39 116.98,154.39 116.7,154.67 116.7,154.85 117.64,154.85 117.64,154.8 117.64,154.75 117.66,154.7 117.68,154.65 117.71,154.61 117.75,154.57 117.79,154.54 117.84,154.52 117.89,154.5 117.94,154.5 117.99,154.5 118.04,154.5 118.09,154.52 118.14,154.54 118.18,154.57 118.22,154.61 118.25,154.65 118.27,154.7 118.29,154.75 118.3,154.8 118.3,154.85 118.29,154.9 118.27,154.95 118.25,155 118.22,155.04 118.18,155.08 118.14,155.11 118.09,155.13 118.04,155.15 117.99,155.16 117.94,155.16 117.89,155.15 117.84,155.13 117.79,155.11 117.75,155.08 117.71,155.04 117.68,155 117.66,154.95 117.64,154.9 117.64,154.85 116.7,154.85 116.7,156.29 116.77,156.37 117.31,156.37 117.37,156.31 117.37,155.84 117.54,155.67 118.29,155.67 118.47,155.85 118.47,157.8 118.58,157.91 118.85,157.91 119.08,158.14 119.08,158.53 119.16,158.61 119.32,158.61
+3VS on IN1 (solid shape): 28.69,107.79 28.69,107.2 28.13,106.64 28.04,106.64 27.79,106.9 27.79,107.14 28.05,107.41 28.05,107.68 28.21,107.84 28.64,107.84
+3VS on IN2 (solid shape): 28.61,143.52 28.61,142.82 28.48,142.69 26.83,142.69 26.64,142.88 26.64,143.46 26.89,143.71 28.42,143.71
+3VS on IN2 (solid shape): 32.58,164.4 32.58,162.94 31.94,162.31 31.43,162.31 31.18,162.56 31.18,164.28 31.5,164.59 32.38,164.59
+3VS on IN3 (solid shape): 33.75,164.44 33.75,163.53 33.7,163.48 31.34,163.48 31.2,163.61 31.2,164.39 31.32,164.51 33.68,164.51
+3VS on IN3 (solid shape): 111.51,171.61 111.69,171.43 111.69,170.15 111.42,169.88 110.06,169.88 109.87,170.08 109.87,171.46 110.03,171.62 111.51,171.62
+3VS on IN3 (solid shape): 27.62,136.69 27.62,135.45 27.5,135.32 26.49,135.32 26.15,135.66 26.15,136.5 26.41,136.76 26.41,136.88 26.47,136.94 27.37,136.94
+3VS on IN3 (solid shape): 42.24,141.29 42.24,141.06 41.58,140.4 41.55,140.4 41.27,140.68 41.27,141.01 41.41,141.15 41.5,141.15 41.87,141.52 42.01,141.52
+3VS on IN3 (solid shape): 143.18,88.84 144.65,88.84 145.36,89.55 145.44,89.47 145.44,88.81 144.83,88.2 143.26,88.2 143.23,88.18 142.88,88.18 141.99,89.07 141.99,89.09 141.96,89.12 141.96,89.65 142.09,89.78 142.24,89.78
+3VS on IN3 (solid shape): 27.17,122.63 27.17,122.25 27.35,122.08 28.69,122.08 29.24,121.53 30.73,121.53 30.89,121.38 30.89,121.31 31.01,121.18 31.01,121 30.88,120.87 29.1,120.87 28.46,121.5 26.79,121.5 25.98,122.32 25.73,122.32 25.53,122.52 25.53,122.77 25.64,122.89 26.91,122.89
+3VS on IN4 (solid shape): 111.87,171.7 111.87,170.77 111.73,170.63 110.11,170.63 109.96,170.78 109.96,171.72 110.11,171.87 111.7,171.87
+3VS on IN4 (solid shape): 26.55,125.52 26.55,122.64 26.3,122.39 25.71,122.39 25.59,122.52 25.59,123.4 25.4,123.59 25.4,124.29 25.4,124.29 25.4,125.13 25.92,125.65 26.42,125.65
+3VS on IN4 (solid shape): 42.44,141.45 42.48,141.38 42.55,141.34 42.6,141.29 42.6,140.12 42.27,139.79 41.55,139.79 41.27,140.07 41.27,140.91 41.91,141.54 42.34,141.54
+3VS on IN4 (solid shape): outline of 169 points within 26.15,134.6 28.19,143.97
+3VS_AUDIO_R on BOTTOM (solid shape): 23.08,138.63 23.08,138.01 23.04,137.97 22.84,137.97 22.44,137.57 22.44,136.64 22.36,136.56 21.87,136.56 21.81,136.63 21.81,137.87 22.09,138.16 22.09,138.6 22.15,138.66 23.05,138.66
+3VS_CAM on BOTTOM (solid shape): 146.81,150.12 146.81,148.34 146.75,148.27 146.18,148.27 145.67,147.77 144.91,147.77 144.86,147.81 144.86,148.74 145.29,149.16 145.29,149.48 145.99,150.18 146.75,150.18
+3VS_CR on BOTTOM (solid shape): 69.67,37.42 69.67,36.97 69.6,36.91 68.61,36.91 68.47,36.76 68.47,34.87 68.42,34.82 68.29,34.82 68.25,34.85 68.25,36.72 68.17,36.8 68.17,37.46 68.2,37.49 69.6,37.49
+3VS_CR on BOTTOM (solid shape): 69.66,31.58 69.66,31.25 69.65,31.2 69.65,31.16 69.65,30.58 69.66,30.57 69.66,30.34 70.53,29.47 70.53,28.04 71.16,27.41 72.3,27.41 72.4,27.32 72.4,26.52 72.32,26.45 69.44,26.45 68.94,26.95 68.96,26.98 69.04,27.22 68.93,27.44 68.93,27.61 69.01,27.83 68.93,28.04 68.93,28.69 68.97,28.73 69.59,28.73 69.73,28.87 69.73,29.58 69.46,29.85 69.46,31.57 69.49,31.61 69.63,31.61
+3VS_CR on IN4 (solid shape): outline of 182 points within 66.26,27.88 71.69,37.91
+3VS_CR_R on BOTTOM (solid shape): 72.39,25.72 72.39,25.08 72.74,24.73 72.74,23.55 72.68,23.5 71.63,23.5 71.37,23.75 71.37,25.72 71.44,25.78 72.33,25.78
+3VS_IR on TOP (solid shape): 27.3,104.84 27.3,104.46 27.05,104.21 14.22,104.21 13.82,103.8 13.82,102.43 14.63,101.62 15.49,101.62 15.61,101.49 15.61,101.18 15.52,101.08 15.21,101.08 15.21,101.09 14.65,101.09 14.58,101.03 13.34,101.03 13.27,101.09 13.27,102.14 13.07,102.34 13.07,104.5 13.56,104.99 27.15,104.99
+3VS_IR on BOTTOM (solid shape): 26.52,102.38 26.52,101.46 26.37,101.31 25.81,101.31 25.5,101.61 25.5,102.35 25.7,102.55 26.34,102.55
+3VS_IR on IN2 (solid shape): 27.1,104.46 27.1,102.55 27.01,102.47 26.44,102.47 26.35,102.56 26.35,104.5 26.36,104.51 27.05,104.51
+3VS_MUX on BOTTOM (solid shape): 23.1,30.76 23.1,30.15 22.94,29.99 22.94,28.51 22.89,28.46 22.76,28.46 22.72,28.5 22.72,30.13 22.61,30.24 22.61,30.74 22.66,30.79 23.08,30.79
+3VS_MUX on BOTTOM (solid shape): 27.62,33.04 27.62,31.5 27.56,31.43 25.83,31.43 25.19,32.08 25.19,33.07 25.25,33.14 27.53,33.14
+3VS_MUX on BOTTOM (solid shape): 23.83,49.2 23.83,48.16 23.79,48.11 23.79,48.06 23.49,47.76 23.49,46.39 22.99,45.89 22.99,44.01 22.8,43.82 22.8,42.84 22.76,42.8 22.63,42.8 22.59,42.84 22.59,43.75 22.52,43.83 22.52,45.32 22.43,45.4 22.43,46.2 22.46,46.23 22.46,48.79 22.91,49.24 23.8,49.24
+3VS_MUX on IN3 (solid shape): 27.33,31.31 27.33,30.93 27.23,30.82 25.73,30.82 25.53,31.03 25.53,31.36 25.65,31.48 27.15,31.48
+3VS_R on BOTTOM (solid shape): 32.96,135.24 32.96,134.38 32.75,134.17 30.97,134.17 30.84,134.29 30.84,135.25 30.89,135.3 32.9,135.3
+3VS_TPM on BOTTOM (solid shape): 38.66,91.11 38.66,89.69 39.21,89.15 39.21,88.18 39.18,88.15 38.06,88.15 37.99,88.23 37.99,89.74 38.39,90.14 38.39,91.12 38.46,91.19 38.59,91.19
+3VS_TPM on BOTTOM (solid shape): 43.5,93.04 43.5,92.02 43.65,91.87 43.97,91.87 44.89,90.96 44.89,88.93 42.44,86.48 41.55,86.48 41.38,86.65 41.38,87.09 41.58,87.29 42.06,87.29 43.61,88.84 43.61,89.35 43.79,89.52 43.99,89.52 44.12,89.65 44.12,90.44 43.43,91.12 42.8,91.12 42.65,91.27 42.65,92.02 42.3,92.38 41.44,92.38 41.35,92.47 41.35,92.6 41.43,92.68 42.73,92.68 42.81,92.76 42.81,93.05 42.94,93.18 43.36,93.18
+3VS_TPM on IN3 (solid shape): 39.12,88.89 39.12,87.42 39.2,87.33 39.2,87.32 39.39,87.17 39.61,87.26 42.03,87.26 42.16,87.13 42.16,86.86 41.97,86.66 39.57,86.66 39.51,86.6 39.09,86.6 38.38,87.31 38.38,88.86 38.53,89.02 38.99,89.02
+3VS_TS on BOTTOM (solid shape): 77.09,29.4 79.84,29.4 80.29,28.95 84,28.95 84.26,29.21 84.58,29.21 84.66,29.12 84.66,28.48 84.31,28.13 76.01,28.13 75.56,27.69 75.56,26.48 75.5,26.42 74.68,26.42 74.61,26.48 74.61,29.97 74.73,30.09 76.4,30.09
+3VS_TS on IN2 (solid shape): 85.6,29.24 85.6,28.51 85.48,28.39 84.58,28.39 84.39,28.58 84.39,29.28 84.45,29.34 85.5,29.34
+3VS_TS_R on BOTTOM (solid shape): 75.63,25.66 75.63,24.98 75.1,24.45 75.1,23.62 74.98,23.5 74.17,23.5 74.13,23.54 74.13,24.66 74.55,25.08 74.55,25.72 74.61,25.78 75.5,25.78
+3VS_USH on BOTTOM (solid shape): 143.54,93.23 143.54,92.11 143.43,92.01 143.1,92.01 142.82,92.29 142.04,92.29 141.92,92.41 141.92,92.73 142.02,92.83 142.42,92.83 142.9,93.31 143.46,93.31
+3VS_USH on IN1 (solid shape): 142.14,93.38 142.14,92.9 142.01,92.78 138.19,92.78 138.05,92.91 138.05,93.43 138.18,93.56 141.96,93.56
+3VS_WLAN on TOP (solid shape): 20.38,62.74 20.38,59.82 20.26,59.7 18.72,59.7 17.78,60.64 17.78,63.31 18.16,63.69 19.43,63.69
+3VS_WLAN on TOP (solid shape): 37.97,61.22 37.97,58.8 37.91,58.74 37.91,58.04 37.78,57.91 36.89,57.91 36.77,58.04 36.77,59.18 37.02,59.44 37.02,61.22 37.08,61.28 37.91,61.28
+3VS_WLAN on TOP (solid shape): 26.16,84.49 26.47,84.15 26.82,83.86 26.82,83.86 27.56,83.12 27.56,82.81 26.48,81.73 26.1,81.73 24.94,82.88 24.12,82.88 24,83 24,84.38 24.11,84.49
+3VS_WLAN on BOTTOM (solid shape): 37.91,58.68 37.91,57.42 37.78,57.3 37.3,57.3 37.15,57.15 37.08,57.15 34.78,57.15 34.73,57.19 34.73,57.79 34.86,57.91 35.5,57.91 35.69,58.1 35.69,58.72 35.9,58.93 37.66,58.93
+3VS_WLAN on BOTTOM (solid shape): 25.95,84.8 25.99,84.74 26.07,84.61 26.16,84.49 26.26,84.38 26.36,84.27 26.46,84.16 26.52,84.11 26.52,83.06 26.28,82.82 22.83,82.82 22.77,82.88 22.77,83.64 24.61,83.64 24.61,84.35 23.85,84.35 23.85,83.64 22.77,83.64 22.77,84.36 22.93,84.52 24.63,84.52 24.91,84.8
+3VS_WLAN on BOTTOM (solid shape): 20.64,63.31 20.64,61.67 20.86,61.46 20.86,59.01 21.12,58.74 21.8,58.74 22.11,58.43 22.11,54.42 21.97,54.28 20.95,54.28 20.84,54.38 20.84,55.47 20.81,55.5 20.81,55.88 20.63,56.06 20.37,56.06 20.31,56 20.2,56.11 20.2,56.11 20.14,56.17 20.14,56.87 19.73,57.28 19.73,57.94 19.73,57.95 19.51,58.95 18.54,59.29 18.48,59.29 18.3,59.46 18.3,61.32 18.5,61.52 19.31,61.52 19.56,61.77 19.56,62.49 19.81,62.74 19.81,63.37 19.88,63.44 20.51,63.44
+3VS_WLAN on IN1 (solid shape): 38.12,62.56 38.12,58.79 37.94,58.44 37.95,58.04 36.81,57.69 36.12,58.65 36.12,61.7 33.68,64.14 27.34,64.14 27.11,63.91 27.11,62.26 24.42,59.56 19.24,59.56 18.22,60.58 19.24,61.6 23.58,61.6 25.08,63.1 25.08,64.75 26.5,66.17 34.52,66.17
+3VS_WLAN_R on BOTTOM (solid shape): 21.94,85.44 21.94,82.86 21.91,82.84 20.9,82.84 20.7,83.03 20.7,85.54 20.77,85.6 21.78,85.6
+3VS_WWAN on TOP (solid shape): 34.85,125.95 34.85,122.04 34.34,121.53 33.66,121.53 33.48,121.35 32.06,121.35 31.97,121.44 31.97,123.54 31.37,124.14 17.39,124.14 17.26,124.27 16.66,124.27 15.79,123.41 15.79,121.44 15.7,121.35 14.61,121.35 14.48,121.48 14.48,125.62 16.37,127.51 33.29,127.51
+3VS_WWAN on BOTTOM (solid shape): 17.2,125.59 17.2,124.91 17.02,124.73 17.02,123.94 17.17,123.79 17.17,123.33 17.09,123.26 16.71,123.26 16.61,123.15 16.08,123.15 16.03,123.2 16.03,125.54 16.15,125.67 17.12,125.67
+3VS_WWAN on BOTTOM (solid shape): 36.51,126.36 36.51,125.57 34.17,125.57 33.68,125.07 33.68,124.98 33.57,124.86 33.52,124.71 33.53,124.29 33.53,123.56 33.66,123.43 33.66,123.06 33.56,122.95 33.52,122.81 33.52,122.43 33.67,122.17 34.06,122.15 34.11,122.07 34.11,121.65 34.06,121.6 33.15,121.6 33.07,121.68 33.07,122.09 33.22,122.24 33.22,122.92 33.21,122.94 33.21,122.96 33.19,122.96 32.94,123.2 32.56,123.2 32.38,123.38 32.38,124.8 32.31,124.88 31.95,124.88 31.75,125.08 31.75,125.99 31.94,126.18 32.78,126.18 33.21,126.61 36.27,126.61
+3VS_WWAN on BOTTOM (solid shape): 31.33,90.07 31.33,88.72 31.27,88.63 31.15,88.66 28.84,89.75 26.45,88.82 26.14,88.48 25.88,88.09 25.84,88.01 25.58,87.33 25.47,86.61 25.47,86.53 25.47,86.44 25.45,86.38 25.41,86.35 23.86,86.35 23.75,86.45 23.75,87.27 23.56,87.47 23.56,90.01 23.66,90.12 25.81,90.12 25.82,90.11 26.17,90.11 26.29,90.24 31.16,90.24
+3VS_WWAN on IN1 (solid shape): 27.01,90.63 27.08,90.6 27.11,90.53 27.34,90.31 27.57,90.53 27.6,90.6 27.67,90.63 29.33,90.63 29.35,90.6 29.55,90.48 29.76,90.6 29.77,90.63 30.12,90.63 30.13,90.62 31.03,90.62 31.33,90.31 31.33,88.72 31.27,88.63 31.15,88.66 27.54,89.53 25.47,86.44 25.44,86.37 25.37,86.34 24.51,86.34 24.24,86.6 24.24,89.28 24.93,89.97 26.02,89.97 26.68,90.63
+3VS_WWAN on IN2 (solid shape): 34.65,122.7 33.43,121.48 33.2,121.48 33.12,121.55 33.12,121.83 34.16,122.87 34.47,122.87
+3VS_WWAN on IN2 (solid shape): outline of 190 points within 23.83,82.15 31.36,91.91
+3VS_WWAN on IN3 (solid shape): 17.17,123.92 17.17,123.41 16.97,123.2 16.3,123.2 15.77,123.73 15.77,124.12 16.19,124.53 16.55,124.53
+3VS_WWAN on IN3 (solid shape): 34.47,122.42 34.47,121.83 34.34,121.71 33.1,121.71 32.77,122.04 32.77,122.24 33.05,122.52 34.37,122.52
+3VS_WWAN on IN3 (solid shape): outline of 154 points within 23.83,82.15 27.44,89.65
+3VS_WWAN on VCC: 24.55,90.59 38.52,90.59 39.49,91.55 39.49,108.26 27.94,119.8 27.94,126.3 33.3,126.3 44.7,114.89 44.7,88.26 37.86,81.41 26.98,81.41 25.89,82.5 23.88,82.5 23.88,89.91
+3VS_WWAN_R on BOTTOM (solid shape): 23.27,89.81 23.27,87.57 22.68,86.99 20.78,86.99 20.71,87.05 20.71,88 21.18,88.47 21.18,89.66 21.53,90 23.07,90
+5V_DOCK on TOP (solid shape): 73.17,63.55 73.17,63.2 73.51,62.87 75.13,62.87 75.27,62.73 75.27,60.57 75.15,60.44 73.91,60.44 73.22,59.74 73.22,59.56 73.03,59.37 72.2,59.37 72.14,59.44 72.14,63.44 72.39,63.69 73.03,63.69
+5V_DOCK_R on TOP (solid shape): 71.37,60.84 71.37,59.44 71.95,59.44 72.39,58.99 72.39,57.79 72.26,57.66 71.5,57.66 71.37,57.79 71.37,58.55 70.42,59.5 70.42,60.83 70.48,60.9 71.31,60.9
+5V_USB_P1 on TOP (solid shape): 30.42,99.4 31.46,99.4 31.54,99.32 31.54,98.21 31.37,98.05 29.91,98.05 28.88,99.07 28.88,99.71 29.14,99.97 29.85,99.97
+5V_USB_P1 on BOTTOM (solid shape): 20.79,98.58 20.79,97.64 21.2,97.23 21.2,96.65 21.34,96.51 21.34,94.58 21.25,94.49 20.81,94.49 20.7,94.61 20.7,95.19 20.47,95.42 18.77,95.42 18.59,95.59 18.59,96.11 18.44,96.27 18.02,96.27 17.98,96.31 17.98,96.7 18.05,96.76 18.2,96.76 18.62,97.18 18.62,98.81 20.56,98.81
+5V_USB_P1 on IN1 (solid shape): outline of 131 points within 8.17,95.96 12.97,107.2
+5V_USB_P1 on IN2 (solid shape): 13.46,97.86 13.46,97.12 13.28,96.94 11.28,96.94 11.18,97.04 11.18,98.11 11.25,98.19 13.13,98.19
+5V_USB_P1 on IN3 (solid shape): outline of 85 points within 10.95,93.23 19.89,97.92
+5V_USB_P1 on VCC: 12,96.97 12,103.29 11.22,104.08 8.17,104.08 8.17,107.95 14.63,107.95 15.49,107.08 15.49,102.86 16.81,101.54 22.58,101.54 24.74,103.7 30.12,103.7 30.73,103.08 30.73,98.47 30.5,98.24 19.07,98.24 17.8,96.97
+5VALW on TOP (solid shape): 36.39,99.51 36.39,96.32 36.09,96.03 34.24,96.03 33.88,96.38 33.88,98.77 33.73,98.92 33.73,99.32 33.82,99.4 34.95,99.4 35.22,99.68 36.21,99.68
+5VALW on TOP (solid shape): 14.48,97.66 14.48,95.7 14.29,95.51 13.81,95.51 13.4,95.92 13.4,96.95 13.28,97.07 12.39,97.07 12.32,97.15 12.32,97.92 12.45,98.05 14.1,98.05
+5VALW on BOTTOM (solid shape): 43.05,58.61 43.05,57.34 42.93,57.22 40.77,57.22 40.65,57.34 40.65,58.64 40.74,58.74 42.93,58.74
+5VALW on BOTTOM (solid shape): 57.53,29.53 57.53,27.75 57.28,27.5 55.37,27.5 55.12,27.75 55.12,29.53 55.24,29.66 57.4,29.66
+5VALW on BOTTOM (solid shape): 26.8,129.07 26.8,128.61 26.72,128.54 25.18,128.54 25,128.72 25,129.09 25.11,129.2 26.67,129.2
+5VALW on BOTTOM (solid shape): 45.02,163.75 45.02,163.17 44.53,163.17 44.53,162.52 45.02,162.52 45.02,161.97 44.53,161.97 44.53,161.32 45.02,161.32 45.02,159.67 44.88,159.53 41.87,159.53 41.72,159.68 41.72,162.93 41.79,163 43.35,163 44.15,163.81 44.97,163.81
+5VALW on BOTTOM (solid shape): 35.94,137.86 35.94,137.24 35.89,137.1 35.94,136.95 35.94,136.62 36.04,136.51 36.53,136.51 36.6,136.44 36.6,135.88 36.55,135.83 34.35,135.83 34.23,135.96 34.23,136.02 34.29,136.08 35.31,136.08 35.41,136.19 35.42,136.19 35.52,136.41 35.37,136.6 35.36,136.6 35.31,136.65 34.29,136.65 34.23,136.72 34.23,137.73 34.48,137.99 35.81,137.99
+5VALW on IN3 (solid shape): 25.55,129.31 25.55,128.72 25.53,128.69 25.43,128.69 25.4,128.67 20.88,128.67 20.62,128.92 20.62,129.33 20.79,129.49 25.37,129.49
+5VALW on IN3 (solid shape): 35.96,137.73 36.07,137.73 36.2,137.61 36.58,137.61 36.7,137.48 36.7,136.65 36.64,136.59 35.38,136.59 35.29,136.61 35.19,136.59 33.52,136.59 33.4,136.71 33.4,137.56 33.96,138.11 35.58,138.11
+5VALW on IN3 (solid shape): outline of 1327 points within 17.76,51.12 43.75,60.83
+5VALW on VCC: 44.98,15.31 44.24,16.01 43.26,16.27 11.94,16.27 11.94,50.63 14.2,50.63 15.27,51.08 15.72,52.15 15.72,87.25 15.13,88.68 13.7,89.27 12,89.27 12,96.46 18.01,96.46 19.28,97.73 30.71,97.73 31.24,98.26 31.24,103.29 30.33,104.21 24.53,104.21 22.37,102.05 17.02,102.05 16,103.07 16,107.29 14.84,108.46 13.08,108.46 13.08,145.1 20.55,145.1 20.81,145.35 21.82,145.35 22.35,145.88 22.35,149.44 22.46,149.54 26.56,149.54 26.67,149.44 26.67,148.17 26.95,147.89 28.55,147.89 28.93,148.27 33.93,148.27 35.31,149.65 35.31,161.12 37.19,163 44.93,163 44.93,148.66 42.71,148.66 41.99,147.93 41.99,137.1 41.98,137.1 23.9,137.1 22.48,135.68 22.48,131.4 27.43,126.45 27.43,119.59 38.98,108.05 38.98,91.76 38.31,91.1 24.34,91.1 23.37,90.12 23.37,78.1 26.63,74.84 26.63,31.2 27.67,30.16 57.43,30.16 59.12,28.47 59.12,15.73 58.7,15.31
+5VALW_IR on TOP (solid shape): 13.29,96.33 13.29,95.87 14.73,94.43 15.43,94.43 15.62,94.24 15.62,93.22 15.49,93.09 14.54,93.09 12.06,95.57 12.06,96.15 12.1,96.23 12.12,96.32 12.19,96.39 13.23,96.39
+5VALW_PD1 on BOTTOM (solid shape): 40.01,63.18 40.77,63.18 40.89,63.06 40.89,61.42 41.03,61.28 42.47,61.28 42.56,61.19 42.56,60.01 42.45,59.89 41.92,59.89 41.91,59.88 39.56,59.88 39.43,60.01 39.43,61.72 38.99,62.17 38.16,62.17 38.04,62.3 38.04,63.88 38.08,63.93 39.26,63.93
+5VALW_PD2 on BOTTOM (solid shape): 63.37,28.51 63.37,23.31 62.56,22.5 62.03,22.5 61.8,22.28 61.32,22.28 61.26,22.22 61.26,21.69 61.16,21.59 60.05,21.59 59.3,20.84 59.3,20.83 58.89,20.41 57.11,20.41 57.01,20.52 57.01,21.51 57.32,21.83 57.91,21.83 58.07,21.99 58.07,22.81 58.15,22.89 59.69,22.89 60.07,23.27 60.07,26.48 58.93,27.62 58.93,29.53 59.05,29.66 62.23,29.66
+5VALWP on TOP (solid shape): 48.77,163.65 48.77,159.79 48.63,159.65 45.93,159.65 44.5,161.08 43.73,161.08 43.5,161.31 43.5,163.32 44.01,163.83 48.59,163.83
+5VALWP on BOTTOM (solid shape): 46.52,162.99 48.6,162.99 48.77,162.83 48.77,159.7 48.6,159.53 45.34,159.53 45.21,159.66 45.21,161.41 45.12,161.41 45.12,161.42 44.65,161.42 44.63,161.43 44.63,161.86 45.18,161.86 45.18,162.62 44.63,162.62 44.63,163.03 44.67,163.07 45.12,163.07 45.12,163.07 45.21,163.07 45.21,163.72 45.3,163.81 45.7,163.81
+5VD on TOP (solid shape): 72.14,55.82 72.14,53.34 72.14,53.34 72.14,53.21 71.95,53.02 70.93,53.02 70.8,53.15 70.8,55.75 71.12,56.07 71.88,56.07
+5VD on TOP (solid shape): 122.9,136.02 122.9,135.76 123.16,135.5 124.05,135.5 124.34,135.78 125.34,135.78 125.44,135.68 125.44,134.95 125.41,134.92 124.56,134.92 124.19,134.55 122.18,134.55 121.92,134.81 121.92,135.8 122.28,136.16 122.76,136.16
+5VD on BOTTOM (solid shape): 141.51,99.55 141.51,98.33 141.26,98.08 140.68,98.08 140.43,98.33 140.43,99.77 140.55,99.89 140.67,99.89 140.67,99.89 141.16,99.89
+5VD on BOTTOM (solid shape): 150.77,90.24 150.77,89.14 150.57,88.94 150.09,88.94 149.76,89.27 149.25,89.27 149.2,89.32 149.2,89.7 149.25,89.75 149.66,89.75 150.22,90.31 150.7,90.31
+5VD on BOTTOM (solid shape): 119.86,138.74 119.86,138.01 119.4,138.01 119.4,137.36 119.86,137.36 119.86,136.81 119.4,136.81 119.4,136.16 119.86,136.16 119.86,135.5 119.61,135.24 117.02,135.24 116.89,135.12 116.89,134.57 116.75,134.43 115.94,134.43 115.82,134.55 115.82,138.69 116.06,138.93 119.67,138.93
+5VD on IN1 (solid shape): 120.78,138.3 120.78,136.69 121.01,136.46 122.59,136.46 122.99,136.06 122.99,134.63 120.78,132.42 120.78,130.11 120.26,129.6 119.91,129.52 119.83,129.17 118.36,127.7 117.09,127.7 116.2,128.59 116.2,129.22 117.35,130.37 117.35,134.24 115.87,135.72 115.87,139.2 116.14,139.47 119.61,139.47
+5VD on IN1 (solid shape): 71.4,53.82 71.4,53.04 71.26,52.9 68.58,52.9 67.44,54.04 67.44,54.06 68.95,54.06 68.95,54.02 68.96,53.98 68.97,53.94 68.99,53.9 69.02,53.87 69.06,53.84 69.09,53.83 69.13,53.81 69.18,53.81 69.22,53.81 69.26,53.83 69.3,53.84 69.33,53.87 69.36,53.9 69.38,53.94 69.4,53.98 69.41,54.02 69.41,54.06 69.4,54.1 69.38,54.14 69.36,54.18 69.33,54.21 69.3,54.24 69.26,54.25 69.22,54.27 69.18,54.27 69.13,54.27 69.09,54.25 69.06,54.24 69.02,54.21 68.99,54.18 68.97,54.14 68.96,54.1 68.95,54.06 67.44,54.06 67.44,55.44 68.33,56.33 68.9,56.33
+5VD on IN2 (solid shape): 141.55,98.6 141.55,96.42 141.52,96.39 140.59,96.39 140.49,96.49 140.49,98.55 140.62,98.68 141.46,98.68
+5VD on IN2 (solid shape): 150.39,91.05 150.39,90.1 150.17,89.88 149.85,89.88 149.63,90.1 149.63,90.74 149.25,91.12 149.25,91.16 149.71,91.62 149.82,91.62
+5VD on IN2 (solid shape): 123.77,136.16 123.84,136.05 123.95,135.98 123.99,135.94 123.99,135.45 123.88,135.34 123.23,135.34 122.98,135.09 122.09,135.09 121.86,135.32 121.86,135.62 122.45,136.22 123.71,136.22
+5VD on IN3 (solid shape): 150.37,90.84 150.37,89.78 149.78,89.19 149.3,89.19 149.1,89.4 149.1,89.63 149.17,89.7 149.56,89.7 149.77,89.92 149.77,90.87 149.89,90.98 150.23,90.98
+5VD on IN1: 74.68,106.87 74.3,107.25 74.3,108.4 74.8,108.9 86.25,108.9 88.12,110.78 93.55,110.78 95.22,112.45 97.04,112.45 97.77,111.72 97.77,110.89 95.32,108.44 90.18,108.44 88.86,107.11 87.85,107.11 87.6,106.87
+5VD_USH on TOP (solid shape): 138.33,90.14 138.33,89.04 138.23,88.94 137.76,88.94 137.6,89.1 137.6,89.33 137.53,89.4 137.53,90.18 137.61,90.26 138.21,90.26
+5VD_USH on BOTTOM (solid shape): 150.72,93.18 150.72,92.11 150.6,91.99 149.97,91.99 149.64,92.32 149.28,92.32 149.22,92.37 149.22,92.72 149.28,92.78 149.68,92.78 150.16,93.26 150.65,93.26
+5VD_USH on IN1 (solid shape): 150.44,93.13 150.44,91.94 150.24,91.73 149.76,91.73 149.38,92.11 149.38,93.16 149.58,93.36 150.22,93.36
+5VD_USH on IN1 (solid shape): 139.12,89.59 139.12,88.92 139.04,88.84 137.92,88.84 137.72,89.03 137.72,89.5 137.82,89.59 137.99,89.59 138.05,89.65 139.05,89.65
+5VD_USH on IN3 (solid shape): 150.47,93.12 150.47,92.15 150.29,91.97 149.82,91.97 149.42,92.37 149.3,92.37 149.2,92.46 149.2,93.17 149.54,93.51 150.07,93.51
+5VDP on TOP (solid shape): 122.96,138.52 122.96,136.54 122.83,136.41 122.33,136.41 121.18,135.27 121.18,135.07 120.98,134.86 117.35,134.86 117.17,135.04 117.17,138.16 117.68,138.67 122.81,138.67
+5VDP on BOTTOM (solid shape): 122.91,138.8 122.91,136.54 122.73,136.36 122.3,136.36 121.72,135.78 121.72,135.45 121.51,135.24 120.31,135.24 120.05,135.5 120.05,136.26 119.96,136.26 119.96,136.26 119.52,136.26 119.5,136.28 119.5,136.7 120.05,136.7 120.05,137.47 119.5,137.47 119.5,137.86 119.53,137.9 120.05,137.9 120.05,138.8 120.18,138.93 122.78,138.93
+5VS on TOP (solid shape): 132.84,136.21 132.84,135.07 132.59,134.81 129.86,134.81 129.79,134.88 129.79,136.08 130.05,136.34 132.72,136.34
+5VS on BOTTOM (solid shape): 149.25,92.17 149.58,92.17 149.66,92.09 149.66,91.73 149.63,91.71 149.22,91.71 148.84,91.33 148.21,91.33 148.08,91.45 148.08,92.65 148.21,92.78 148.64,92.78
+5VS on IN3 (solid shape): 143.6,135.42 143.6,134.71 142.6,133.71 140.2,133.71 140.04,133.86 140.04,135.03 140.28,135.27 141.99,135.27 142.34,135.62 143.4,135.62
+5VS on IN3 (solid shape): 137.6,136.01 137.6,135.12 137.41,134.93 136.02,134.93 135.22,135.73 133.82,135.73 133.41,135.32 130.75,135.32 130.49,135.57 130.49,136.78 131,137.29 136.32,137.29
+5VS on IN3 (solid shape): 147.96,92.29 148.95,92.29 149.07,92.17 149.48,92.17 149.61,92.04 149.61,91.53 149.45,91.38 148.08,91.38 147.07,92.39 146.94,92.39 146.35,92.98 146.35,93.13 146.53,93.31 146.94,93.31
+5VS_AUDIO on BOTTOM (solid shape): 34.49,147.13 37.19,147.13 37.39,146.93 37.39,142.66 37.38,142.65 37.38,141.17 36.95,140.75 36.95,138.82 36.63,138.5 35.44,138.5 35.33,138.52 35.22,138.5 34.67,138.5 34.01,137.83 32.16,137.83 32.12,137.88 32.12,139.93 32.31,140.12 32.31,140.17 33.71,141.57 33.71,142.03 34.49,142.81 34.49,145.78 34.09,146.19 32.92,146.19 32.66,146.45 31.8,146.45 31.7,146.55 31.7,147.44 31.78,147.51 34.11,147.51
+5VS_AUDIO_R on BOTTOM (solid shape): 31.25,139.37 31.25,137.92 31.31,137.86 31.9,137.86 32.08,137.68 32.92,137.68 32.98,137.62 32.98,136.73 32.92,136.68 31.83,136.68 31.29,137.21 31.29,137.23 31.28,137.23 31.22,137.29 30.38,137.29 30.02,137.65 30.02,139.28 30.12,139.38 31.24,139.38
+5VS_R on TOP (solid shape): 129.03,134.94 128.97,134.88 126.94,134.88 126.81,135 126.81,135.7 126.94,135.83 129.03,135.83
+5VS_USH on BOTTOM (solid shape): 149.66,90.31 149.66,89.96 149.63,89.93 149.2,89.93 148.95,89.68 148.95,88.58 148.79,88.43 148.21,88.43 148.08,88.56 148.08,89.93 148.49,90.34 149.63,90.34
+5VS_USH on IN2 (solid shape): 149.3,90.46 149.3,90.06 149.1,89.85 148.97,89.85 148.16,90.67 148.16,90.87 148.46,91.17 148.59,91.17
+AVDD1 on BOTTOM (solid shape): 32.83,150.5 32.83,149.67 33.08,149.42 35.5,149.42 36.45,148.46 36.45,147.45 36.39,147.39 34.61,147.39 34.54,147.45 34.54,148.59 34.39,148.75 34.07,148.75 34.07,148.75 28.64,148.75 28.29,148.4 28.28,148.4 28.16,148.27 27.17,148.27 27.12,148.33 27.12,148.47 27.15,148.51 27.99,148.51 28.78,149.29 29.92,149.29 30.62,149.99 31.94,149.99 32.07,150.12 32.07,150.5 32.13,150.56 32.77,150.56
+DVDD on BOTTOM (solid shape): 25.65,144.73 25.65,143.53 26.36,142.82 26.52,142.82 26.65,142.7 26.65,142.25 26.83,142.06 26.83,141.52 27.14,141.21 28.29,141.21 28.7,140.8 28.7,140.37 28.24,139.92 26.23,139.92 26.03,140.12 26.03,142.71 25.38,143.35 25.38,144.74 25.44,144.8 25.59,144.8
+DVDDIO on BOTTOM (solid shape): 22.42,144.74 22.42,143.55 21.46,142.58 21.46,142.17 21.37,142.08 20.15,142.08 19.89,141.83 19.89,140.99 19.84,140.94 18.93,140.94 18.88,140.99 18.88,142.86 18.95,142.93 21.05,142.93 22.11,144 22.11,144.71 22.18,144.78 22.38,144.78
+VBUS1_20V on TOP (solid shape): 16.15,42.05 16.15,41.92 16.54,41.54 18.59,41.54 18.75,41.39 18.75,41.14 18.9,40.98 20.27,40.98 20.4,40.86 20.4,39.89 20.27,39.77 17.96,39.77 17.6,39.41 17.6,37.76 17.48,37.63 16.31,37.63 16.26,37.58 14.2,37.58 14.05,37.73 14.05,41.85 14.38,42.18 16.03,42.18
+VBUS1_PD_20V on TOP (solid shape): 6.35,42.19 8.28,42.19 8.52,41.95 8.52,41.64 8.69,41.46 9.82,41.46 10.17,41.11 10.17,39.53 9.96,39.32 7.8,39.32 7.76,39.36 6.96,39.36 6.95,39.35 6.29,39.35 6.13,39.19 5.64,39.19 5.48,39.34 5.48,39.74 5.62,39.87 6.09,39.87 6.27,39.69 7.66,39.69 7.8,39.83 7.8,41.67 7.64,41.83 6.6,41.83 6.4,41.63 5.7,41.63 5.53,41.8 5.53,42.18 5.68,42.34 6.2,42.34
+VBUS1_PD_20V on TOP (solid shape): 13.94,42.1 13.94,39.08 13.82,38.95 13.82,37.95 13.68,37.81 13.26,37.81 13.1,37.65 12.52,37.65 12.46,37.71 12.46,40.56 12.37,40.65 12.33,40.7 12.29,40.74 12.25,40.82 12.29,40.9 12.42,41.2 12.22,41.47 12.19,41.48 12.19,42 12.37,42.18 13.87,42.18
+VBUS1_PD_20V on BOTTOM (solid shape): 37.85,62.93 37.85,62.3 38.1,62.04 38.93,62.04 39.18,61.79 39.18,60.33 39.12,60.26 38.61,60.26 38.54,60.33 38.54,60.9 37.53,61.91 37.53,62.93 37.59,62.99 37.78,62.99
+VBUS1_PD_20V on BOTTOM (solid shape): 9.33,41.77 9.33,38.94 9.3,38.91 5.96,38.91 5.66,39.22 5.6,39.4 5.49,39.55 5.49,39.69 5.61,39.82 6.17,39.82 8.18,41.83 9.28,41.83
+VBUS1_PD_20V on BOTTOM (solid shape): 40.06,68.2 40.06,65.93 39.85,65.72 38.67,65.72 38.1,65.72 37.97,65.85 37.97,66.04 37.85,66.17 37.59,66.17 37.53,66.23 37.53,66.49 37.59,66.55 37.91,66.55 38.04,66.68 38.04,66.93 38.1,66.99 38.29,66.99 38.42,67.12 38.42,67.69 39.05,68.33 39.94,68.33
+VBUS1_PD_20V on IN1 (solid shape): outline of 2029 points within 5.53,39.19 42.8,66.79
+VBUS1_PD_20V on GND1 (solid shape): 9.3,41.01 9.3,39.68 9.14,39.52 8.1,39.52 7.91,39.71 7.91,41.15 8.08,41.31 8.99,41.31
+VBUS1_PD_20V on IN3 (solid shape): outline of 136 points within 7.49,39.02 13.97,47.69
+VBUS1_PD_20V on GND3 (solid shape): 9.3,41.61 9.3,39.68 9.25,39.63 7.98,39.63 7.84,39.77 7.84,41.61 7.98,41.75 9.16,41.75
+VBUS2_20V on TOP (solid shape): 15.5,22.89 15.71,22.51 16.12,22.67 16.28,22.67 16.46,22.49 16.46,22.24 16.26,22.04 14.53,22.04 14.35,22.21 14.35,23.03 14.52,23.19 15.2,23.19
+VBUS2_20V on TOP (solid shape): outline of 153 points within 13.97,25.21 21.17,29.96
+VBUS2_20V on IN1 (solid shape): 14.87,25.55 14.87,23.9 15.27,23.51 15.27,22.87 15.09,22.7 14.53,22.7 14.1,23.13 14.1,25.64 14.22,25.77 14.66,25.77
+VBUS2_PD_20V on TOP (solid shape): 13.04,32.46 13.32,32.46 13.72,32.07 13.72,28.11 13.84,27.98 13.84,25.57 13.74,25.47 12.5,25.47 12.5,30.72 11.53,31.69 11.53,32.27 11.73,32.48 13.03,32.48
+VBUS2_PD_20V on TOP (solid shape): 5.97,27.56 6.94,27.56 6.96,27.54 7.69,27.54 7.71,27.56 8.26,27.56 8.57,27.24 8.57,26.6 8.65,26.52 9.44,26.52 9.89,26.07 9.89,24.55 9.8,24.45 8.38,24.45 8.13,24.7 7.83,24.7 7.77,24.76 6.96,24.76 6.9,24.7 6.03,24.7 5.96,24.63 5.67,24.63 5.46,24.83 5.46,25.08 5.68,25.3 6.02,25.3 6.22,25.1 7.58,25.1 7.81,25.33 7.81,27.05 7.62,27.24 6.15,27.24 5.95,27.04 5.63,27.04 5.48,27.19 5.48,27.5 5.65,27.66 5.87,27.66
+VBUS2_PD_20V on BOTTOM (solid shape): 20.78,18.24 20.78,17.38 20.68,17.28 19.64,17.28 19.56,17.37 19.56,18.23 19.67,18.34 20.67,18.34
+VBUS2_PD_20V on BOTTOM (solid shape): 28.02,18.81 28.02,18.23 27.81,18.02 26.83,18.02 26.77,18.07 26.77,19 26.8,19.03 27.79,19.03
+VBUS2_PD_20V on BOTTOM (solid shape): 9.18,27.69 9.18,24.73 9.07,24.62 7.4,24.62 7.28,24.75 7.28,26.65 8.38,27.75 9.11,27.75
+VBUS2_PD_20V on BOTTOM (solid shape): 60.96,21.4 60.96,20.89 60.83,20.77 60.45,20.77 59.56,19.88 58.04,19.88 57.98,19.94 57.98,20.19 58.04,20.26 58.99,20.26 60.2,21.46 60.9,21.46
+VBUS2_PD_20V on BOTTOM (solid shape): 53.73,22.8 53.83,22.7 53.83,22.16 54.03,21.97 54.93,21.97 55.29,21.61 55.29,20.5 55.24,20.46 54.99,20.46 54.86,20.33 54.86,20 54.8,19.94 54.48,19.94 54.42,20 54.42,20.32 54.28,20.46 54.02,20.46 53.98,20.5 53.98,20.77 53.72,21.02 53.34,21.02 53.24,21.11 53.24,21.14 52.86,21.52 52.84,21.52 52.73,21.63 51.67,21.63 51.32,21.97 51.32,22.71 51.41,22.8 52.01,22.8
+VBUS2_PD_20V on IN1 (solid shape): 60.39,22.66 60.39,20.51 60.01,20.13 52.24,20.13 51.24,21.12 51.24,22.68 51.44,22.88 60.17,22.88
+VBUS2_PD_20V on IN1 (solid shape): 6.02,27.57 8.31,27.57 8.59,27.29 8.59,26.66 8.7,26.55 9.42,26.55 9.89,26.07 9.89,24.55 9.78,24.44 8.39,24.44 8.08,24.75 6.08,24.75 5.97,24.63 5.76,24.63 5.61,24.78 5.55,24.89 5.46,24.98 5.46,25.13 5.63,25.3 6.05,25.3 6.21,25.14 7.58,25.14 7.78,25.34 7.78,27.08 7.61,27.25 6.18,27.25 5.97,27.04 5.59,27.04 5.46,27.17 5.46,27.32 5.6,27.5 5.66,27.72 5.87,27.72
+VBUS2_PD_20V on IN2 (solid shape): 9.6,27.07 9.6,25.05 9.25,24.69 8.25,24.69 7.94,25 7.94,26.2 7.69,26.45 7.69,27.17 7.85,27.33 9.34,27.33
+VBUS2_PD_20V on IN3 (solid shape): outline of 598 points within 6.99,16.52 53.28,33.09
+VCC_CORE on TOP (solid shape): outline of 120 points within 71.95,118.29 76.88,120.57
+VCC_CORE on TOP (solid shape): outline of 140 points within 71.12,128.59 78.76,131.38
+VCC_CORE on TOP (solid shape): outline of 289 points within 65.91,134.29 95.02,147.51
+VCC_CORE on BOTTOM (solid shape): 73.05,147.51 90.86,147.51 91.01,147.36 91.01,143.91 90.88,143.78 66.04,143.78 65.94,143.88 65.94,147.41 66.07,147.54 73.03,147.54
+VCC_CORE on BOTTOM (solid shape): 79.32,138.24 79.32,134.05 78.49,133.21 78.49,128.44 78.66,128.26 79.63,128.26 79.76,128.13 80.64,128.13 80.75,128.03 80.75,126.56 80.59,126.4 79.32,126.4 78.77,125.85 78.77,122.59 79.32,122.04 80.59,122.04 80.72,121.91 80.72,120.44 80.67,120.38 79.76,120.38 79.32,120.82 78.31,120.82 78.18,120.69 76.94,120.69 76.42,120.17 76.42,118.81 76.37,118.76 72.62,118.76 72.57,118.81 72.57,119.19 72.59,119.22 72.97,119.22 73.13,119.37 73.13,120.44 72.99,120.58 71.95,120.58 71.86,120.66 71.86,122.26 71.73,122.39 71.5,122.39 71.45,122.44 71.45,123.41 71.32,123.53 71.2,123.53 71.15,123.59 71.15,127.84 74.22,127.84 74.22,124.03 74.4,123.85 74.4,121.66 74.53,121.53 75.01,121.53 75.04,121.5 75.04,120.44 75.13,120.36 75.59,120.36 75.86,120.63 76.38,120.63 76.48,120.72 76.48,127.72 76.17,128.03 74.41,128.03 74.22,127.84 71.15,127.84 71.15,128.56 71.22,128.64 72.34,128.64 72.48,128.77 72.48,129.18 72.92,129.62 72.92,131.13 73.15,131.36 73.15,133.21 73.43,133.49 73.43,138.29 73.51,138.37 79.2,138.37
+VCC_CORE on IN1 (solid shape): outline of 587 points within 68.05,128.34 91.26,147.51
+VCC_CORE on IN2 (solid shape): 76.45,120.38 76.45,119.9 76.36,119.81 73.36,119.81 72.89,120.28 72.89,120.49 76.35,120.49
+VCC_CORE on IN2 (solid shape): 74.02,130.44 77.32,130.44 77.44,130.32 77.44,129.68 76.86,129.1 71.55,129.1 71.27,129.38 71.27,130.8 71.4,130.93 73.53,130.93
+VCC_CORE on IN3 (solid shape): outline of 776 points within 65.93,119.45 91.01,147.54
+VCC_CORE on VCC: 70.87,119.32 70.87,135.81 65.91,140.76 65.91,147.51 91,147.51 91,142.85 90.38,142.24 83.27,142.24 79.25,138.22 79.25,131.49 78.36,130.6 78.36,119.32
+VCC_GT on TOP (solid shape): outline of 799 points within 83.44,118.4 111,152.29
+VCC_GT on BOTTOM (solid shape): outline of 1330 points within 82.4,115.79 110.63,140.94
+VCC_GT on IN1 (solid shape): outline of 911 points within 86.11,112.33 92.33,115.51
+VCC_GT on IN2 (solid shape): outline of 1645 points within 86.49,114.24 95.26,129.22
+VCC_GT on IN3 (solid shape): outline of 1857 points within 83.29,119.75 109.4,147.51
+VCC_GT on VCC: 83.57,119.32 83.57,130.85 82.78,131.64 79.76,131.64 79.76,138.01 83.48,141.73 90.59,141.73 91.5,142.64 91.5,147.51 105.47,147.51 105.69,147.29 105.69,142.79 106.3,142.18 109.09,142.18 109.09,124.65 105.05,124.65 103.78,123.38 94.38,123.38 91.08,120.08 88.16,120.08 87.4,119.32
+VCC_SA on TOP (solid shape): 68.82,120.52 68.82,119.56 68.61,119.34 67.56,119.34 67.49,119.42 67.49,120.56 67.56,120.64 68.71,120.64
+VCC_SA on TOP (solid shape): 60.71,147.05 60.71,142.38 59.11,140.78 57.12,140.78 55.96,141.95 55.96,143.6 55.7,143.85 55.7,144.49 55.85,144.64 56.74,144.64 57.05,144.95 57.05,146.98 57.15,147.08 60.68,147.08
+VCC_SA on TOP (solid shape): outline of 92 points within 67.02,128.59 71.42,131.37
+VCC_SA on BOTTOM (solid shape): 69.19,135.93 70.94,135.93 71.15,135.73 71.15,130.04 70,128.89 70,120.89 69.81,120.7 68.97,120.7 68.8,120.52 68.8,119.9 68.63,119.74 68.29,119.74 68.1,119.93 68.1,123.99 68.25,124.14 68.25,129.17 67.67,129.76 67.67,135.93 67.97,136.23 68.88,136.23
+VCC_SA on IN2 (solid shape): 60.58,146.95 60.58,145.33 60.45,145.2 57.66,145.2 57.33,145.53 57.33,146.6 57.78,147.05 60.48,147.05
+VCC_SA on IN2 (solid shape): 70.54,129.91 70.54,129.45 70.23,129.15 68.99,129.15 67.92,130.21 67.92,130.95 68.43,131.46 68.99,131.46
+VCC_SA on IN3 (solid shape): outline of 493 points within 57.28,119.72 70.48,147.51
+VCC_SA on VCC: 66.42,119.32 66.42,130.98 56.13,141.27 56.13,146.45 57.19,147.51 65.41,147.51 65.41,140.55 70.36,135.6 70.36,119.32
+VCCIA_GT on TOP (solid shape): outline of 138 points within 77.52,118.17 83.3,120.64
+VCCIA_GT on TOP (solid shape): outline of 1326 points within 78.87,128.59 84.28,136.17
