# Allegro board Dell Latitude 5290 2-IN-1 LA-F371P Boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PD1_USBC_EN: length 61.9
  IN3 w0.066: v5(28.66,42.7) 28.87,42.7 29.09,42.48 41.33,42.48 42.27,41.54 44.65,41.54 45.49,42.38 v6(45.87,42.38)
  IN4 w0.066: v1(29.93,70.69) 29.81,70.56 29.81,69.85 29.69,69.73 29.69,67.47 29.89,67.27 29.89,62.85 31.39,61.35 32.02,61.35 32.12,61.44 32.88,61.44 35.77,58.56 35.77,57.68 36.21,57.23 36.21,56.34 35.62,55.75 35.62,51.47 36.49,50.61 41.24,50.61 46.13,45.72 46.13,43.09 46,42.96 46,42.51 v6(45.87,42.38)
  BOTTOM w0.112: v2(29.15,42.93) 28.92,42.7 v5(28.66,42.7) 28.29,43.07 26.84,43.07 26.8,43.11 26.8,43.11 26.71,43.2 26.71,43.2 26.63,43.28 26.62,43.28 RV66.2 RV88.2 ; RT4.1 29.65,70.41 v1(29.93,70.69)
PD1_USBC_POL: length 44
  IN3 w0.066: v6(44.99,42.74) 44.62,43.12 43.61,43.12 43.14,42.64 29.18,42.64 v5(28.57,43.25)
  IN4 w0.066: v1(34.3,58.24) 34.32,58.24 35.34,57.22 35.34,56.18 35.12,55.96 35.12,51.26 36.48,49.9 41.24,49.9 44.79,46.35 44.79,43.45 44.99,43.26 v6(44.99,42.74)
  BOTTOM w0.112: v2(34.02,57.96) v1(34.3,58.24) 34.37,58.31 34.37,58.78 RT45.2 ; RV87.2 RV65.2 27.78,43.55 27.78,43.55 27.87,43.46 28.36,43.46 v5(28.57,43.25)
PD1_VBUS_SENSE: length 75.7
  TOP w0.112: RC61.2 48.33,121.41 v3(48.2,121.27)
  IN2 w0.066: v3(48.2,121.27) 47.9,120.98 46.86,120.98 46.73,121.1 45.96,121.1 45.64,120.78 45.64,119.47 v4(44.35,118.18)
  IN3 w0.066: v7(52.7,64.84) 44.27,64.84 v5(43.26,63.82) ; v4(44.35,118.18) 44.68,117.84 v6(44.78,117.84)
  IN4 w0.066: v7(52.7,64.84) 52.7,65.82 53.81,66.92 53.81,80.01 52.21,81.6 52.21,82.22 50.76,83.67 50.76,90.71 50.47,91 50.47,99.66 49.89,100.24 49.89,103.39 48.51,104.76 48.51,111.37 49.16,112.01 49.16,114.57 47.92,115.81 47.92,116.4 46.47,117.84 v6(44.78,117.84)
PD2_AUX_N: length 15
  IN4 w0.066: v1(51.4,12.09) 51.41,12.09 51.41,11.75 51.54,11.62 51.94,11.62 52.36,11.19 52.36,10.53 52.76,10.14 54.6,10.14 54.84,10.38 54.84,11.39 53.89,12.35 53.72,12.35 v1(53.47,12.09) 53.47,12.22 53.15,12.54 53.15,13.11 53.02,13.23 52.95,13.23 52.73,13.46 52.73,14.32 54.34,15.93 54.47,15.93 v1(54.63,16.1)
  BOTTOM w0.112: CT37.2 49.96,11.63 50.94,11.63 v1(51.4,12.09)
PD2_AUX_P: length 15.4
  IN4 w0.066: v1(54.63,15.6) 54.47,15.76 54.41,15.76 52.9,14.25 52.9,13.53 53.02,13.4 53.09,13.4 53.47,13.78 v1(53.47,13.95) 53.78,13.63 53.78,12.68 55.01,11.46 55.01,10.31 54.67,9.97 52.69,9.97 52.19,10.46 52.19,11.12 51.87,11.45 51.54,11.45 51.41,11.32 v1(51.41,10.97)
  BOTTOM w0.112: CT36.2 49.9,11.42 50.97,11.42 51.41,10.98 v1(51.41,10.97)
PD2_CC1: length 4.6
  BOTTOM w0.254: CT26.1 51.69,19.8 ; 51.69,19.8 51.44,19.8 51.31,19.93 51.31,20.28 RT115.1 ; 51.69,19.8 51.69,19.86 51.98,20.16 52.68,20.16 53.24,19.6 UT2.L9 UT2.K9
PD2_CC2: length 5.3
  BOTTOM w0.254: RT116.1 49.91,21.57 50.05,21.43 51.18,21.43 CT25.1 51.69,20.77 51.94,20.51 52.83,20.51 53.24,20.1 UT2.L10 UT2.K10
PD2_DEBUG1: length 4.9
  BOTTOM w0.112: RT81.2 RT80.2 51.43,14.74 52.21,14.74 52.58,15.11 52.58,15.69 52.99,16.1 UT2.L2
PD2_DEBUG2: length 6.1
  BOTTOM w0.076: UT2.K2 53.89,15.86 53.13,15.86 53.09,15.81
  BOTTOM w0.112: RT90.2 RT89.2 51.23,13.53 51.94,13.53 52.07,13.65 52.07,14.29 52.83,15.05 52.83,15.56 53.09,15.81
PD2_DEBUG3: length 2.6
  BOTTOM w0.112: RT77.2 51.89,15.56 52.93,16.6 UT2.L3
PD2_DEBUG4: length 5.3
  IN4 w0.066: v1(50.13,15.33) 50.56,15.76 52.53,15.76 53.36,16.6 v1(54.13,16.6)
  BOTTOM w0.112: v1(50.13,15.33) 50.13,14.77 RT126.2
PD2_DEBUG_CTL1: length 10.7
  IN4 w0.066: v1(56.63,17.1) 56.63,14.17 57.4,13.4 v1(63.21,13.4)
  BOTTOM w0.112: v1(63.21,13.4) 63.21,12.6 v2(63.14,12.54)
PD2_DEBUG_CTL2: length 10.4
  IN4 w0.066: v1(57.13,17.6) 57.13,16.91 56.8,16.58 56.8,14.24 57.47,13.57 62.74,13.57 v1(63.21,14.04)
PD2_EE_CLK: length 2.2
  BOTTOM w0.112: UT2.A3 60.23,16.6 RT73.2
PD2_EE_CS#: length 5.5
  IN4 w0.066: v1(63.45,16.19) 63.04,16.6 v1(58.13,16.6)
PD2_EE_MISO: length 5.3
  BOTTOM w0.112: UT2.A4 59.25,17.72 62.94,17.72 RT69.2
PD2_EE_MOSI: length 2.5
  IN4 w0.066: v1(60.63,17.21) 60.52,17.1 v1(58.13,17.1)
PD2_GPIO0: length 2.9
  IN4 w0.066: v1(58.13,16.1) 59.71,16.1 v1(60.63,15.18)
PD2_GPIO1: length 8.5
  IN4 w0.066: v1(64.26,16.03) 63.41,15.18 v1(62.53,15.18) 62.17,15.18 61.9,14.92 58.82,14.92 v1(57.63,16.1)
  BOTTOM w0.112: v2(64.39,15.11) 64.26,15.24 v1(64.26,16.03)
PD2_GPIO2: length 8
  IN3 w0.066: v5(57.13,20.1) 57.13,22.2 v5(57.4,22.47)
  IN4 w0.066: v5(57.4,22.47) 56.88,22.99 52.81,22.99 v1(52.3,23.5)
PD2_GPIO3: length 2
  BOTTOM w0.112: UT2.G11 55.63,22.21 RT59.1
PD2_GPIO5: length 4.6
  IN3 w0.066: v5(57.4,24.37) 56.63,23.6 v5(56.63,20.1)
PD2_GPIO6: length 2.9
  IN3 w0.066: v5(54.36,22.47) 55.63,21.19 v5(55.63,20.1)
PD2_GPIO7: length 6.7
  IN4 w0.066: v1(59.44,24.37) 58.99,23.93 58.99,20.58 57.13,18.73 v1(57.13,18.6)
PD2_GPIO8: length 11
  IN4 w0.066: v1(55.13,18.1) 54.87,17.84 51.55,17.84 50.22,16.5 49.23,16.5 v1(48.13,17.59)
  BOTTOM w0.112: v1(48.13,17.59) 48.13,19.62 48.51,20 RT65.1
PD2_GPIO8_EXT: length 4.9
  BOTTOM w0.112: TC22.1 49.23,23.67 49.23,21.68 49.76,21.15 RT106.1 RT65.2 RT105.2
PD2_HWRST: length 137
  IN1 w0.066: v10(38.15,73.09) 38.23,73.17 43.46,73.17 50.19,66.44 50.19,46.04 67.41,28.82 67.41,28.16 68.37,27.19 v7(68.71,27.19)
  IN2 w0.066: v10(38.15,73.09) 38.15,73.14 38.66,73.65 38.66,77.69 39.37,78.4 39.37,85.99 41.94,88.56 41.94,103.9 38.3,107.53 38.3,120.31 39.03,121.04 39.03,122.64 39,122.67 39,125.04 v4(39.5,125.54)
  IN3 w0.066: v4(39.5,125.54) 39.37,125.67 38.23,125.67 v5(38.1,125.8)
  IN4 w0.066: v1(57.13,18.1) 57.56,18.52 57.56,18.91 58.46,19.81 59.56,19.81 v1(61.65,21.9)
  BOTTOM w0.112: v7(68.71,27.19) 68.55,27.04 64.33,27.04 63.68,26.39 v2(63.68,24.09) 63.68,23.1 62.92,22.34 62.09,22.34 v1(61.65,21.9)
PD2_LPS1: length 42.8
  TOP w0.112: PR225.2 32.91,45.62 31.61,44.32 31.61,40.92 32,40.53 v2(32,39.35) v3(32,38.17)
  TOP w0.381: v8(16.84,21.02) 17.14,21.02 17.27,21.15 PQ136.6
  IN1 w0.066: v10(15.93,31.41) 16.48,31.41 17.07,30.82 17.07,24.49 16.67,24.09 16.67,22.59 16.51,22.43 16.51,21.35 v8(16.84,21.02)
  IN2 w0.066: v4(32,37.81) v3(32,38.17) ; v4(16.33,31.46) 16.28,31.41 v10(15.93,31.41)
  IN3 w0.066: v4(16.33,31.46) 16.33,32.17 17.14,32.98 17.14,34.89 17.31,35.05 20.12,35.05 21.13,36.06 22.4,36.06 22.66,35.8 26.29,35.8 27.03,35.07 30.1,35.07 32,36.97 v4(32,37.81)
PD2_LPS2: length 29.8
  TOP w0.254: v3(33.68,37.61) 34.01,37.94 v2(35.9,37.94) 38.15,37.94 38.94,38.72 PR113.1
  IN2 w0.254: v3(33.68,37.61) 32.73,36.65 32.73,30.3 32.16,29.73 27.06,29.73 26.63,29.3 25.02,29.3 22.48,26.76 v3(21.29,26.76)
PD2_LSRX: length 5.3
  IN4 w0.066: v1(49.4,16.19) 49.66,15.93 52.46,15.93 53.29,16.77 53.8,16.77 v1(54.13,17.1)
PD2_LSTX: length 2.8
  BOTTOM w0.112: UT2.L4 53.13,17.1 52.23,16.19 v2(52.06,16.19) RT74.2
PD2_SBU1: length 9.3
  IN4 w0.066: v1(51.47,25.26) 51.62,25.11 51.78,25.11 51.93,24.96 51.93,24.33 51.5,23.9 51.5,23.17 51.19,22.86 51.19,21.54 53.17,19.55 53.17,19.32 v1(53.29,19.2)
  BOTTOM w0.076: UT2.K8 53.89,19.34 53.43,19.34 v1(53.29,19.2)
  BOTTOM w0.112: v1(51.47,25.26) 51.41,25.2 51.24,25.2 RT121.1
PD2_SBU2: length 8.9
  IN4 w0.066: v1(52.93,19.17) 53.03,19.26 53.03,19.49 51.04,21.47 51.04,22.92 51.35,23.23 51.35,23.97 51.78,24.4 51.78,24.89 51.71,24.96 51.55,24.96 v1(51.47,24.87)
  BOTTOM w0.076: UT2.L8 53.48,18.95 53.15,18.95 53.09,19.01
  BOTTOM w0.112: RT122.1 51.19,24.98 51.36,24.98 v1(51.47,24.87) ; 53.09,19.01 v1(52.93,19.17)
PD2_USBC_AMSEL: length 34.2
  IN4 w0.066: v1(24.59,19.93) 27.16,17.35 44.77,17.35 47.69,14.43 50.05,14.43 50.8,15.18 v1(50.98,15.18)
  BOTTOM w0.112: RV50.1 v1(24.59,19.93) ; RV50.1 24.59,20.94 24.05,21.47 23.42,21.47 22.82,22.07 UV2.23 ; RV50.1 25.36,21.59 v2(25.36,21.78)
PD2_USBC_EN: length 51.2
  IN3 w0.066: v5(47.82,25.45) 47.68,25.59 41.35,25.59 41.05,25.3 38.63,25.3 35.35,22.01 28.41,22.01 28.13,21.73 v5(27.56,21.73) 27.48,21.73 27.33,21.58 26.09,21.58 25.86,21.81 25.86,22.96 24.64,24.18 24.64,25.12 23.79,25.97 21.57,25.97 17.33,21.73 16.46,21.73 v5(16.04,21.31)
  BOTTOM w0.112: RV70.2 27.43,22.15 27.56,22.02 v5(27.56,21.73) v2(27.56,21.17) ; v5(47.82,25.45) 47.82,15.62 48.11,15.33 RT78.1
PD2_USBC_POL: length 73.6
  IN3 w0.066: v5(28.04,22.01) 27.36,22.01 27.1,21.76 26.24,21.76 26.06,21.93 26.06,22.99 24.81,24.25 24.81,25.19 23.86,26.14 20.02,26.14 18.69,27.46 v5(18.69,28.41) 19.57,29.29 20.31,29.29 20.45,29.14 23.71,29.14 24.23,29.66 26.89,29.66 27.28,29.28 33.86,29.28 36.42,26.71 51.03,26.71 51.44,27.12 v7(52.45,27.12)
  IN4 w0.066: v1(61.54,15.18) 61.93,15.56 63.5,15.56 63.75,15.81 63.75,16.51 62.23,18.04 62.23,22.42 58.93,25.72 53.09,25.72 52.45,26.35 v7(52.45,27.12)
  BOTTOM w0.112: v2(53.11,27.2) 53.02,27.12 v7(52.45,27.12) ; RV69.2 27.3,22.75 v5(28.04,22.01)
PD_EE_CLK: length 26.8
  IN3 w0.066: v5(34.19,62.33) 33.97,62.55 30.51,62.55 29.4,61.45 27.77,61.45 24.38,64.84 22.61,64.84 v5(20.76,66.68)
  BOTTOM w0.112: TC4.1 19.18,66.11 18.91,66.37 18.91,68.51 19.81,69.41 21.72,69.41 22.19,68.94 22.69,68.94 22.86,68.77 U22.6 22.86,67.88 22.18,67.2 21.28,67.2 v5(20.76,66.68)
PD_EE_CS#: length 11.4
  IN3 w0.066: v5(34.19,63.44) 30.21,63.44 29.83,63.06 v5(26.86,63.06)
  BOTTOM w0.076: v5(34.19,63.44) UT1.B3
  BOTTOM w0.112: v5(26.86,63.06) 26.89,63.03 RT47.2 26.31,61.6 25.53,61.6 25.4,61.72 U22.1
PD_EE_MISO: length 12.5
  IN3 w0.066: v5(26.89,61.41) 27.01,61.28 29.49,61.28 30.59,62.38 33.63,62.38 33.99,62.02 34.38,62.02 v5(34.69,62.33)
  BOTTOM w0.112: v5(26.89,61.41) 26.5,61.03 TC11.1 24.77,61.03 24.13,61.66 U22.2
PD_EE_MOSI: length 22.3
  IN3 w0.066: v5(20.76,67.13) 22.33,67.13 27.84,61.61 29.29,61.61 30.51,62.83 v5(34.69,62.83)
  BOTTOM w0.112: v5(20.76,67.13) 21.08,67.44 21.34,67.44 21.59,67.69 U22.5 21.59,68.77 21.46,68.9 19.81,68.9 19.27,68.36 TC5.1
PD_EE_WP#: length 5.3
  BOTTOM w0.112: U22.3 22.86,61.66 v2(23.59,60.93) 23.94,60.58 26.7,60.58 RT49.2
PD_HOLD#: length 2.6
  BOTTOM w0.112: RT10.2 24.82,70.5 24.56,70.25 24.56,69.34 24.13,68.91 U22.7
PECI_EC_R: length 5.3
  IN4 w0.066: v1(24.07,122.9) 23.7,122.9 23.47,122.67 23.47,122.21 23.17,121.9 v1(23.17,119.85)
  BOTTOM w0.076: UE3.K13 23.28,118.55 23.28,118.86 23.05,119.08 23.05,119.32
  BOTTOM w0.112: 23.05,119.32 23.05,119.48 23.17,119.6 v1(23.17,119.85)
PEWAKE#: length 12.5
  TOP w0.112: R57.1 61.16,86.58 R64.1 61.61,85.29 61.61,84.25 61.02,83.67 61.02,78.11 59.25,76.33 JNGFF2.54
PLL_COMP1: length 5.3
  IN4 w0.254: v1(151.15,143.96) 151.03,144.08 151.03,144.79 v1(153.62,147.39)
  BOTTOM w0.254: R95.1 153.58,147.42 v1(153.62,147.39)
PLL_VDD: length 1.6
  BOTTOM w0.254: U12.A5 150.35,144.86 150.24,144.97 C64.2
PLT_RST#: length 480.7
  TOP w0.112: Q16.2 49.68,85.51 48.69,85.51 48.39,85.82 48.39,87.09 48.13,87.34 47.19,87.34 v7(46.99,87.54)
  IN1 w0.066: v8(56.24,94.55) 55.58,93.89 54.81,93.89 52.99,92.08 52.07,92.08 47.35,87.36 47.17,87.36 v7(46.99,87.54) ; v8(58.25,75.24) 57.93,74.92 48.92,74.92 48.21,75.63 47.57,75.63 v10(47.19,75.25)
  IN2 w0.066: v3(20.63,122.17) 21.61,122.17 22.07,122.64 23.47,122.64 24,122.11 24,121.02 23.01,120.03 v4(23.01,119.14) ; v7(46.99,87.54) 46.93,87.48 46.93,86.76 47.19,86.5 v10(47.19,75.25)
  IN3 w0.066: v6(41.33,115.66) 41.2,115.79 41.2,116.31 40.7,116.81 40.7,116.84 39.79,117.76 32.68,117.76 32.56,117.63 29.6,117.63 29.51,117.73 28.57,117.73 28.31,117.99 25.16,117.99 24.84,117.66 24.26,117.66 23.19,118.73 23.19,118.96 v4(23.01,119.14) ; v5(77.05,25.22) 74.31,25.22 71.78,27.75 69.66,27.75 69.09,28.32 58.99,28.32 56.67,30.65 v7(55.35,30.65) ; v5(16.26,92.85) 17.34,92.85 18.51,94.01 18.64,94.01 18.64,94.02 20.69,94.02 21.03,93.67 28.05,93.67 28.41,94.03 34.71,94.03 34.88,93.87 39.65,93.87 42.82,90.69 v5(42.88,90.69) 43.11,90.69 46.26,87.54 v7(46.99,87.54) 47.35,87.19 v6(51.05,87.19) 51.12,87.19 51.93,86.38 53.64,86.38 54.89,85.13 71.15,85.13 73.41,82.87 77.34,82.87 v6(77.72,83.25) ; v6(53.08,50.87) 29.57,50.87 28.87,50.17 26.88,50.17 26.18,50.87 21.34,50.87 v5(21.34,50.87)
  IN4 w0.066: v1(44.88,118.24) 46.53,118.24 48.26,116.51 48.26,115.92 49.48,114.71 49.48,111.8 48.84,111.16 48.84,106.11 50.21,104.75 50.21,100.37 50.79,99.79 50.79,91.14 51.08,90.84 51.08,87.21 v6(51.05,87.19) ; v5(42.88,90.69) 42.82,90.74 42.82,94 42.98,94.15 42.98,100.99 41.71,102.25 41.71,107.72 41.04,108.4 41.04,112.35 41.33,112.64 v6(41.33,115.66) ; v1(151.55,141.16) 151.77,141.16 154.49,138.43 157.87,138.43 160.03,136.27 160.03,115.65 157.39,113 157.39,96.41 151.84,90.87 151.84,89.96 149.23,87.35 120.99,87.35 119.59,85.95 112.6,85.95 112.12,86.43 94.3,86.43 93.63,87.1 81.58,87.1 v6(77.72,83.25) ; v7(55.35,30.65) 55.35,44.88 54.66,45.57 54.66,49.28 v6(53.08,50.87) 50.07,53.87 50.07,72.9 47.24,75.73 47.24,79.63 45.37,81.5 45.37,86.8 45.89,87.31 46.76,87.31 v7(46.99,87.54)
  BOTTOM w0.112: UR1.1 66.48,31.81 66.23,31.56 66.23,30.99 65.72,30.48 60.87,30.48 60.12,31.23 55.93,31.23 v7(55.35,30.65) ; U23.1 v2(21.34,51.86) v5(21.34,50.87) ; v1(44.88,118.24) 44.39,118.24 44.37,118.25 RC152.1 43.47,118.25 43.31,118.41 43.31,119.19 43.42,119.3 UC4.4 ; U4246.17 41.02,90.23 41.36,89.88 42.16,89.88 42.88,90.59 v5(42.88,90.69) ; UE5.2 17.27,97.47 16.26,96.46 v5(16.26,92.85)
PME#: length 1.2
  TOP w0.112: UCPU1.AU11 60.08,115.31 v7(59.86,115.53)
  BOTTOM w0.112: T38.1 59.42,115.97 v7(59.86,115.53)
POA_WAKE#: length 140
  TOP w0.112: JIO1.27 132.85,89 131.85,88 125.95,88 v2(125.71,88.23) 124.93,89.02 v3(123.95,89.02)
  IN2 w0.066: v3(123.95,89.02) 123.95,89.3 124.18,89.52 v4(124.18,89.6)
  IN3 w0.066: v5(28.42,106.29) 28.42,105.73 29.51,104.64 30.68,104.64 31.31,104.01 32.25,104.01 32.38,104.14 32.88,104.14 33.51,104.76 34.27,104.76 v6(34.65,105.15) ; v6(69.66,81.36) 69.13,81.36 68.93,81.16 65.94,81.16 64.73,82.36 47.84,82.36 45.93,84.27 43.87,84.27 41.62,86.52 39.7,86.52 v6(39.47,86.3) ; v4(124.18,89.6) 124.03,89.75 123.8,89.75 v6(123.42,90.13)
  IN4 w0.066: v6(69.66,81.36) 70.03,81.72 70.03,83.23 71.19,84.39 75.15,84.39 78.99,88.23 94.1,88.23 94.48,87.84 110.42,87.84 114.35,91.78 121.72,91.78 123.37,90.13 v6(123.42,90.13) ; v6(39.47,86.3) 39.34,86.3 38.09,87.55 38.09,90.02 37.74,90.36 37.74,90.84 37.85,90.95 37.85,91.29 37.45,91.68 37.45,95.39 37.46,95.39 37.46,95.66 36.5,96.62 36.5,97.89 35.08,99.3 35.08,102.99 34.5,103.57 34.5,105 v6(34.65,105.15)
  BOTTOM w0.076: UE3.E4 26.96,111.2 26.84,111.08 26.82,111.08 26.61,110.86 26.61,109.18 26.84,108.95 26.84,108.28 27.21,107.92
  BOTTOM w0.112: 27.21,107.92 28.16,106.96 28.16,106.55 v5(28.42,106.29)
POWER_SW_IN#: length 187.8
  TOP w0.112: JIO1.22 134.05,93.43 v3(134.01,93.48) ; v3(40.96,104.29) 41.22,104.56 42.89,104.56 RE113.1 43.36,104.28 44.72,102.92 v2(44.72,102.19)
  IN1 w0.066: v3(134.01,93.48) 134.48,93.94 143.49,93.94 144.27,93.16 146.38,93.16 150,96.78 v8(150,118.19)
  IN2 w0.066: v3(134.01,93.48) 134.01,93.03 v4(133.9,92.92) ; v3(40.96,104.29) v4(40.72,104.54)
  IN3 w0.066: v6(39.42,89.41) 39.49,89.35 40.92,89.35 41.16,89.59 41.7,89.59 45.63,85.66 50.8,85.66 51.38,85.08 53.16,85.08 54.71,83.53 66.69,83.53 v6(67.75,82.47) ; v6(37.85,105.55) 38.02,105.38 39.51,105.38 39.85,105.04 40.21,105.04 v4(40.72,104.54) ; v4(133.9,92.92) v6(133.9,92.48)
  IN4 w0.066: v1(37.68,105.84) 37.85,105.68 v6(37.85,105.55) 37.75,105.45 37.75,103.64 38.27,103.12 38.27,100.54 40.29,98.51 40.29,98.15 40.28,98.14 40.28,96.3 40.1,96.12 40.1,93.77 40.2,93.67 40.2,92.9 40.1,92.8 40.1,90.88 39.47,90.24 39.47,89.51 39.42,89.46 v6(39.42,89.41) ; v6(67.75,82.47) 67.75,82.49 68.42,83.16 68.75,83.16 69.02,83.43 69.02,84.32 69.51,84.8 69.82,84.8 70.63,85.61 74.47,85.61 78.43,89.57 94.65,89.57 95.1,89.12 109.8,89.12 113.83,93.15 123.06,93.15 123.7,93.79 126.21,93.79 126.57,93.43 128,93.43 128.48,92.95 130.76,92.95 131.99,91.72 133.14,91.72 v6(133.9,92.48) ; v1(34.24,106.17) 34.24,106.44 33.56,107.11 33.07,107.11 32.19,107.99 32.19,110.8 v1(32.05,110.94)
  BOTTOM w0.076: 31.24,110.94 30.99,110.94 30.81,110.76 30.28,110.76 29.92,111.11 29.92,111.27 29.64,111.55 28.56,111.55 28.11,112 UE3.D5
  BOTTOM w0.112: v1(37.68,105.84) 37.54,105.98 37.54,106.16 CE21.1 35.32,106.75 34.99,106.41 RE27.2 34.49,106.41 v1(34.24,106.17) ; 31.24,110.94 v1(32.05,110.94)
POWER_SW_IN#_R: length 4.6
  TOP w0.112: SW3.1 42.74,104.12 43.16,103.7 RE113.2 v9(43.17,102.52) 43.17,102.1 42.54,101.47 SW3.3
PRIM_CORE_OPT_DIS: length 20.8
  TOP w0.076: 58.39,135.45 58.39,134.41 UCPU1.B9
  TOP w0.112: 58.39,135.45 58.39,136.62 57.28,137.73 RC12.1 57.28,138.08 56.83,138.52 56.83,139.49 v3(56.52,139.8)
  IN2 w0.066: v4(56.96,139.12) 56.96,139.37 56.53,139.8 v3(56.52,139.8)
  IN3 w0.066: v4(56.96,139.12) 57.33,139.12 v6(57.75,138.7)
  IN4 w0.066: v1(68.81,137.62) 68.22,138.2 65.46,138.2 65.44,138.18 63.67,138.18 63.6,138.25 60.21,138.25 59.92,138.54 57.91,138.54 v6(57.75,138.7)
  BOTTOM w0.112: U4252.1 68.67,137.21 68.81,137.35 v1(68.81,137.62)
PROCHOT#: length 5.7
  IN4 w0.066: v1(25.65,121.1) 25.65,120.69 24.82,119.85 v1(24.82,119.85)
  BOTTOM w0.076: UE3.H13 24.73,119.32
  BOTTOM w0.112: v1(25.65,121.1) 25.65,121.91 26.44,122.7 26.44,122.98 26.25,123.16 Q12.2 ; 24.73,119.32 24.73,119.55 24.82,119.64 v1(24.82,119.85)
PS_SMBCLK: length 5.3
  BOTTOM w0.112: T1.1 119.82,156.83 RS3.2 119.82,157.68 119.74,157.77 Q1.1 119.74,158.77 119.62,158.89 118.56,158.89 118.11,158.43 U1.B1
PS_SMBDAT: length 3.8
  BOTTOM w0.112: U1.A1 117.63,158.83 Q1.4 118.74,160.37 118.78,160.41 RS4.2 118.14,161.61 T4.1
PWM_CORE1: length 28.3
  IN2 w0.254: v3(82,160.98) 67.09,160.98 65.47,159.36 61,159.36 60.33,158.69 60.33,158.38 59.23,157.29 59.23,155.41 v4(58.19,154.37)
  IN3 w0.254: v5(57.71,154.37) 58.06,154.37 58.06,154.37 v4(58.19,154.37)
PWM_CORE2: length 13.4
  IN2 w0.254: v4(57.35,153.96) 57.35,155.11 58.24,156 58.24,158.84 59.8,160.4 62.18,160.4 62.79,161.01 v3(65.11,161.01)
  IN3 w0.254: v4(57.35,153.96) 57.36,153.97 v5(57.71,153.97)
PWM_FAN1: length 221.7
  TOP w0.112: R27.1 152.81,137.67 C1120.1 153.92,136.56 JFAN1.3 156.44,136.56 156.79,136.22 v7(157.36,136.22)
  IN2 w0.066: v7(157.36,136.22) 157.36,136.02 157.94,135.45 157.94,132.21 160.04,130.1 160.04,115.58 157.19,112.72 157.19,105.88 159.07,104 159.07,96.88 149.54,87.35 124.76,87.35 120.62,91.48 117.01,91.48 111.37,85.85 95.84,85.85 95.08,86.1 92.29,86.73 82.67,86.73 81.51,85.56 80.9,84.96 80.9,83.77 80.01,82.88 v4(78.96,82.88)
  IN3 w0.066: v4(78.96,82.88) 78.26,82.18 71.25,82.18 v6(70.99,81.92) ; v6(26.72,115.08) 27.18,115.54 28.91,115.54 29.4,116.03 34.58,116.03 35.66,114.95 38.78,114.95 40.03,113.7 40.03,112.88 44.68,108.23 45.67,108.23 46.16,107.74 50.81,107.74 53.49,105.06 53.68,105.06 57.79,100.94 59.76,100.94 61.88,98.82 62.6,98.82 v6(62.87,98.56)
  IN4 w0.066: v1(23.56,115.85) 23.69,115.71 25.7,115.71 26.01,115.41 26.54,115.41 26.72,115.23 v6(26.72,115.08) ; v6(62.87,98.56) 63.29,98.13 63.29,91.04 63.32,91.01 63.32,89.82 63.99,89.16 63.99,88.89 63.99,84.61 65.77,82.82 65.77,81.35 67.12,80 69.08,80 v6(70.99,81.92)
  BOTTOM w0.076: UE3.L10 22.47,116 22.75,115.72 23.25,115.72 23.37,115.85 v1(23.56,115.85)
  BOTTOM w0.112: v7(157.36,136.22) 157.33,136.22 v2(156.64,136.91)
PWM_GT: length 42.9
  IN2 w0.254: v4(58.12,152.77) 60.48,155.13 60.48,156.28 62.1,157.9 66.57,157.9 67.67,158.99 73.28,158.99 74.76,157.52 78.51,157.52 79.71,158.71 92,158.71 92.79,157.93 94.11,157.93 94.44,158.26 v3(94.65,158.26)
  IN3 w0.254: v4(58.12,152.77) 58.11,152.77 v5(57.71,152.77)
  BOTTOM w0.112: v5(57.71,152.77) 56.68,152.77 v2(56.62,152.71)
PWM_SA: length 9.5
  IN2 w0.254: v4(57.35,152.36) 54.76,152.36 53.75,153.38 53.75,156.96 54.55,157.76 v3(54.97,157.76)
  IN3 w0.254: v5(57.71,152.37) 57.38,152.37 57.38,152.36 v4(57.35,152.36)
REM_DIODE1_N: length 174.5
  IN1 w0.127: v10(123.65,94.2) 123.41,94.44 123.41,94.5 122.83,95.08 115.9,95.08 111.17,90.36 104.92,90.36 104.17,91.11 93.29,91.11 91.44,91.72 90.33,91.72 89.79,91.17 88.42,91.17 88.17,91.43 86.51,91.43 85.89,90.81 75.96,90.81 74.71,89.56 68.99,89.56 68.06,90.49 68.06,91.23 67.78,91.51 67.63,91.51 v7(67.37,91.76)
  IN2 w0.127: v7(139.5,97.51) 139.4,97.61 139.27,97.61 139.13,97.47 139.13,96.91 137.89,95.67 130.1,95.67 128.7,94.27 123.72,94.27 v10(123.65,94.2)
  IN3 w0.127: v6(31.08,109.2) 31.38,109.2 31.84,108.74 31.84,107.76 32.62,106.99 38.17,106.99 38.53,106.62 40.38,106.62 42.62,104.38 44.38,104.38 45.7,103.07 45.7,102.06 48.52,99.24 51.51,99.24 52.17,98.57 54.34,98.57 54.93,97.98 55.36,97.56 58.12,97.56 60.89,94.79 65.31,94.79 67.82,92.28 67.82,91.94 67.64,91.76 v7(67.37,91.76)
  IN4 w0.127: v6(31.08,109.2) 30.94,109.33 30.94,112.96 30.63,113.27 30.63,114.02 30.33,114.33 v1(30.33,114.37)
  BOTTOM w0.076: 31.17,115.13 30.44,114.4 UE3.A8 v1(30.33,114.37)
  BOTTOM w0.127: v7(139.5,97.51) 139.66,97.68 139.98,97.68 140.28,97.37 141.74,97.37 143.73,99.36 143.73,110.68 CE26.1 144.22,111.18 Q6.2 144.22,113.03 Q6.1 ; v7(67.37,91.76) 67.58,91.96 v11(67.58,102.88) 67.58,104.91 65.68,106.8 65.68,108.05 CE2.2 65.1,108.64 Q11.3 ; 31.17,115.13 31.58,115.55 31.6,115.55 31.65,115.6 31.65,116.62 31.8,116.77 31.8,116.94 32.21,117.35 32.97,117.35 CE27.1
REM_DIODE1_P: length 174.4
  IN1 w0.127: v7(67.36,91.11) 67.5,91.25 67.68,91.25 67.81,91.12 67.81,90.39 68.88,89.31 74.82,89.31 76.06,90.55 86,90.55 86.62,91.17 88.06,91.17 88.32,90.92 89.89,90.92 90.44,91.47 91.4,91.47 93.24,90.85 104.07,90.85 104.81,90.11 111.28,90.11 116,94.83 122.72,94.83 123.14,94.41 v10(123.14,94.2)
  IN2 w0.127: v10(123.14,94.2) 123.14,94.23 123.44,94.53 128.6,94.53 129.99,95.92 137.78,95.92 138.87,97.02 138.87,97.58 139.16,97.87 139.27,97.87 v7(139.5,98.1)
  IN3 w0.127: v6(30.63,109.49) 31.52,109.49 32.1,108.91 32.1,107.87 32.73,107.24 38.28,107.24 38.64,106.88 40.49,106.88 42.73,104.64 44.49,104.64 45.95,103.17 45.95,102.16 48.62,99.49 51.61,99.49 52.28,98.83 54.45,98.83 55.47,97.81 58.22,97.81 60.99,95.04 65.42,95.04 68.07,92.39 68.07,91.82 v7(67.36,91.11)
  IN4 w0.127: v1(30.33,113.6) 30.38,113.55 30.38,113.17 30.69,112.86 30.69,109.54 v6(30.63,109.49)
  BOTTOM w0.076: CE27.2 32.26,116.91 31.88,116.52 31.88,115.48 30.88,114.48 30.79,114.39 30.33,113.93 v1(30.33,113.6)
  BOTTOM w0.127: v7(139.5,98.1) 139.66,97.93 140.08,97.93 140.39,97.63 141.63,97.63 143.47,99.47 143.47,110.61 CE26.2 142.92,111.15 Q6.3 ; Q11.1 65.75,110.59 66.4,109.94 Q11.2 66.4,108.51 CE2.1 65.94,108.05 65.94,106.91 67.83,105.02 v11(67.83,96.95) 67.83,91.57 67.37,91.11 v7(67.36,91.11)
REM_DIODE2_N: length 161.8
  TOP w0.127: v3(20.19,17.85) 20.57,18.23 21.17,18.23 21.3,18.35 21.55,18.35 Q8.1 22.23,18.19 22.23,18.99 22.62,19.38 Q8.2 ; CE3.2 44.37,86.53 Q7.3
  IN2 w0.127: v3(44.55,87.42) 44.75,87.21 44.75,85.87 45.26,85.36 45.26,82.12 v4(45.12,81.98) 45.25,81.86 45.25,79.82 46.18,78.89 46.18,54.55 35.31,43.68 35.31,37.17 36.32,36.15 36.32,32.62 32.49,28.78 29.36,28.78 29.05,28.47 26.68,28.47 22.23,24.02 22.23,22.05 21.46,21.29 21.46,19.98 20.99,19.51 19.69,19.51 19.2,19.03 19.2,18.57 19.59,18.18 19.85,18.18 v3(20.19,17.85)
  IN3 w0.127: v6(20.92,90.65) 21.03,90.54 33.32,90.54 39.83,84.04 40.68,84.04 41.76,82.96 43.38,82.96 44.73,81.6 45,81.6 45.12,81.73 v4(45.12,81.98)
  IN4 w0.127: v6(20.92,90.65) 20.99,90.59 21.09,90.59 21.22,90.71 21.22,94.08 20.4,94.9 20.4,97.16 18.26,99.3 18.26,99.84 18.04,100.06 18.04,103.41 17.89,103.56 17.89,106.54 18.33,106.98 18.33,106.98 19.34,107.99 19.34,108.63 20.51,109.81 20.51,112.15 20.51,112.36 21.84,113.68 22,113.68 22.14,113.82 22.14,113.82 22.23,113.91 24.48,113.91 24.49,113.91 24.92,113.91 25,113.91 25.74,113.91 25.78,113.91 26.02,114.15 26.59,114.15 26.69,114.05 27.49,114.05 28.41,114.97 28.98,114.97 29.7,115.7 29.88,115.7 v1(29.92,115.74)
  BOTTOM w0.076: v1(29.92,115.74) 30.19,116 UE3.A10 30.84,116.51 30.84,117.95 30.84,117.98 31.19,118.34 31.19,118.37
  BOTTOM w0.127: CE29.1 32.9,119.2 32.01,119.2 31.19,118.37
REM_DIODE2_P: length 161.2
  TOP w0.127: v3(45.29,87.44) 45.29,86.53 Q7.2 44.83,85.69 Q7.1 ; Q8.3 21.32,18.73 21.07,18.48 20.47,18.48 v3(20.19,18.76)
  IN2 w0.127: v3(45.29,87.44) 45.01,87.16 45.01,85.97 45.52,85.46 45.52,82.12 v4(45.66,81.98) 45.5,81.82 45.5,79.93 46.43,79 46.43,54.45 35.56,43.58 35.56,37.27 36.58,36.26 36.58,32.51 32.59,28.53 29.46,28.53 29.15,28.21 26.78,28.21 22.48,23.91 22.48,21.95 21.72,21.18 21.72,19.88 21.1,19.26 19.79,19.26 19.46,18.92 19.46,18.67 19.69,18.44 19.87,18.44 v3(20.19,18.76)
  IN3 w0.127: v4(45.66,81.98) 45.66,81.79 45.21,81.35 44.63,81.35 43.27,82.7 41.65,82.7 40.57,83.78 39.72,83.78 33.22,90.29 20.94,90.29 v6(20.92,90.27)
  IN4 w0.127: v1(29.92,115.38) 29.86,115.44 29.81,115.44 29.08,114.72 28.52,114.72 27.6,113.8 26.58,113.8 26.49,113.9 26.12,113.9 25.88,113.66 25.74,113.66 25,113.66 24.92,113.65 24.59,113.65 24.59,113.65 22.34,113.65 22.25,113.56 22.24,113.56 22.1,113.43 21.94,113.43 20.77,112.25 20.77,109.7 19.59,108.53 19.59,107.88 18.15,106.44 18.15,103.66 18.29,103.52 18.29,100.17 18.52,99.95 18.52,99.4 20.65,97.27 20.65,97.03 20.65,95.01 21.47,94.19 21.47,90.61 21.19,90.33 20.99,90.33 v6(20.92,90.27)
  BOTTOM w0.076: 31.37,118.19 31.35,118.18 31.28,118.14 31.04,117.9 31.04,116.43 30.7,116.09 30.7,115.84 30.33,115.47 UE3.A9 30.1,115.2 v1(29.92,115.38)
  BOTTOM w0.127: CE29.2 31.86,118.68 31.37,118.19
REM_DIODE3_N: length 223.4
  TOP w0.127: JIO1.16 v8(135.25,93.52) ; v7(5.33,160.39) 5.99,161.05 CE1.2 6.19,162.14 Q2.3
  IN1 w0.127: v7(66.8,91.83) 66.8,91.74 66.27,91.21 66.27,90.29 68.01,88.55 75.37,88.55 76.4,89.57 86.37,89.57 86.93,90.13 90.33,90.13 90.78,90.59 91.55,90.59 94.76,89.52 100.21,89.52 100.43,89.74 102.63,89.74 103.33,89.04 111.29,89.04 116.32,94.07 121.22,94.07 121.77,93.51 124.64,93.51 125.4,94.27 129.12,94.27 131.13,92.27 134.77,92.27 135.19,92.69 135.19,93.46 v8(135.25,93.52)
  IN2 w0.127: v4(10.95,112.65) 10.86,112.56 10.86,112.08 10.44,111.66 9.3,111.66 7.66,113.31 7.66,119.56 6.39,120.83 2.53,120.83 1.14,122.22 1.14,126.76 5.02,130.64 5.02,135.34 3.98,136.38 3.98,144.42 4.85,145.29 4.85,155.26 5.61,156.02 5.61,160.11 v7(5.33,160.39)
  IN3 w0.127: v4(10.95,112.65) 10.95,112.37 11.44,111.89 12.7,111.89 14.91,109.68 19.92,109.68 20.91,108.69 21.98,108.69 22.47,108.2 23.77,108.2 24.53,107.44 25.93,107.44 26.07,107.58 27.16,107.58 27.26,107.48 28.71,107.48 28.91,107.28 29.18,107.28 29.37,107.48 29.38,107.48 30.56,108.65 30.98,108.65 v6(31,108.63) 31.03,108.65 31.21,108.65 31.33,108.53 31.33,107.55 32.41,106.48 37.96,106.48 38.32,106.11 40.17,106.11 42.44,103.85 43.98,103.85 45.06,102.77 45.06,101.98 48.31,98.73 51.29,98.73 51.96,98.06 53.91,98.06 55.21,96.76 58.06,96.76 60.54,94.28 65.1,94.28 66.1,93.28 66.1,92.2 66.47,91.83 v7(66.8,91.83)
  IN4 w0.127: v6(31,108.63) 31.05,108.59 31.2,108.59 31.45,108.83 31.45,113.17 31.14,113.48 31.14,113.53 31.02,113.65 31.02,115.6 30.98,115.64 30.98,115.93 v1(31.19,116.14)
  BOTTOM w0.076: UE3.B9 29.81,114.92 30.45,114.92 30.74,115.21 30.74,115.54 31.03,115.83 31.03,115.86 31.19,116.02 v1(31.19,116.14) 31.24,116.19 31.24,117.23 31.29,117.28 31.29,117.37 31.37,117.45
  BOTTOM w0.127: CE28.1 32.95,118.26 32.18,118.26 31.37,117.45
REM_DIODE3_P: length 222.1
  TOP w0.127: v7(5.33,161.09) 5.08,161.35 CE1.1 4.89,162.14 Q2.2 4.89,164.13 Q2.1 ; v8(134.85,93.52) JIO1.18
  IN1 w0.127: v7(66.8,91.19) 66.65,91.19 66.52,91.06 66.52,90.39 68.12,88.8 75.27,88.8 76.3,89.83 86.27,89.83 86.83,90.39 90.22,90.39 90.68,90.84 91.59,90.84 94.8,89.78 100.11,89.78 100.33,89.99 102.74,89.99 103.43,89.3 111.18,89.3 116.21,94.32 121.32,94.32 121.88,93.77 124.53,93.77 125.29,94.53 129.23,94.53 131.23,92.52 134.67,92.52 134.94,92.79 134.94,93.43 v8(134.85,93.52)
  IN2 w0.127: v4(10.42,112.65) 10.6,112.46 10.6,112.18 10.34,111.92 9.41,111.92 7.91,113.42 7.91,119.66 6.49,121.08 2.64,121.08 1.4,122.32 1.4,126.65 5.27,130.53 5.27,135.44 4.23,136.48 4.23,144.31 5.11,145.18 5.11,155.15 5.87,155.92 5.87,160.56 v7(5.33,161.09)
  IN3 w0.127: v7(66.8,91.19) 66.41,91.58 66.36,91.58 65.84,92.1 65.84,93.18 65,94.02 60.44,94.02 57.95,96.51 55.11,96.51 53.81,97.81 51.86,97.81 51.19,98.48 48.2,98.48 44.81,101.87 44.81,102.66 43.87,103.6 42.33,103.6 40.07,105.86 38.22,105.86 37.85,106.22 32.3,106.22 31.08,107.45 31.08,108.13 v6(30.94,108.27) 30.53,108.27 29.49,107.22 29.48,107.22 29.28,107.03 28.8,107.03 28.61,107.22 27.15,107.22 27.05,107.32 26.18,107.32 26.03,107.18 24.42,107.18 23.66,107.94 22.36,107.94 21.87,108.43 20.8,108.43 19.81,109.42 14.81,109.42 12.6,111.63 11.33,111.63 10.66,112.3 10.66,112.41 v4(10.42,112.65)
  IN4 w0.127: v6(30.94,108.27) 31.29,108.27 31.53,108.5 31.7,108.68 31.7,113.28 31.39,113.59 31.39,113.64 31.27,113.76 v1(31.27,115.76)
  BOTTOM w0.076: 31.55,117.27 31.5,117.21 31.5,117.2 31.44,117.15 31.44,115.93 v1(31.27,115.76) 31.27,115.61 30.95,115.29 30.95,115.13 30.53,114.71 29.84,114.71 UE3.B8
  BOTTOM w0.127: 31.55,117.27 32.08,117.79 CE28.2
RESET_IN#: length 4.7
  BOTTOM w0.076: UE3.C1 28.73,108.73 29.45,108.02
  BOTTOM w0.112: 29.45,108.02 29.97,107.5 29.97,105.82 29.99,105.8 29.99,104.98 29.95,104.94 29.95,104.92 RE250.2
RESET_OUT#_R: length 6.6
  IN3 w0.066: v5(153.21,132.1) 153,132.1 v5(150.11,134.99)
  BOTTOM w0.112: v5(150.11,134.99) RC99.2 148.31,135.9 RC100.2
RING2: length 11.7
  IN3 w1.016: 22.93,151.83 16.07,158.69 14.08,158.69
  vias: v5(13.41,159.56) v5(13.41,159.23) v5(13.41,158.89) v5(23.61,151.66) v5(23.66,151.36) v5(23.89,151.13)
RING2_CONN: length 12.3
  BOTTOM w1.016: 12.24,164.54 10.34,166.45 3.96,166.45 JP1.3
  vias: v2(12.29,163.5)
RREF: length 3.5
  BOTTOM w0.112: v2(65.76,36.15) 65.76,36.41 RR1.2
  BOTTOM w0.203: 67.06,36.13 67.56,35.63 UR1.9
  BOTTOM w0.305: RR1.2 66.43,36.76 67.06,36.13
RTC_RST#: length 128.5
  TOP w0.076: v8(61.75,119.11) 61.98,118.89 62.64,118.89 62.96,118.56 UCPU1.AM16
  TOP w0.112: CC25.2 65.56,101.64 RC89.2 CLRP1.2 65.75,103.5 65.91,103.65 65.91,104.13 66.24,104.46 66.24,105.63 65.93,105.94 63.74,105.94 v3(62.99,105.2)
  IN1 w0.066: v10(48.51,115.7) 49.74,115.7 49.87,115.83 53.02,115.83 v10(53.28,116.08) 53.51,116.32 54.15,116.32 54.78,116.95 56.15,116.95 58.4,119.19 60.07,119.19 60.29,119.41 61.58,119.41 61.75,119.24 v8(61.75,119.11)
  IN2 w0.066: v10(48.51,115.7) 48.39,115.7 47.23,116.87 v4(44.77,116.87) ; v10(53.28,116.08) 53.05,115.86 v4(52.86,115.86) ; v4(62.98,107.51) 62.98,105.21 v3(62.99,105.2)
  IN3 w0.066: v6(22.61,122.65) 22.73,122.53 24.08,122.53 24.73,123.18 28.7,123.18 29.67,122.2 31.82,122.2 32.78,121.24 36.01,121.24 37.7,119.55 40.82,119.55 43.5,116.87 v4(44.77,116.87) ; v5(62.94,107.08) 62.94,107.47 v4(62.98,107.51) 61.33,109.16 60.37,109.16 57.8,111.73 56.13,111.73 53.34,114.52 53.34,115.38 v4(52.86,115.86)
  IN4 w0.066: v7(28.96,162.08) 28.96,151.6 27.66,150.31 27.66,144.82 27.14,144.3 26.71,144.3 26.11,143.7 26.11,139.37 24.95,138.22 24.95,137.09 24.7,136.84 24.7,132.04 25.09,131.65 25.09,127.24 24.44,126.59 24.34,126.59 22.51,124.76 22.51,122.74 v6(22.61,122.65)
  BOTTOM w0.112: v9(67.07,101.25) 67.06,101.23 CC25.2 65.15,104.79 62.91,107.04 v5(62.94,107.08) ; v7(28.96,162.08) 32.68,162.08 33.14,161.61 JAPS1.10
RTCRST_ON: length 95.6
  IN3 w0.066: 27.8,100.34 27.43,99.98 27.43,98.48 27.28,98.32 v5(27.28,97.82) ; 27.8,100.34 27.8,101.14 27.24,101.7 24.78,101.7 24.51,101.97 19.15,101.97 18.31,102.81 15.98,102.81 15.67,103.11 v6(15.67,103.32) ; 27.8,100.34 28.31,100.34 29.25,99.41 29.25,98.08 29.54,97.79 30.88,97.79 31.12,98.04 31.12,98.42 32.18,99.47 38.62,99.47 39.22,98.87 41.71,98.87 46.14,94.44 49.39,94.44 51.1,92.74 56.36,92.74 57.75,91.34 57.75,91.07 58.46,90.36 v6(62.56,90.36)
  IN4 w0.066: v1(63.33,103.19) 63.27,103.19 62.92,102.84 62.92,100.53 62.92,100.09 62.06,99.24 62.06,97.51 62.56,97.02 v6(62.56,90.36) ; v6(15.67,103.32) 15.81,103.45 15.81,107.09 15.98,107.26 15.98,107.44 18.7,110.16 18.7,111.61 18.7,112.14 18.7,113.35 19.12,113.77 19.12,115.72 19.68,116.28 20.85,116.28 21.13,116.56 21.13,117.21 21.26,117.34 21.68,117.34 21.7,117.37 21.99,117.37 22.02,117.34 22.54,117.34 22.82,117.62 24.87,117.62 25.51,116.98 26.15,116.98 v1(26.33,116.8)
  BOTTOM w0.112: v1(63.33,103.19) 62.85,102.7 Q10.2
RTCRST_ON_R: length 4.3
  BOTTOM w0.112: D116.2 27.36,96.5 27.06,96.79 R5769.1 26.52,95.94 C1132.1 27.39,95.92 27.54,95.77 Q348.2
RUN_ON: length 17.1
  IN4 w0.066: v1(24.43,124.47) 24.43,124.12 24.59,123.97 24.59,123.27 24.59,123.26 24.59,122.19 24.47,122.07 v1(24.47,120.26)
  BOTTOM w0.076: 25.43,119.32 25.24,119.13 25.24,117.49 25.47,117.26 25.47,117.26 25.83,116.9 25.83,116.27 25.98,116.12 25.98,114.7 25.98,114.69 25.98,114.37 25.98,114.36 25.98,114.35 26.21,114.12 26.84,114.12 UE3.E8
  BOTTOM w0.112: 24.07,124.69 24.07,125.1 24.26,125.29 24.59,125.29 25.53,126.23 RE114.1 ; 24.07,124.69 RE17.2 23.47,124.69 23.06,125.1 RE100.1 ; 24.07,124.69 24.29,124.47 v1(24.43,124.47) ; 25.43,119.32 25.48,119.36 25.48,119.96 25.3,120.13 24.59,120.13 24.46,120.26 v1(24.47,120.26)
RUN_ON#: length 3.3
  BOTTOM w0.112: QE14.2 16.38,103.06 16.26,103.19 16.26,103.57 16.4,103.71 QE14.3 17.06,103.71 17.17,103.82 17.17,104.13 17.07,104.23 16.6,104.23 16.47,104.36 RE174.1
RUN_ON_EC: length 258.4
  IN3 w0.066: v5(21.96,124.21) 23.93,124.21 24.04,124.1 29.04,124.1 29.52,123.62 30.91,123.62 31,123.54 31.82,123.54 32.01,123.35 35.41,123.35 37.24,121.53 v5(37.95,121.53) ; v6(140.48,148.76) 137.26,148.76 v6(134.24,145.73)
  IN4 w0.066: v5(21.96,124.21) 21.96,124.66 24.14,126.84 24.14,127.07 24.62,127.55 24.62,127.55 24.77,127.7 24.77,130.73 24.23,131.27 24.23,132.05 24.3,132.11 24.3,138.01 25.79,139.51 25.79,143.84 26.58,144.62 27.01,144.62 27.34,144.96 27.34,150.81 28.02,151.48 28.02,152.92 28.55,153.46 28.55,162.3 31.76,165.52 36.7,165.52 38.22,167.03 106.09,167.03 106.2,167.14 108.78,167.14 109.35,167.71 109.35,174.87 111.23,176.76 123.2,176.76 127.44,172.51 127.44,170.43 125.94,168.92 125.94,154.76 129.59,151.1 136.19,151.1 139.07,151.1 140.48,149.7 v6(140.48,148.76) ; v6(134.24,145.73) 133.93,145.43 132.16,145.43 131.88,145.15 131.88,143.53 129.2,140.86 129.2,139.68 128.87,139.34 128.87,136.16 128.32,135.61 127.03,135.61 125.68,134.26 125.68,131.22 124.71,130.25 120.56,130.25 114.38,124.07 110.72,124.07 v1(109.98,123.33)
  BOTTOM w0.112: RE100.2 v5(21.96,124.21) ; UC5.2 37.64,119.06 37.29,119.42 37.29,120.21 37.92,120.84 RE13.2 37.92,121.43 37.95,121.45 v5(37.95,121.53) ; v1(109.98,123.33) 108.85,124.46 v2(107.77,124.46)
RUN_ON_P: length 260.5
  TOP w0.112: PR826.1 124.05,133.16 123.52,133.69 v8(123.52,134.05) ; PR826.1 124.63,133.52 124.35,133.8 124.35,134.3 124.6,134.56 U2.3 ; PR826.1 124.63,133.1 125.92,131.8 v2(125.92,131.52)
  IN1 w0.066: v8(123.52,134.05) 123.52,134.02 124.04,133.51 124.04,132.91 123.53,132.41 123.53,131.17 124.04,130.67 124.04,129.19 122.44,127.59 122.44,125.55 119.25,122.37 119.25,119 118.74,118.49 v10(117.28,118.49) ; v10(112.57,102.64) 110.39,102.64 109.55,101.8 105.33,101.8 104.51,100.98 104.51,97.54 v8(104.44,97.47)
  IN2 w0.066: v10(117.28,118.49) 116.51,119.27 116.03,119.27 115.25,118.49 115.25,106.95 112.57,104.28 v10(112.57,102.64) 112.57,100.66 111.15,99.24 106.83,99.24 105.53,97.93 105.53,94.36 106.3,93.59 106.3,91.43 106.3,91.3 102.46,87.45 93.73,87.45 93.44,87.74 81.62,87.74 79.75,85.87 79.28,85.87 79.01,85.6 v4(78.55,85.6)
  IN3 w0.066: v5(78.07,85.6) v4(78.55,85.6) 78.55,86.12 78.42,86.25 74.01,86.25 72.7,87.56 68.92,87.56 66.99,89.48 65.05,89.48 65.04,89.48 64.89,89.48 64.75,89.48 63.59,90.64 59.46,90.64 58.58,90.64 v5(58.55,90.67) 57.92,91.29 57.92,91.41 56.43,92.9 51.17,92.9 49.39,94.68 46.14,94.68 41.64,99.18 v6(40.18,99.18) 39.17,99.18 38.71,99.64 32.11,99.64 30.95,98.49 30.95,98.11 30.81,97.96 29.61,97.96 29.42,98.15 29.42,99.48 28.15,100.75 28.15,101.03 27.28,101.91 24.85,101.91 24.61,102.15 19.52,102.15 v5(18.6,103.06) ; v5(54.55,138.37) 53.19,138.37 51.1,140.45 43.05,140.45 42.19,139.58 36.66,139.58 36.24,140 v6(35.92,140)
  IN4 w0.066: v6(35.92,140) 35.92,138.94 34.9,137.93 34.9,136.03 35.46,135.47 v1(35.59,135.47) 36.07,134.99 36.07,133.01 34.51,131.45 34.51,128.32 35.1,127.73 35.1,125.08 35.46,124.73 35.46,122.75 36.1,122.1 36.1,120.9 v1(36.03,120.83) 35.83,120.63 35.83,120.23 35.98,120.07 36.01,120.07 v1(36.01,118.4) 36.04,118.37 36.04,118.19 36.14,118.09 36.14,117.44 36.62,116.96 36.62,116.13 36.14,115.66 36.14,113.88 36.93,113.1 36.93,112.98 37.33,112.58 37.33,111.03 37.2,110.9 37.2,109.2 38.35,108.05 38.35,106.52 38.43,106.44 38.43,100.7 39.95,99.18 v6(40.18,99.18)
  BOTTOM w0.112: R149.1 56.44,87 56.97,87.53 56.97,88.79 58.55,90.36 v5(58.55,90.67) ; U13.5 35.48,135.58 v1(35.59,135.47) 35.8,135.26 R117.2 ; U4255.3 69.78,84.31 R5780.2 70.36,83.83 70.89,84.37 76.83,84.37 v5(78.07,85.6) ; RE14.1 36.35,120.72 36.6,120.97 RE13.1 ; UC2.2 v5(54.55,138.37)
RUNPWROK: length 15.5
  IN4 w0.066: v1(25.53,110.4) 25.49,110.36 25.49,109.18 24.8,108.49 24.8,108.38 24.48,108.06 24.48,108.05 23.89,107.47 23.76,107.47 22.4,107.47 21.96,107.03 21.28,107.03 21.27,107.03 20.24,105.99 20.24,105.48 19.32,104.56 19.32,102.8 18.94,102.42 18.94,101.73 v1(19.05,101.61)
  BOTTOM w0.112: QE14.6 18.6,102.16 18.17,101.73 RE168.1 18.2,101.07 18.75,101.61 v1(19.05,101.61)
SAR_DPR#: length 8
  BOTTOM w0.076: 21.24,111.1 21.35,111.2 UE3.M4
  BOTTOM w0.112: 21.24,111.1 21.24,111.07 20.88,110.72 20.61,110.72 20.22,110.32 20.22,109.95 19.82,109.55 19.82,108.74 19.16,108.08 19.16,107.72 18.92,107.48 18.54,107.48 18.4,107.34 17.18,107.34 16.61,107.91 D111.1
SAR_DPR_R: length 21.9
  TOP w0.112: JNGFF1.25 26.88,113.32 27.36,112.84 27.93,112.84 28.11,112.66 R33.2 27.87,112.1 27.87,112.09 27.78,112 27.77,112 27.59,111.82 27.59,109.72 27.25,109.38 v2(27.25,109.16) 27.25,107.76 v3(26.5,107.01)
  IN2 w0.066: v4(26.64,106.34) 26.5,106.48 v3(26.5,107.01)
  IN3 w0.066: v4(26.64,106.34) 24.12,106.34 23.33,107.13 22.17,107.13 22.12,107.08 19.4,107.08 18.77,107.71 16.61,107.71 v5(16.34,107.43)
  BOTTOM w0.112: v5(16.34,107.43) 16.61,107.16 D111.2
SATA_PRX_SSDTX_N8: length 66.6
  TOP w0.076: v3(66.28,130.98) 65.96,130.98 UCPU1.G21
  TOP w0.112: JNGFF2.43 56.5,83.56 56.31,83.74 56.31,84.04 56.08,84.28 55.92,84.28 v3(55.79,84.41)
  IN2 w0.081: v3(55.79,84.41) 55.66,84.28 55.54,84.28 55.46,84.36 55.46,86.1 55.03,86.53 55.03,87.51 53.59,88.95 53.59,91.93 50.17,95.36 50.17,99.12 49.4,99.89 49.4,100.47 50.17,101.24 50.17,104.91 48.91,106.16 48.91,111.59 49.37,112.05 49.37,114.65 49.1,114.92 49.1,116.52 48.62,117 48.62,118.25 51.76,121.38 51.76,124.21 53.94,126.4 53.94,127.18 54.47,127.7 55.67,127.7 56.13,128.16 56.76,128.16 57.59,129 58.19,129 58.57,129.38 59.38,129.38 60.06,130.06 64.41,130.06 64.56,129.91 65.58,129.91 65.86,130.19 65.86,130.96 66.11,131.21 66.2,131.21 66.28,131.12 v3(66.28,130.98)
SATA_PRX_SSDTX_P8: length 66.6
  TOP w0.076: v3(66.26,131.52) 66.2,131.45 UCPU1.F21
  TOP w0.112: JNGFF2.41 56,83.54 56.1,83.63 56.1,83.95 55.99,84.06 55.83,84.06 v3(55.79,84.02)
  IN2 w0.081: v3(55.79,84.02) 55.74,84.08 55.46,84.08 55.26,84.28 55.26,86.01 54.83,86.44 54.83,87.43 53.39,88.86 53.39,91.85 49.96,95.27 49.96,99.04 49.2,99.8 49.2,100.56 49.96,101.32 49.96,104.82 48.71,106.08 48.71,111.68 49.17,112.13 49.17,114.57 48.9,114.84 48.9,116.44 48.42,116.91 48.42,118.33 51.55,121.46 51.55,124.3 53.74,126.49 53.74,127.26 54.38,127.9 55.59,127.9 56.05,128.37 56.67,128.37 57.51,129.2 58.1,129.2 58.48,129.58 59.3,129.58 59.98,130.26 64.49,130.26 64.65,130.11 65.49,130.11 65.66,130.28 65.66,131.04 66.03,131.41 66.16,131.41 v3(66.26,131.52)
SATA_PTX_SSDRX_N8: length 74
  TOP w0.076: UCPU1.D21 v3(66.06,132.51)
  TOP w0.112: CD44.1 57.69,86.08 57.69,86.42 57.48,86.63 54.89,86.63 54.76,86.76 54.49,86.76 v3(54.4,86.67)
  IN2 w0.081: v3(54.4,86.67) 54.28,86.79 53.64,86.79 52.12,88.31 52.12,92.28 49.38,95.03 49.38,98.79 48.61,99.56 48.61,100.8 49.38,101.57 49.38,104.58 48.12,105.84 48.12,108.6 47.51,109.21 45.78,109.21 43.04,111.95 43.04,116.26 44.64,117.86 47.11,117.86 50.96,121.71 50.96,124.89 53.35,127.28 53.35,127.47 54.17,128.29 54.99,129.11 55.61,129.11 56.74,130.24 57.43,130.24 57.81,130.62 58.36,130.62 58.59,130.85 64.55,130.85 65.85,132.16 66.11,132.16 66.45,132.5 66.45,132.77 66.39,132.84 66.21,132.84 66.06,132.69 v3(66.06,132.51)
SATA_PTX_SSDRX_N8_C: length 2.2
  TOP w0.112: JNGFF2.47 57.5,83.6 57.68,83.78 57.68,84.5 CD44.2
SATA_PTX_SSDRX_P8: length 74
  TOP w0.076: UCPU1.C21 66.06,133.4 v3(66.26,133.2)
  TOP w0.112: CD45.1 57.91,86.08 57.91,86.51 57.57,86.84 54.98,86.84 54.85,86.97 54.49,86.97 v3(54.4,87.05)
  IN2 w0.081: v3(66.26,133.2) 66.31,133.2 66.66,132.85 66.66,132.42 66.19,131.95 65.94,131.95 64.63,130.65 58.68,130.65 58.44,130.41 57.89,130.41 57.52,130.04 56.82,130.04 55.69,128.91 55.08,128.91 53.56,127.38 53.56,127.2 51.17,124.81 51.17,121.62 47.2,117.65 44.72,117.65 43.24,116.17 43.24,112.03 45.86,109.41 47.6,109.41 48.32,108.69 48.32,105.92 49.58,104.66 49.58,101.48 48.81,100.72 48.81,99.64 49.58,98.88 49.58,95.11 52.32,92.37 52.32,88.4 53.73,87 54.35,87 v3(54.4,87.05)
SATA_PTX_SSDRX_P8_C: length 2.2
  TOP w0.112: JNGFF2.49 58,83.67 57.9,83.77 57.9,84.48 CD45.2
SD_CD#: length 68.1
  IN2 w0.066: v4(78.04,80.01) 78.82,79.23 78.82,74.86 80.8,72.88 80.8,69.98 79.97,69.15 79.97,65.29 80.8,64.46 80.8,50.91 79.16,49.28 79.16,44.08 81.65,41.59 81.65,32.41 79.08,29.85 v7(74.1,29.85)
  IN3 w0.066: v5(68.36,30.42) 69.19,31.24 71.73,31.24 73.13,29.85 v7(74.1,29.85) ; v5(78.04,80.4) 78.04,80.4 v4(78.04,80.01)
  BOTTOM w0.112: UR1.30 v5(68.36,30.42) ; v7(74.1,29.85) v2(74.1,29.34)
SD_CLK: length 47.7
  IN2 w0.066: v4(74.12,79.97) 74.95,79.97 76.97,77.96 76.97,70.94 75.72,69.69 75.72,61.68 75.17,61.13 75.17,40.05 74.93,39.82 v4(74.93,36.57)
  IN3 w0.066: v5(74.6,36.57) v4(74.93,36.57) ; v4(74.12,79.97) 74.12,80.03 v5(73.74,80.4)
  BOTTOM w0.112: RR4.2 v5(74.6,36.57)
SD_CLK_L: length 3.1
  BOTTOM w0.112: RR4.1 72.46,36.57 71.44,35.55 71.44,34.72 71.33,34.61 UR1.17
SD_CMD: length 48.2
  IN2 w0.066: v4(71.56,80.01) 71.56,79.25 71.11,78.8 71.11,40.39 74.34,37.17 v4(74.34,37.09)
  IN3 w0.066: v5(71.94,80.4) 71.94,80.39 v4(71.56,80.01) ; v5(74.38,34.79) 74.34,34.84 v4(74.34,37.09)
  BOTTOM w0.112: RR6.2 v5(74.38,34.79)
SD_CMD_L: length 2.1
  BOTTOM w0.112: RR6.1 72.61,34.7 71.72,33.81 UR1.19
SD_D2: length 50
  IN2 w0.066: v4(70.14,80.01) 70.37,79.78 70.37,40.2 v4(73.34,37.23)
  IN3 w0.066: v5(74.38,33.01) 73.34,34.05 v4(73.34,37.23) ; v4(70.14,80.01) v5(70.14,80.4)
  BOTTOM w0.112: RR9.2 v5(74.38,33.01)
SD_D2_L: length 1.6
  BOTTOM w0.112: RR9.1 UR1.21
SD_D3: length 49
  IN2 w0.066: v4(70.89,80.01) 70.69,79.81 70.69,40.36 73.83,37.22 v4(73.83,37.09)
  IN3 w0.066: v4(70.89,80.01) 70.89,80.25 v5(71.04,80.4) ; v5(74.35,33.9) 73.83,34.42 v4(73.83,37.09)
  BOTTOM w0.112: RR8.2 v5(74.35,33.9)
SD_D3_L: length 1.8
  BOTTOM w0.112: RR8.1 72.12,33.41 UR1.20
SD_LN0_M: length 54
  IN2 w0.081: v7(79.39,63.75) 79.57,63.58 79.87,63.58 80.07,63.38 80.07,61.79 78.48,60.19 78.48,44.3 81.27,41.51 81.27,32.71 79.24,30.68 71.03,30.68 70.85,30.5 70.85,30.4 v7(71.04,30.21)
  BOTTOM w0.112: v7(71.04,30.21) 70.64,30.61 70.48,30.61 70.36,30.73 UR1.25 ; JCR1.17 74.32,66.53 74.21,66.42 74.09,66.42 73.98,66.31 73.98,66.15 74.09,66.04 75.63,66.04 76.08,65.59 76.97,65.59 79,63.56 79.2,63.56 v7(79.39,63.75)
SD_LN0_P: length 53.9
  IN2 w0.081: v7(70.46,30.21) 70.65,30.4 70.65,30.58 70.95,30.88 79.15,30.88 81.07,32.8 81.07,41.42 78.27,44.22 78.27,60.27 79.87,61.87 79.87,63.29 79.79,63.37 79.6,63.37 v7(79.39,63.17)
  BOTTOM w0.112: JCR1.16 73.41,66.53 73.53,66.42 73.65,66.42 73.76,66.31 73.76,66.06 74,65.82 75.54,65.82 75.99,65.37 76.88,65.37 78.91,63.35 79.22,63.35 v7(79.39,63.17) ; v7(70.46,30.21) 69.96,30.71 UR1.26
SD_LN1_M: length 49.8
  IN2 w0.081: v7(71.95,32.04) 72.14,32.23 72.64,32.23 73.17,31.7 79.49,31.7 80.65,32.85 80.65,41.37 77.03,44.99 77.03,55.33 77.94,56.24 77.94,61.24 78.99,62.3 78.99,64.5 79.08,64.58 79.19,64.58 v7(79.39,64.38)
  BOTTOM w0.112: UR1.23 71.45,32.21 71.54,32.3 71.69,32.3 v7(71.95,32.04) ; v7(79.39,64.38) 79.22,64.55 78.59,64.55 77.19,65.96 76.73,65.96 76.49,66.19 76.49,66.37 76.38,66.48 76.26,66.48 76.14,66.59 JCR1.19
SD_LN1_P: length 49.3
  IN2 w0.081: v7(71.95,32.63) 72.14,32.44 72.72,32.44 73.26,31.9 79.41,31.9 80.44,32.94 80.44,41.29 76.82,44.9 76.82,55.42 77.73,56.33 77.73,61.33 78.79,62.38 78.79,64.58 78.99,64.78 79.22,64.78 v7(79.39,64.96)
  BOTTOM w0.112: v7(79.39,64.96) 79.2,64.77 78.68,64.77 77.28,66.17 76.82,66.17 76.71,66.28 76.71,66.37 76.82,66.48 76.94,66.48 77.05,66.59 JCR1.20 ; UR1.22 71.47,32.61 71.56,32.51 71.83,32.51 v7(71.95,32.63)
SD_PWR_EN: length 105.1
  IN2 w0.066: v3(58.88,112.85) 58.88,112 v4(58.99,111.89)
  IN3 w0.066: v4(58.99,111.89) 59.41,111.89 v6(59.44,111.92)
  IN4 w0.066: v7(71.12,20.89) 71.42,21.2 71.42,24.37 72.76,25.71 72.76,34.74 72.59,34.92 72.59,38.13 66.04,44.68 66.04,66.69 62.19,70.53 62.19,73.74 61.61,74.33 61.61,83.26 61.31,83.56 61.31,87.36 61.47,87.52 61.47,88.4 60.77,89.11 60.77,91.71 60.36,92.12 60.36,92.67 59.63,93.39 59.63,97.93 58.07,99.49 58.07,100.69 57.83,100.93 57.83,103.97 59.23,105.36 59.23,107.78 59.57,108.12 59.57,110.75 59.8,110.98 59.8,111.59 59.48,111.92 v6(59.44,111.92)
  BOTTOM w0.112: v2(71.25,21.4) 71.12,21.27 v7(71.12,20.89) 71.25,20.77 R211.1 R210.1 72.5,20.44 72.83,20.44 73.04,20.65 UZ4.5
SD_RCLK_M: length 46.7
  IN2 w0.081: v4(76.45,80.01) 76.2,79.76 76.2,79.57 77.58,78.19 77.58,62.73 76.27,61.42 76.27,40.07 75.5,39.31 75.5,38.08 75.58,38 75.74,38 v4(75.91,38.17)
  IN3 w0.066: v4(76.45,80.01) 76.45,80.39 v5(76.44,80.4)
  IN3 w0.081: v5(74.6,38.35) 74.94,38 75.75,38 v4(75.91,38.17)
  BOTTOM w0.112: RR2.2 v5(74.6,38.35)
SD_RCLK_M_L: length 4.5
  BOTTOM w0.112: UR1.15 69.96,35.61 70.45,36.09 70.81,36.09 v11(71.05,36.33) 72.39,37.67 72.39,37.88 RR2.1
SD_RCLK_P: length 47.1
  IN2 w0.081: v4(75.7,80.02) 76,79.72 76,79.48 77.38,78.1 77.38,62.82 76.06,61.5 76.06,40.16 75.3,39.39 75.3,38 75.5,37.8 75.74,37.8 v4(75.91,37.63)
  IN3 w0.066: v4(75.7,80.02) 75.7,80.25 v5(75.54,80.4)
  IN3 w0.081: v5(74.6,37.46) 74.94,37.8 75.74,37.8 v4(75.91,37.63)
  BOTTOM w0.112: RR3.2 v5(74.6,37.46)
SD_RCLK_P_L: length 3.7
  BOTTOM w0.112: UR1.16 70.36,35.7 70.54,35.88 70.93,35.88 71.41,36.36 71.41,36.38 72.48,37.46 RR3.1
SD_RCOMP: length 3.3
  TOP w0.305: UCPU1.AB7 57.36,123.12 v7(57.34,123.1)
  BOTTOM w0.305: RC140.1 v2(56.12,122.24) 56.69,122.24 57.34,122.89 v7(57.34,123.1)
SD_REG2: length 3.2
  BOTTOM w0.112: v2(72.57,29.55) CR19.2
  BOTTOM w0.203: 71.72,31.53 71.44,31.81 UR1.24
  BOTTOM w0.254: 71.72,31.53 72.57,30.68 CR19.2
SHD_CLK: length 5.6
  BOTTOM w0.076: 19.81,114.87 20.8,114.87 21.15,114.53 21.15,114.25 21.36,114.03 21.68,114.03 21.86,113.86 22.16,113.86 22.42,114.12 23.64,114.12 UE3.J8
  BOTTOM w0.112: 19.81,114.87 19.62,114.87 T57.1
SHD_IO2: length 23.1
  IN4 w0.066: v1(25.17,119.78) 25.84,119.78 26.28,119.33 28.16,119.33 28.16,119.33 28.23,119.33 28.82,119.92 28.82,121.6 29.38,122.16 29.49,122.16 29.82,122.49 29.82,124.17 31.88,126.23 31.88,126.41 31.87,126.42 31.87,126.64 31.88,126.65 31.88,127.05 v1(30.72,128.2)
  BOTTOM w0.076: 22.33,113.6 22.69,113.96 24.24,113.96 24.38,114.11 24.38,114.46 24.61,114.69 24.62,114.69 25.01,115.08 25.01,116.12 24.96,116.18 24.96,116.63 25.01,116.68 25.01,119.32
  BOTTOM w0.112: 25.01,119.32 25.01,119.37 25.17,119.53 v1(25.17,119.78) ; RE252.1 30.71,128.2 v1(30.72,128.2)
SIO_EXT_SCI#: length 20
  TOP w0.076: v7(57.93,117.56) 57.58,117.91 UCPU1.AN7
  TOP w0.112: v3(45.22,123.36) 45.22,124.36 RC399.2 45.26,124.47 45.62,124.83 46.35,124.83 46.79,125.26 RC149.2
  IN2 w0.066: v3(45.22,123.36) 45.22,123.21 45.14,123.13 v4(45.14,122.99)
  IN3 w0.066: v7(57.93,117.56) 57.93,118.23 56.36,119.8 55.58,119.8 55.45,119.93 50.62,119.93 49.45,121.1 47.12,121.1 46.94,120.92 46.48,120.92 45.49,121.91 45.49,122.06 45.25,122.3 45.25,122.89 45.16,122.98 45.16,122.99 v4(45.14,122.99)
SIO_EXT_SMI#: length 7.1
  TOP w0.112: v2(52.15,139.04) 53.28,139.04 RC8.2 54.36,137.61 56.83,135.14 UCPU1.A6
SIO_EXT_WAKE#: length 77.3
  IN2 w0.066: 49.43,126.25 49.43,126.2 48.9,125.67 48.9,123.99 v4(47.98,123.08) ; 49.43,126.25 v3(49.43,126.3) ; 49.43,126.25 49.74,126.25 49.77,126.28 51.6,126.28 53.62,128.3 53.94,128.3 54.53,128.89 54.53,129.89 v3(54.63,129.99)
  IN3 w0.066: v4(47.98,123.08) 47.88,123.08 v6(47.69,123.27) ; v6(53.52,104.61) 53.06,104.61 50.26,107.41 45.91,107.41 45.43,107.89 44.33,107.89 39.66,112.56 39.66,113.51 38.59,114.58 35.87,114.58 35.55,114.25 34.13,114.25 33.77,113.9 33.56,113.68 33.09,113.68 32.85,113.44 30.63,113.44 29.51,112.32 29.51,112.1 28.98,111.57 28.55,111.57 28.43,111.7 28.16,111.7 27.03,110.57 26.59,110.57 26.07,111.09 26.07,113.26 25.6,113.72 25.6,114.87 25.27,115.2 v6(24.77,115.2) ; v6(23.14,114.92) 23.14,115.15 22.93,115.37 22.93,116.36 21.92,117.37 21.75,117.37 21.53,117.6 v5(21.53,117.6)
  IN4 w0.066: v6(23.14,114.92) 23.16,114.95 23.55,114.95 23.86,115.26 24.71,115.26 v6(24.77,115.2) ; v6(53.52,104.61) 53.42,104.71 53.42,104.92 51.61,106.72 51.61,109.06 51.92,109.36 51.92,109.94 51.64,110.22 51.64,115.36 50.94,116.06 50.94,116.74 50.94,116.88 50.66,117.16 50.66,117.78 49.58,118.86 49.58,120.62 47.69,122.52 v6(47.69,123.27)
SIO_PWRBTN#: length 421.5
  TOP w0.066: v8(62.78,112.51) 62.53,112.76 UCPU1.BA15
  TOP w0.112: RC127.2 62.03,98.43 62.45,98.01 v8(63.66,98.01)
  IN1 w0.066: v10(33.02,158.56) 31.94,157.48 31.94,150.67 32.07,150.54 32.07,143 29.84,140.76 v10(29.74,140.76) ; v8(62.78,112.51) 62.78,111.27 62.67,111.16 62.67,108.78 63.3,108.14 63.3,103.7 63.66,103.35 v8(63.66,98.01) 63.66,97.7 57.09,91.12 52.25,91.12 47.02,85.89 47.02,83.89 46.72,83.59 46.32,83.59 45.72,83 45.72,81.16 43.68,79.12 42.72,79.12 40.94,77.35 31.29,77.35 29.76,75.82 v7(27.2,75.82)
  IN2 w0.066: v4(16.4,76.85) 16.4,92.15 14.86,93.69 14.86,97.86 12.27,100.45 12.27,111.04 12.17,111.14 12.17,116.17 9.93,118.4 9.93,121.04 8.64,122.34 8.64,125.41 18.22,135 23.98,135 v10(29.74,140.76) ; v4(33.02,158.94) v10(33.02,158.56)
  IN3 w0.066: v7(27.2,75.82) 27.2,76.47 26.82,76.85 v4(16.4,76.85) ; v6(78.99,86.58) 78.94,86.63 74.16,86.63 72.87,87.92 69.07,87.92 67.14,89.84 64.9,89.84 63.74,91 58.86,91 56.59,93.26 51.34,93.26 49.55,95.05 46.28,95.05 41.5,99.83 32.03,99.83 31.61,99.42 30.57,99.42 30.07,99.93 29.49,99.93 v6(29.45,99.89) 29.34,99.89 28.34,100.88 28.34,101.11 27.36,102.1 24.93,102.1 24.66,102.38 19.66,102.38 18.62,103.42 18.39,103.42 18.03,103.06 16.26,103.06 v6(16.21,103.11) ; v5(33.02,159.32) v4(33.02,158.94)
  IN4 w0.066: v6(16.21,103.11) 16.17,103.15 16.17,106.56 16.79,107.18 16.79,107.75 19.06,110.01 19.06,111.75 19.06,112.13 19.06,112.63 20.19,113.76 20.19,115.38 20.47,115.66 21.59,115.66 22.21,116.29 22.48,116.29 22.49,116.3 22.5,116.3 23.04,116.84 v1(23.13,116.84) ; v6(78.99,86.58) 79.84,87.42 93.76,87.42 94.38,86.81 112.35,86.81 112.88,86.27 119.46,86.27 120.85,87.67 148.95,87.67 151.36,90.08 151.36,90.84 156.92,96.39 156.92,109.34 148.99,117.27 148.99,119.66 149.66,120.33 149.66,128.19 v1(150.19,128.72) ; v7(27.2,75.82) 27.36,75.98 27.36,76.82 26.49,77.69 26.49,79.54 25.89,80.14 24.5,80.14 23.01,81.62 23.01,88.64 23.02,88.64 23.02,88.8 23.01,88.8 23.01,89.26 23.78,90.03 25.61,90.03 26.63,91.05 27.1,91.05 28.55,92.5 28.55,93.77 29.39,94.6 29.39,99.83 v6(29.45,99.89)
  BOTTOM w0.112: v5(33.02,159.32) 33.02,159.5 32.14,160.38 JAPS1.8 ; JXDP1.41 150.89,130.3 CC36.1 v1(150.19,128.72)
