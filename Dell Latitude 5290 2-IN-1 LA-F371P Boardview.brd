# Allegro board Dell Latitude 5290 2-IN-1 LA-F371P Boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
UART_MOSI: length 70.5
  IN3 w0.066: v5(33.69,64.33) 33.35,64.67 32.54,64.67 31.35,65.86 29.35,65.86 v5(29.16,66.05) ; v5(56.13,16.1) 54.94,14.91 47.8,14.91 v6(47.24,15.46)
  IN4 w0.066: v5(33.69,64.33) 34.67,63.36 35.82,63.36 36.09,63.09 36.84,63.09 37.93,62 37.93,60.98 39.3,59.61 39.3,59.35 39.96,58.69 39.96,54.95 41.35,53.56 41.35,52.46 47.08,46.73 47.08,16.13 46.98,16.03 46.98,15.73 v6(47.24,15.46)
UF_HCLK: length 46.6
  TOP w0.112: v3(122.57,169.86) 122.57,169.75 122.41,169.59 121.95,169.59 121.95,169.59 JUFC1.11
  IN2 w0.066: v3(122.57,169.86) 122.64,169.94 122.89,169.94 v4(122.94,169.99)
  IN3 w0.066: v4(122.94,169.99) 123.19,169.99 124.56,168.62 126.64,168.62 v6(126.66,168.63)
  IN4 w0.066: v5(150.66,149.67) 149.77,150.56 143.23,150.56 141.91,151.88 141.13,152.66 130,152.66 128.13,154.54 128.13,157.46 126.55,159.03 126.55,160.61 127.2,161.27 127.2,168.09 v6(126.66,168.63)
  BOTTOM w0.112: v5(150.66,149.67) 150.66,149.2 L21.1
UF_HCLK_R: length 5.5
  IN3 w0.066: v5(150.37,148.15) 150.66,147.86 v5(150.66,147.26) 150.77,147.15 150.77,143.28 150.65,143.16 v5(150.35,143.16)
UF_I2C_CLK: length 116.9
  TOP w0.112: JUFC1.19 121.2,171.19 121.16,171.15 121.02,171.15 120.9,171.26 120.9,172.39 120.65,172.64 120.03,172.64 119.76,172.91 119.76,173.29 119.51,173.54 119.2,173.54 v3(119,173.74) 118.8,173.54 118.47,173.54 RH1.1
  IN1 w0.066: v10(113.79,145.38) 113.97,145.38 114.38,144.97 114.38,144.74 113.6,143.97 113.35,143.97 111.96,142.58 111.35,142.58 106.82,138.05 106.82,136.29 107.15,135.97 107.15,132.15 103.85,128.85 101.65,128.85 100.92,128.12 99.42,128.12 99.11,127.81 99.11,127.14 98.6,126.62 98.03,126.62 v8(97.71,126.3) 97.4,126.62 96.57,126.62 96,127.19 89.34,127.19 89.1,127.43 88.16,127.43 87.39,126.66 69.27,126.66 68.73,127.19 66.99,127.19 66.62,127.56 65.96,127.56 65.55,127.97 64.6,127.97 64.31,127.68 60.93,127.68 60.18,126.92 59.87,126.92 59.44,126.5 59.44,126.18 59.7,125.93 61.09,125.93 61.5,125.52 61.5,125.19 62.23,124.46 62.23,122.73 61.49,121.99 60.46,121.99 60.39,121.92 60.39,121.73 v8(60.61,121.51)
  IN2 w0.066: v3(119,173.74) 118.78,173.52 118.6,173.52 118.3,173.21 118.3,172.61 117.48,171.8 117.48,167.41 120.54,164.35 120.54,153.37 114.11,146.94 114.11,145.55 113.93,145.38 v10(113.79,145.38)
UF_I2C_DATA: length 116.7
  TOP w0.112: JUFC1.17 121.57,170.79 121.25,170.79 121.13,170.91 120.92,170.91 120.67,171.16 120.67,172.29 120.55,172.4 119.93,172.4 119.52,172.82 119.52,173.19 119.41,173.3 119.2,173.3 v3(119,173.1) 118.8,173.3 118.47,173.3 RH2.1
  IN1 w0.066: v8(59.96,121.51) 60.2,121.75 60.2,122 60.38,122.18 61.41,122.18 62.04,122.81 62.04,124.38 61.31,125.11 61.31,125.44 61.01,125.74 59.62,125.74 59.25,126.1 59.25,126.58 59.79,127.12 60.1,127.12 60.85,127.87 64.23,127.87 64.52,128.16 65.63,128.16 66.04,127.75 66.7,127.75 67.07,127.38 68.81,127.38 69.35,126.85 87.31,126.85 88.08,127.62 89.18,127.62 89.42,127.38 96.08,127.38 96.65,126.81 97.33,126.81 v8(97.71,127.19) 98.09,126.81 98.52,126.81 98.92,127.22 98.92,127.89 99.34,128.31 100.84,128.31 101.57,129.05 103.77,129.05 106.95,132.23 106.95,135.89 106.63,136.21 106.63,138.13 111.27,142.78 111.88,142.78 113.27,144.16 113.52,144.16 114.18,144.82 114.18,144.89 114.01,145.06 113.83,145.06 v10(113.79,145.02)
  IN2 w0.066: v3(119,173.1) 118.78,173.32 118.68,173.32 118.49,173.13 118.49,172.53 117.68,171.72 117.68,167.49 120.73,164.43 120.73,153.29 114.3,146.86 114.3,145.47 113.85,145.02 v10(113.79,145.02)
UF_SENSOR_RST#: length 47
  TOP w0.112: v3(125.6,169.67) 125.63,169.65 R3.2 R5.2 ; v7(122.37,170.44) 122.32,170.39 JUFC1.15
  IN2 w0.066: v3(125.6,169.67) 125.21,170.07 123.47,170.07 123.1,170.44 122.37,170.44 v7(122.37,170.44)
  IN3 w0.066: v6(139.13,150.41) 141.69,150.41 144.96,147.14 v5(144.96,145.73)
  IN4 w0.066: v7(122.37,170.44) 122.57,170.44 125.3,167.71 125.3,154.76 129.4,150.66 136,150.66 136,150.66 138.89,150.66 v6(139.13,150.41)
UF_SENSOR_RST#_R: length 5.1
  IN4 w0.066: 148.98,143.48 147.62,144.84 146.77,144.84 145.87,145.73 v1(145.87,145.73) ; v1(149.95,143.16) 149.3,143.16
  IN4 w0.076: 149.3,143.16 148.98,143.48
UFCAM_CSI2_CLKN0: length 77.4
  TOP w0.112: v3(116.28,169.69) 116.33,169.64 116.8,169.64 116.95,169.78 117.7,169.78 R6.1
  IN2 w0.081: v3(116.28,169.69) 115.56,169.69 115.29,169.41 115.29,168.95 115.49,168.75 115.97,168.75 116.05,168.67 116.05,168.43 115.97,168.35 115.49,168.35 115.29,168.14 115.29,166.52 116.2,165.61 117.34,165.61 119.17,163.78 119.17,154.63 112.14,147.61 112.14,143.23 109.61,140.7 93.2,140.7 91.61,139.1 85.45,139.1 84.99,139.57 80.63,139.57 76.9,135.84 76.9,135.24 76.61,134.95 76.4,134.95 75.63,134.18 75.31,134.18 75.1,133.97 75.1,133.83 75.18,133.75 75.32,133.75 v3(75.41,133.85)
UFCAM_CSI2_CLKN0_L: length 6.4
  TOP w0.112: v3(123.57,169.61) 123.69,169.49 123.85,169.49 123.95,169.59 124.22,169.59 JUFC1.12 ; v3(120.14,169.67) 119.93,169.46 119.74,169.46 119.42,169.78 119.09,169.78 119,169.86 R6.2
  IN2 w0.081: v3(120.14,169.67) 120.36,169.46 121.11,169.46 121.54,169.03 122.46,169.03 122.92,169.48 123.44,169.48 v3(123.57,169.61)
UFCAM_CSI2_CLKP0: length 77.5
  TOP w0.112: R4.1 117.7,168.93 116.82,168.93 116.71,169.04 116.71,169.29 116.58,169.42 116.4,169.42 v3(116.28,169.31)
  IN2 w0.081: v3(116.28,169.31) 116.1,169.48 115.65,169.48 115.49,169.33 115.49,169.04 115.57,168.95 116.06,168.95 116.26,168.75 116.26,168.34 116.06,168.14 115.57,168.14 115.49,168.06 115.49,166.61 116.28,165.81 117.42,165.81 119.37,163.87 119.37,154.55 112.34,147.52 112.34,143.14 109.7,140.5 93.29,140.5 91.69,138.9 85.37,138.9 84.9,139.37 80.71,139.37 77.1,135.75 77.1,135.15 76.7,134.75 76.49,134.75 75.76,134.02 75.76,133.84 75.41,133.5 v3(75.41,133.2)
UFCAM_CSI2_CLKP0_L: length 6.3
  TOP w0.112: v3(123.57,169.21) 123.63,169.27 123.78,169.27 123.86,169.19 124.22,169.19 JUFC1.10 ; R4.2 118.78,168.93 119.46,168.93 119.78,169.25 119.93,169.25 v3(120.14,169.04)
  IN2 w0.081: v3(123.57,169.21) 123.5,169.28 123,169.28 122.55,168.82 121.45,168.82 121.02,169.25 120.36,169.25 v3(120.14,169.04)
UFCAM_CSI2_DN0: length 77.5
  TOP w0.112: R1.1 117.47,171.9 117.39,171.81 117.07,171.81 116.84,171.58 v3(116.28,171.58)
  IN2 w0.081: v3(116.28,171.58) 115.54,171.58 114.7,170.74 114.7,166.01 115.92,164.78 117.33,164.78 118.58,163.54 118.58,154.88 111.43,147.73 111.43,143.53 109.19,141.29 92.93,141.29 91.36,139.71 85.73,139.71 85.29,140.16 80.15,140.16 75.91,135.92 75.91,135.34 75.03,134.46 74.94,134.46 74.85,134.55 v3(74.85,134.82)
UFCAM_CSI2_DN0_L: length 6.3
  TOP w0.112: JUFC1.18 123.86,170.79 v3(123.72,170.93) ; R1.2 119,171.9 119.09,171.81 119.46,171.81 119.78,171.5 119.94,171.5 v3(120.14,171.71)
  IN2 w0.081: v3(120.14,171.71) 120.14,171.62 120.27,171.49 123.19,171.49 123.44,171.24 123.44,171.07 123.58,170.93 v3(123.72,170.93)
UFCAM_CSI2_DN1: length 77.4
  TOP w0.112: v3(116.47,167.58) 116.53,167.52 116.91,167.52 117.07,167.69 117.39,167.69 117.53,167.83 R8.1
  IN2 w0.081: v3(75.98,133.52) 75.9,133.45 75.9,133.27 75.98,133.19 76.1,133.19 76.38,133.47 76.38,133.75 77.41,134.78 77.41,135.51 80.84,138.94 84.78,138.94 85.23,138.5 91.89,138.5 93.49,140.1 110.15,140.1 112.83,142.77 112.83,147.46 113.01,147.64 113.01,147.64 113.51,148.15 113.8,148.15 113.89,148.06 114,148.06 114.17,148.23 114.17,148.35 114.09,148.43 114.09,148.72 114.38,149.01 114.66,149.01 114.75,148.92 114.86,148.92 115.04,149.09 115.04,149.21 114.95,149.3 114.95,149.58 115.24,149.87 115.52,149.87 115.61,149.78 115.73,149.78 115.9,149.96 115.9,150.07 115.81,150.16 115.81,150.44 116.1,150.73 116.39,150.73 116.47,150.65 116.59,150.65 116.76,150.82 116.76,150.93 116.67,151.02 116.67,151.31 116.97,151.6 117.25,151.6 117.34,151.51 117.45,151.51 117.62,151.68 117.62,151.8 117.54,151.89 117.54,152.17 117.83,152.46 118.11,152.46 118.2,152.37 118.31,152.37 118.49,152.55 118.49,152.66 118.4,152.75 118.4,153.03 118.69,153.32 118.97,153.32 119.06,153.24 119.18,153.24 119.35,153.41 119.35,153.52 119.26,153.61 119.26,153.89 119.76,154.39 119.76,164.03 117.47,166.31 116.33,166.31 115.87,166.77 115.87,167.38 116.07,167.58 v3(116.47,167.58)
UFCAM_CSI2_DN1_L: length 6.4
  TOP w0.112: R8.2 118.94,167.83 119.09,167.69 119.3,167.69 119.58,167.41 119.91,167.41 v3(120.14,167.64) ; v3(123.57,168.41) 123.67,168.31 123.79,168.31 123.88,168.39 124.22,168.39 JUFC1.6
  IN2 w0.081: v3(123.57,168.41) 123.5,168.34 122.46,168.34 121.55,167.43 120.36,167.43 v3(120.14,167.64)
UFCAM_CSI2_DP0: length 77.5
  TOP w0.112: R2.1 117.7,170.96 116.95,170.96 116.78,171.13 116.78,171.26 116.68,171.36 116.47,171.36 116.3,171.2 v3(116.28,171.2)
  IN2 w0.081: v3(116.28,171.2) 116.1,171.38 115.62,171.38 114.9,170.65 114.9,166.09 116,164.99 117.42,164.99 118.78,163.62 118.78,154.79 111.63,147.64 111.63,143.45 109.27,141.09 93.02,141.09 91.44,139.51 85.65,139.51 85.2,139.96 80.23,139.96 76.11,135.83 76.11,135.26 75.11,134.26 74.94,134.26 v3(74.85,134.17)
UFCAM_CSI2_DP0_L: length 6.3
  TOP w0.112: v3(123.67,170.58) 123.86,170.39 JUFC1.16 ; v3(120.14,171.07) 119.94,171.28 119.78,171.28 119.46,170.96 119.09,170.96 119,170.88 R2.2
  IN2 w0.081: v3(123.67,170.58) 123.65,170.58 123.24,170.98 123.24,171.15 123.11,171.29 120.36,171.29 v3(120.14,171.07)
UFCAM_CSI2_DP1: length 77.5
  TOP w0.112: v3(116.47,167.2) 116.58,167.3 116.66,167.3 116.77,167.19 116.77,166.95 116.88,166.84 117.39,166.84 117.53,166.69 R7.1
  IN2 w0.081: v3(75.98,132.87) 76.09,132.98 76.18,132.98 76.58,133.38 76.58,133.67 77.61,134.7 77.61,135.43 80.92,138.74 84.69,138.74 85.14,138.29 91.97,138.29 93.57,139.89 110.24,139.89 113.03,142.69 113.03,147.37 113.21,147.55 113.21,147.55 113.6,147.94 113.71,147.94 113.8,147.86 114.08,147.86 114.38,148.15 114.38,148.43 114.29,148.52 114.29,148.63 114.46,148.81 114.58,148.81 114.66,148.72 114.95,148.72 115.24,149.01 115.24,149.29 115.15,149.38 115.15,149.5 115.32,149.67 115.44,149.67 115.53,149.58 115.81,149.58 116.1,149.87 116.1,150.16 116.01,150.24 116.01,150.36 116.19,150.53 116.3,150.53 116.39,150.44 116.67,150.44 116.96,150.74 116.96,151.02 116.88,151.11 116.88,151.22 117.05,151.39 117.16,151.39 117.25,151.31 117.54,151.31 117.83,151.6 117.83,151.88 117.74,151.97 117.74,152.08 117.91,152.26 118.03,152.26 118.12,152.17 118.4,152.17 118.69,152.46 118.69,152.74 118.6,152.83 118.6,152.95 118.78,153.12 118.89,153.12 118.98,153.03 119.26,153.03 119.55,153.32 119.55,153.61 119.47,153.7 119.47,153.81 119.96,154.3 119.96,164.11 117.56,166.51 116.42,166.51 116.08,166.85 116.08,167.29 116.16,167.37 116.29,167.37 v3(116.47,167.2)
UFCAM_CSI2_DP1_L: length 6.4
  TOP w0.112: R7.2 118.94,166.69 119.09,166.84 119.3,166.84 119.63,167.17 119.98,167.17 v3(120.14,167.01) ; v3(123.57,168.01) 123.65,168.09 123.81,168.09 123.91,167.99 124.22,167.99 JUFC1.4
  IN2 w0.081: v3(120.14,167.01) 120.36,167.22 121.63,167.22 122.55,168.14 123.44,168.14 v3(123.57,168.01)
UFCAM_LED#: length 1.6
  BOTTOM w0.112: R487.1 154.38,146.64 154.74,146.99 154.74,147.36 154.88,147.5 Q9.3
UIM_CLK: length 94.8
  IN1 w0.066: v7(24.19,77.6) 24.5,77.91 24.5,79.91 23.13,81.28 23.13,89.2 25.09,91.17 25.09,94.86 24.59,95.37 24.59,98.36 25.09,98.87 25.09,105 21.52,108.57 20.1,108.57 18.8,109.87 18.8,116.58 21.36,119.14 24.1,119.14 25.96,121.01 25.96,122.45 25.86,122.55 25.4,122.55 25.13,122.28 v8(25.13,122.17)
  IN3 w0.066: v5(56.42,69.06) 56.1,68.74 54.07,68.74 52.23,70.58 48.67,70.58 42.78,76.47 v5(41.91,76.47) 36.88,76.47 35.75,77.6 v7(24.19,77.6)
  BOTTOM w0.112: C137.2 41.91,76.44 v5(41.91,76.47) 41.92,76.46 D64.2 ; v7(24.19,77.6) v2(23.78,77.19)
UIM_DATA: length 96.2
  IN1 w0.066: v7(23.43,78.16) 23.43,80.08 22.49,81.02 22.49,89.47 24.45,91.43 24.45,94.6 23.95,95.1 23.95,98.63 24.45,99.13 24.45,104.74 21.26,107.93 19.83,107.93 18.16,109.61 18.16,116.84 21.09,119.78 23.83,119.78 24.63,120.58 v8(24.63,122.17)
  IN3 w0.066: v5(56.42,70.16) 55.09,71.49 49.59,71.49 43.66,77.42 43.66,79.28 v5(42.93,80.02) 42.04,80.02 40.01,77.99 36.25,77.99 35.71,78.54 23.82,78.54 v7(23.43,78.16)
  BOTTOM w0.112: v7(23.43,78.16) v2(22.82,78.16) ; R154.2 C135.2 C134.1 42.92,80.02 v5(42.93,80.02)
UIM_DET: length 87
  IN1 w0.066: v10(17.81,123.38) 17.89,123.3 17.89,121.9 18.09,121.69 18.09,119.16 16.47,117.54 16.47,108.91 19.13,106.25 20.56,106.25 22.44,104.37 22.44,91.38 21.15,90.09 21.15,80.24 v7(21.72,79.67)
  IN2 w0.066: v4(17.42,123.2) 17.55,123.33 17.65,123.33 17.7,123.38 v10(17.81,123.38)
  IN3 w0.066: v5(53.86,80.88) 53.01,80.02 v5(45.21,80.02) 43.77,81.46 36.71,81.46 34.91,79.67 v7(21.72,79.67) ; v5(17.98,123.59) 17.81,123.59 v4(17.42,123.2)
  BOTTOM w0.112: v5(45.21,80.02) 46.22,80.02 D62.2 ; v7(21.72,79.67) 21.26,79.67 v2(21.12,79.81) ; R122.2 18.73,123.88 18.24,123.88 17.98,123.62 v5(17.98,123.59)
UIM_DET#: length 4.2
  TOP w0.112: v3(16.94,123.33) 16.94,123.24 16.63,122.93 JNGFF1.66
  IN2 w0.066: v3(16.94,123.33) 17.07,123.33 17.28,123.54 17.31,123.54 18.7,124.94 v4(18.7,125.01)
  IN3 w0.066: v5(19.03,125.26) 18.96,125.19 18.95,125.19 18.78,125.01 v4(18.7,125.01)
UIM_RESET: length 89.8
  IN1 w0.066: v7(24,78.17) 24,79.96 22.81,81.15 22.81,89.34 24.77,91.3 24.77,94.73 24.27,95.23 24.27,98.5 24.77,99 24.77,104.87 21.39,108.25 19.96,108.25 18.48,109.74 18.48,116.71 21.23,119.46 23.96,119.46 25.63,121.13 v8(25.63,122.17)
  IN3 w0.066: v5(54.23,69.06) 52.39,70.9 49.26,70.9 v5(41.91,78.25) 40.72,78.25 40.14,77.67 36.12,77.67 35.63,78.17 v7(24,78.17)
  BOTTOM w0.112: D65.2 42.92,78.25 v5(41.91,78.25) ; v7(24,78.17) 24.28,78.17 v2(24.47,78.36)
UPD1_HPD: length 15.4
  IN4 w0.066: v1(18.89,104.16) 18.63,104.42 18.63,105.16 19.05,105.59 19.05,106.64 20.29,107.89 20.29,108.42 20.95,109.08 21.49,109.08 21.79,109.38 21.79,110.1 21.43,110.46 21.43,112.24 22.07,112.88 22.64,112.88 v1(22.71,112.95)
  BOTTOM w0.076: v1(22.71,112.95) 22.71,113.43 22.89,113.6 23.13,113.6
  BOTTOM w0.112: RE258.1 19.62,101.84 19.62,102.43 19.55,102.43 19.11,102.86 19.11,103.93 v1(18.89,104.16)
UPD1_HPD_R: length 1.2
  BOTTOM w0.112: R475.1 19.62,104.48 D105.2
UPD1_PS_SMBCLK: length 323.1
  TOP w0.112: v3(33.41,38.86) v2(32.72,38.17) 32.33,37.78 QC2.6 30.81,38.59 RV91.2
  IN2 w0.066: v4(82.99,71.62) 83.16,71.79 83.39,71.79 84.24,72.65 84.24,78.91 81.41,81.74 79.59,81.74 77.8,83.53 77.8,85.52 79.01,86.73 79.73,86.73 81.35,88.35 93.7,88.35 93.98,88.07 99.67,88.07 100.31,88.71 102.49,88.71 105.09,91.31 105.09,92.55 105.21,92.67 105.38,92.67 v4(105.57,92.48) ; v3(33.41,38.86) 33.41,39.73 34.79,41.1 34.79,44.55 36.39,46.15 36.39,49.28 38.86,51.76 38.86,55.39 36.4,57.86 36.4,58.61 37.09,59.29 37.09,60.07 36.93,60.23 36.55,60.23 v4(36.39,60.39) 36.26,60.26 36.1,60.26 36.04,60.33 36.04,60.74 37.02,61.72 38.2,61.72 42.09,65.61 42.09,67.95 v4(42.26,68.12)
  IN3 w0.066: v4(105.57,92.48) 105.7,92.62 106.35,92.62 v6(106.44,92.52) ; v6(14.61,104.48) 14.66,104.42 18.61,104.42 19.67,105.49 26.01,105.49 26.18,105.32 27.4,105.32 29.43,103.29 v6(30.28,103.29) ; v4(36.39,60.39) 36.28,60.29 v5(35.69,60.29) ; v4(82.99,71.62) 82.51,72.11 79.85,72.11 77.53,69.79 77.53,67.9 76.4,66.77 73.22,66.77 72.85,67.13 44.12,67.13 42.61,68.65 42.25,68.65 42.09,68.48 42.09,68.29 v4(42.26,68.12) 42.09,67.95 42.09,67.64 41.91,67.46 41.6,67.46 40.42,68.64 40.42,70.07 38.27,72.22 27.93,72.22 27.72,72.02 27.72,71.24 v5(28.12,70.84)
  IN4 w0.066: v5(28.12,70.84) 27.73,71.24 27.73,72.82 27.14,73.41 26.63,73.41 24.9,75.13 24.9,75.62 17.8,82.72 17.8,89.57 18.33,90.1 18.33,93.07 16.36,95.04 16.36,95.21 14.25,97.32 14.25,103.57 14.71,104.03 14.71,104.37 v6(14.61,104.48) ; v1(119.74,160.05) 119.32,159.34 119.34,159.25 119.42,159.2 120.27,158.35 120.27,154.5 122.91,151.86 122.91,145.43 128.7,139.63 128.7,136.23 128.25,135.77 126.96,135.77 125.51,134.33 125.51,131.29 124.64,130.42 120.49,130.42 114.31,124.23 108.1,124.23 107.78,124.55 104.6,124.55 102.36,122.32 102.36,121.78 101,120.42 101,117.9 103.37,115.52 104.36,115.52 110.21,109.67 110.21,103.67 110.6,103.28 110.6,100.09 107.26,96.75 107.26,95.63 107.8,95.09 107.8,93.29 107.12,92.61 106.53,92.61 v6(106.44,92.52) ; v1(30.29,104.69) 30.28,104.67 v6(30.28,103.29)
  BOTTOM w0.076: UE3.C3 29.22,109.91 29.22,108.7 29.42,108.5 29.61,108.5 30.09,108.02
  BOTTOM w0.112: 30.09,108.02 30.64,107.47 30.64,105.06 30.29,104.71 v1(30.29,104.69) ; RT5.1 28.5,70.65 28.31,70.84 v5(28.12,70.84)
UPD1_PS_SMBDAT: length 333.1
  TOP w0.112: QC2.3 30.18,36.48 RV92.2 30.86,35.45 30.86,34.74 v2(30.94,34.66) 31.11,34.48 31.75,34.48 32.13,34.86 32.13,36.9 v3(33.24,38)
  IN2 w0.066: v4(105.57,93.02) 105.42,92.86 105.13,92.86 104.9,92.63 104.9,91.39 102.41,88.9 100.23,88.9 99.59,88.26 94.06,88.26 93.78,88.55 81.27,88.55 79.9,87.17 79.65,86.92 78.93,86.92 77.61,85.6 77.61,83.48 79.52,81.57 81.34,81.57 84.07,78.84 84.07,72.73 83.33,71.99 83.16,71.99 v4(82.99,72.16) ; v4(41.72,68.12) 41.89,67.95 41.89,65.69 38.12,61.91 36.94,61.91 35.84,60.82 35.84,60.25 36.02,60.07 36.13,60.07 v4(36.39,59.82) 36.6,60.04 36.85,60.04 36.89,59.99 36.89,59.37 36.21,58.69 36.21,57.78 38.67,55.31 38.67,51.84 36.19,49.36 36.19,46.23 34.59,44.63 34.59,41.37 33.1,39.87 33.1,38.14 v3(33.24,38)
  IN3 w0.066: v4(105.57,93.02) 105.78,92.81 106.35,92.81 v6(106.44,92.9) ; v5(27.18,70.84) 27.56,71.22 27.56,72.09 27.88,72.41 38.32,72.41 40.59,70.14 40.59,68.71 41.65,67.65 41.83,67.65 41.89,67.72 41.89,67.95 v4(41.72,68.12) 41.89,68.29 41.89,68.56 42.17,68.84 42.69,68.84 44.2,67.33 72.93,67.33 73.3,66.96 76.35,66.96 77.31,67.92 77.31,69.81 79.88,72.38 82.77,72.38 v4(82.99,72.16) ; v5(35.12,60.29) 35.46,59.95 36.26,59.95 v4(36.39,59.82) ; v6(30.56,103.06) 30.52,103.03 29.45,103.03 27.33,105.15 26.11,105.15 25.94,105.32 19.74,105.32 18.45,104.03 14.51,104.03 v6(14.42,104.12)
  IN4 w0.066: v5(27.18,70.84) 27.56,71.23 27.56,72.75 27.09,73.22 26.58,73.22 24.71,75.09 24.71,75.53 17.63,82.62 17.63,89.67 18.13,90.18 18.13,93.01 16.15,94.98 16.15,95.14 14.07,97.22 14.07,103.77 v6(14.42,104.12) ; v1(27.49,110.79) 27.49,110.64 27.82,110.31 27.82,109.71 27.98,109.55 27.98,108.76 27.85,108.63 27.85,106.17 29.04,104.98 30.37,104.98 30.71,104.64 v1(30.71,104.56) 30.56,104.41 v6(30.56,103.06) ; v6(106.44,92.9) 106.54,92.8 107.04,92.8 107.6,93.37 107.6,95.01 107.07,95.55 107.07,96.83 110.41,100.17 110.41,103.2 110.02,103.59 110.02,109.59 109.32,110.28 104.28,115.33 103.29,115.33 101.91,116.71 100.8,117.82 100.8,120.5 102.17,121.86 102.17,122.4 104.52,124.74 107.86,124.74 108.18,124.43 114.26,124.43 120.45,130.61 124.6,130.61 125.32,131.33 125.32,134.41 126.88,135.97 128.17,135.97 128.51,136.31 128.51,139.55 122.72,145.35 122.72,151.78 120.08,154.42 120.08,158.27 119.3,159.04 119.25,159.08 119.15,159.06 v1(118.74,158.35)
  BOTTOM w0.076: v1(27.49,110.79) 27.61,110.91 29.24,110.91 UE3.B4
  BOTTOM w0.112: v5(27.18,70.84) 27.09,70.84 RT8.1
UPD1_SMBINT#: length 84.6
  IN3 w0.066: v5(37.21,60.1) 37.21,60.68 38.76,62.23 40.32,62.23 41.64,60.92 46.4,60.92 v6(46.55,60.77)
  IN4 w0.066: v6(46.55,60.77) 46.55,68.22 42.52,72.25 42.52,78.18 42.19,78.51 42.19,81.94 41.92,82.22 41.92,83.07 37.75,87.23 37.75,89.81 37.4,90.17 37.4,90.42 37.06,90.75 37.06,91.42 37.12,91.47 37.12,95.53 36.16,96.48 36.16,97.68 34.75,99.1 34.75,102.13 34,102.87 34,105.74 33.47,106.27 32.66,106.27 31.83,107.1 31.43,107.1 30.04,108.49 30.04,111.56 29.73,111.87 29.73,114.57 29.95,114.78 30.17,114.78 30.52,115.13 30.52,115.26 30.52,115.98 29.83,116.67 28.59,116.67 28.57,116.66 28.34,116.66 28.14,116.45 28.14,116.44 27.43,115.74 26.94,115.74 26.87,115.81 26.52,115.81 v1(26.33,116)
  BOTTOM w0.076: v1(26.33,116) 26.04,116.29 26.04,119.01 26.12,119.08 26.12,119.32
  BOTTOM w0.112: 26.12,119.32 26.12,119.6 26.97,120.46 RE20.1
UPD2_HPD: length 15.8
  IN3 w0.066: v5(32.12,103.75) 31.34,103.75 30.61,104.47 29.43,104.47 27.33,106.58 26.88,106.58 26.78,106.68 26.5,106.68 26.33,106.51 24.19,106.51 23.4,107.3 22.1,107.3 21.72,107.67 v5(21.27,107.67)
  BOTTOM w0.076: UE3.M1 21.53,108.59 21.84,108.27 21.84,108.08 21.53,107.76 21.49,107.76 21.4,107.67 v5(21.27,107.67)
  BOTTOM w0.112: v5(32.12,103.75) 32.41,103.75 32.69,104.03 RE259.1 32.69,104.64 R476.2
UPD2_HPD_R: length 3.8
  BOTTOM w0.112: D106.2 35.33,104.46 v2(35.14,104.65) 34.95,104.84 R476.1
UPD2_SMBINT#: length 122
  IN3 w0.066: v5(28.29,111.43) 28.43,111.3 29.45,111.3 31.25,113.11 32.99,113.11 33.23,113.35 34.19,113.35 v5(34.33,113.49) 34.34,113.5 34.34,113.6 34.52,113.78 38.38,113.78 39.04,113.12 39.04,112.47 40.88,110.63 40.88,109.71 41.55,109.03 41.78,109.03 v6(42.52,108.29)
  IN4 w0.066: v1(64.39,21.91) 64.64,22.16 64.64,25.57 56.11,34.1 56.11,45.52 55.65,45.98 55.65,50 51.31,54.35 51.31,66.37 52.86,67.92 52.86,79.61 51.27,81.21 51.27,81.75 49.81,83.2 49.81,86.98 47.95,88.85 47.03,88.85 46.26,89.61 45.32,89.61 44.58,90.36 44.58,92.95 44.87,93.24 44.87,95.59 44.58,95.89 44.58,100.97 42.4,103.14 42.4,108.18 v6(42.52,108.29)
  BOTTOM w0.076: v5(28.29,111.43) 28.24,111.49 27.81,111.49 27.69,111.37 27.43,111.37 27.31,111.49 27.25,111.49 26.88,111.49 26.36,112 UE3.F5
  BOTTOM w0.112: v5(34.33,113.49) 34.26,113.55 RE52.1 ; RT61.1 63,20.52 v2(63.73,21.25) v1(64.39,21.91)
UPD2_USH_SMBCLK: length 472.4
  TOP w0.112: QC3.6 28.01,25.36 RV93.2 28.41,24.66 28.73,24.35 29.26,24.35 29.97,25.06 30.4,25.06 30.96,25.62 31.18,25.62 32.98,27.42 33.59,27.42 34.02,27.85 34.67,27.85 v3(34.72,27.8) ; v3(127.29,95.11) 127.29,94.92 127.69,94.52 127.69,94.01 C221.1 127.8,93.74 127.8,93.21 127.89,93.12 127.89,90.24 v2(128.11,90.02) 128.94,89.19 130.81,89.19 131.25,89.63 JIO1.35
  IN1 w0.066: v10(128.69,154.33) 128.78,154.25 128.78,152.89 132.83,148.84 132.83,145.16 v7(132.62,144.95)
  IN2 w0.066: v10(128.69,154.33) 128.79,154.42 128.79,155.32 128.86,155.39 128.86,171.03 126.2,173.69 124.54,173.69 123.85,174.37 116.46,174.37 114.11,172.02 114.11,169.65 110.92,166.46 54.03,166.46 53.46,165.89 42.97,165.89 37.4,160.32 37.4,150.72 23.39,136.7 16.64,136.7 5.86,125.92 v7(5.86,125.65) ; v4(34.32,27.98) 34.54,27.98 v3(34.72,27.8) ; v7(129.45,128.69) 129.65,128.49 129.65,120.15 130.16,119.64 130.16,117.12 129.92,116.88 124.64,116.88 122.87,115.11 122.87,106.33 122.3,105.76 122.3,102.05 121.79,101.54 119.99,101.54 119.67,101.22 119.67,97.14 120.48,96.33 127.03,96.33 127.38,95.97 127.38,95.2 v3(127.29,95.11)
  IN3 w0.066: v5(63.03,19.24) 63.03,18.9 62.96,18.83 61.63,18.83 59.27,16.48 59.27,15.39 59.44,15.22 59.44,12.6 59.23,12.38 56.58,12.38 55.82,13.15 54.38,13.15 53.87,13.65 52.02,13.65 v5(51.64,14.04) ; v4(34.32,27.98) 34.59,27.98 36.77,25.8 40.81,25.8 41.16,26.15 51.13,26.15 51.73,26.75 52.85,26.75 53.37,27.27 v6(53.37,27.5) ; v7(5.86,125.65) 5.86,125.68 6.18,126 6.39,126 8.51,123.88 8.51,112.41 11.43,109.49 12.02,109.49 14.35,107.16 15.86,107.16 16.01,107 18.77,107 19.19,106.57 22.37,106.57 23.27,105.67 26.07,105.67 26.25,105.49 27.47,105.49 29.16,103.8 30.33,103.8 31.15,102.98 32.67,102.98 33.16,103.47 33.68,103.98 33.68,103.98 34.88,103.98 v6(35.53,104.64) 35.67,104.77 36.9,104.77 37.36,104.32 39.25,104.32 v6(40.21,103.36) ; v5(32.13,114.62) 32.13,114.54 32,114.42 30.28,114.42 29.89,114.03 29.77,113.91 29.46,113.6 v5(27.93,113.6)
  IN4 w0.066: v5(32.13,114.62) 34.55,112.2 34.99,112.2 35.23,111.96 35.23,107.99 35.76,107.46 35.76,107.42 35.76,107.42 35.76,107.28 35.76,104.86 v6(35.53,104.64) ; v6(40.21,103.36) 40.21,101.92 41.02,101.11 41.02,100.35 41.75,99.62 41.75,95.61 41.61,95.47 41.61,94.86 41.71,94.76 41.71,87.63 41.76,87.58 41.76,87.54 44.66,84.65 44.66,81.94 44.27,81.55 44.27,79.31 44.25,79.29 44.25,76.51 45.02,75.74 45.02,74.35 48.59,70.78 48.59,53.26 53.04,48.81 53.04,27.82 v6(53.37,27.5) 53.37,27.43 54.63,26.17 59.11,26.17 62.92,22.36 62.92,20.93 63.56,20.3 63.56,18.86 63.49,18.8 63.12,18.8 63.03,18.89 v5(63.03,19.24) ; v7(132.62,144.95) 132.82,144.75 132.82,143.84 129.65,140.68 129.65,128.89 v7(129.45,128.69)
  BOTTOM w0.076: RE70.1 32.51,115.51 32.13,115.13 v5(32.13,114.62)
UPD2_USH_SMBDAT: length 470.6
  TOP w0.112: QC3.3 29.32,27.13 29.12,27.33 RV94.2 29.77,28.01 30.35,27.42 31.11,27.42 31.45,27.75 31.45,28.31 31.6,28.46 32.84,28.46 v3(33.3,28.01) ; JIO1.37 130.85,89.54 130.76,89.45 129.13,89.45 128.13,90.45 128.13,93.22 128.04,93.31 128.04,93.74 C220.1 128.07,94.09 128.07,94.71 v3(127.67,95.11)
  IN1 w0.066: v10(129.08,154.33) 128.97,154.22 128.97,152.97 133.02,148.92 133.02,145.14 v7(133.21,144.95)
  IN2 w0.066: v7(130.03,128.69) 130.03,128.69 129.84,128.51 129.84,120.23 130.35,119.72 130.35,117.04 130,116.69 124.72,116.69 123.07,115.03 123.07,106.25 122.49,105.68 122.49,101.97 121.87,101.35 120.07,101.35 119.86,101.14 119.86,97.22 120.56,96.52 127.11,96.52 127.58,96.05 127.58,95.2 v3(127.67,95.11) ; v7(5.45,126.06) 5.73,126.06 16.56,136.9 23.31,136.9 33.88,147.47 37.21,150.8 37.21,160.4 42.89,166.08 53.38,166.08 53.93,166.63 110.82,166.63 113.92,169.73 113.92,172.1 116.38,174.57 123.93,174.57 124.62,173.88 126.28,173.88 129.05,171.11 129.05,155.31 128.98,155.24 128.98,154.4 129.05,154.33 v10(129.08,154.33) ; v3(33.3,28.01) v4(33.71,28.01)
  IN3 w0.066: v6(53.72,27.47) 53.72,27.34 52.96,26.59 51.82,26.59 51.18,25.95 41.21,25.95 40.9,25.63 36.56,25.63 34.7,27.5 34.21,27.5 v4(33.71,28.01) ; v5(51.64,13.02) 52.08,13.46 53.79,13.46 54.3,12.95 55.74,12.95 56.5,12.19 59.31,12.19 59.63,12.52 59.63,15.3 59.47,15.47 59.47,16.4 61.71,18.64 62.96,18.64 63.03,18.57 v5(63.03,18.23) ; v7(5.45,126.06) 5.73,126.06 5.83,126.17 6.46,126.17 8.7,123.93 8.7,112.45 11.49,109.67 12.08,109.67 14.42,107.33 15.79,107.33 15.93,107.33 16.08,107.17 18.83,107.17 19.26,106.74 22.44,106.74 23.34,105.84 26.14,105.84 26.32,105.66 27.54,105.66 29.23,103.97 30.4,103.97 31.22,103.15 32.6,103.15 33.09,103.63 33.61,104.15 33.61,104.15 34.63,104.15 v6(35.5,105.02) 35.58,104.94 36.97,104.94 37.43,104.48 39.48,104.48 v6(40.2,103.77)
  IN4 w0.066: v7(130.03,128.69) 129.84,128.88 129.84,140.6 133.01,143.76 133.01,144.75 v7(133.21,144.95) ; v6(40.2,103.77) 40.62,103.34 40.62,101.97 41.2,101.39 41.2,100.45 41.92,99.72 41.92,95.54 41.78,95.4 41.78,94.93 41.88,94.83 41.88,87.7 44.82,84.75 44.82,82.01 44.82,81.83 44.44,81.45 44.44,79.25 44.42,79.22 44.42,76.62 45.21,75.82 45.21,74.43 48.79,70.86 48.79,53.34 53.23,48.89 53.23,28.01 53.72,27.52 v6(53.72,27.47) 53.72,27.34 54.7,26.36 59.19,26.36 63.12,22.44 63.12,21.01 63.75,20.38 63.75,18.78 63.57,18.6 63.41,18.6 v5(63.03,18.23) ; v6(35.5,105.02) 35.59,105.11 35.59,107.39 35.06,107.92 35.06,111.89 34.92,112.03 34.42,112.03 32.84,113.6 v1(32.64,113.6)
  BOTTOM w0.076: v1(32.64,113.6) 32.26,113.22 31.37,113.22 30.73,112.59 30.52,112.59 30.45,112.52 30.21,112.52 30.14,112.59 30.1,112.59 29.81,112.87 29.81,112.92 29.65,113.09 29.6,113.09 29.37,113.32 27.46,113.32 27.33,113.45 27.28,113.45 27.13,113.6
USB3RN1: length 147.1
  IN1 w0.066: v8(58.47,130.15) 58.47,130.33 58.4,130.4 58.26,130.4 58.05,130.61 58.05,131.08 58.45,131.48 58.45,132.46 58.8,132.82 58.8,134.19 57.88,135.11 52.11,135.11 51.37,135.85 49.68,135.85 47.65,137.87 43.69,137.87 40.68,140.89 38.61,140.89 36.91,142.59 36.91,142.93 v10(36.89,142.95)
  IN2 w0.081: v4(21.77,49.6) 21.95,49.77 21.95,50.03 20.56,51.42 20.56,60.44 18.33,62.67 18.33,93.02 16.97,94.38 16.97,100.18 14.15,103 14.15,114.86 13.95,115.06 13.95,116.91 11.72,119.14 11.72,124.73 18.57,131.59 24.48,131.59 34.89,141.99 36.16,141.99 36.89,142.72 v10(36.89,142.95)
  IN3 w0.081: v4(21.77,49.6) v5(21.77,49.21)
  BOTTOM w0.112: CV23.1 21.55,45.65 v11(21.55,46.31) 21.55,47.31 21.53,47.33 21.53,48.05 21.88,48.4 21.88,49.1 v5(21.77,49.21)
USB3RN1_C: length 1.9
  BOTTOM w0.112: UV1.4 21.9,43.65 21.98,43.74 21.98,44.06 21.58,44.46 21.58,44.62 CV23.2
USB3RN2: length 75.7
  IN1 w0.066: v8(57.56,129.5) 56.98,130.07 56.98,130.85 57.46,131.33 57.46,132.51 58.11,133.16 58.11,133.93 57.71,134.33 52.12,134.33 51.12,135.33 49.46,135.33 47.44,137.35 47.44,137.35 47.18,137.35 43.45,137.35 v10(43.34,137.24)
  IN2 w0.081: v10(43.34,137.24) 43.3,137.29 40.67,134.66 40.67,133.33 33.02,125.68 29.97,125.68 28.51,124.22 28.51,117.12 26.52,115.13 26.52,112.38 27.74,111.16 27.74,110.43 27.46,110.15 27.46,109.64 28.55,108.55 28.55,107.62 28.98,107.18 28.98,98.15 30.7,96.43 30.7,95.16 30.21,94.67 29.61,94.67 v3(29.49,94.55)
USB3RN3: length 92.6
  IN1 w0.066: v10(40.06,143.93) 40.01,143.89 40.01,143.44 40.26,143.19 40.88,143.19 44.48,139.59 50.22,139.59 50.73,139.08 54.45,139.08 55.06,138.47 58.93,138.47 60.28,137.11 62.13,135.27 62.13,135.15 62.13,132.26 60.05,130.18 60.05,130.13 59.72,129.8 59.5,129.8 59.38,129.69 v8(59.38,129.5)
  IN2 w0.081: v10(40.06,143.93) 40.02,143.89 40.02,143.6 36.87,140.45 35.3,140.45 24.38,129.53 18.87,129.53 14.61,125.27 14.61,121.26 15.34,120.53 15.34,115.66 15.53,115.46 15.53,107.58 19.63,103.48 19.63,103.2 19.97,102.86 20.34,102.86 20.57,103.1 20.57,103.19 20.4,103.37 v4(20.35,103.37)
  IN3 w0.081: v5(20.55,103.06) 20.55,103.16 v4(20.35,103.37)
  BOTTOM w0.112: ML4.4 v5(20.55,103.06)
USB3RN3_CONN: length 19.5
  IN3 w0.081: JUSB1.5 10.31,99.25 10.38,99.32 13.34,99.32 14.85,97.8 20.26,97.8 21.48,96.59 22.03,96.59 v5(22.12,96.5)
  BOTTOM w0.112: ML4.3 20.7,101.18 20.7,100.78 21.12,100.35 MD1.1 21.12,98.98 21.35,98.76 21.35,98.1 21.58,97.87 21.58,96.82 21.82,96.59 22.03,96.59 v5(22.12,96.5)
USB3RN4: length 169.9
  IN1 w0.066: v8(59.38,132.1) 59.38,131.92 59.56,131.74 60.64,131.74 61.48,132.57 61.48,134.97 58.97,137.48 54.88,137.48 53.95,138.41 50.45,138.41 49.94,138.92 44.19,138.92 40.59,142.52 39.98,142.52 38.74,143.77 38.74,144.34 v10(38.61,144.46)
  IN2 w0.081: v10(38.61,144.46) 38.72,144.36 38.72,144.26 38.63,144.18 35.41,144.18 24,132.76 18.08,132.76 10.54,125.22 10.54,118.65 12.78,116.42 12.78,114.48 12.97,114.28 12.97,100.86 15.62,98.21 15.62,94.05 17.15,92.52 17.15,51.67 22.89,45.94 22.89,44.57 23.67,43.79 23.67,33.93 23.17,33.43 22.92,33.43 v4(22.76,33.59)
  IN3 w0.081: v5(22.3,33.64) 22.71,33.64 v4(22.76,33.59)
  BOTTOM w0.112: CV44.1 21.67,31.3 21.67,33.09 21.94,33.36 22.02,33.36 v5(22.3,33.64)
USB3RN4_C: length 1.9
  BOTTOM w0.112: CV44.2 21.72,30.25 21.72,30.06 22.09,29.68 22.09,29.4 22.02,29.33 UV2.4
USB3RP1: length 147
  IN1 w0.066: v8(58.47,130.8) 58.47,130.62 58.4,130.55 58.32,130.55 58.2,130.68 58.2,130.98 58.6,131.38 58.6,132.4 58.95,132.76 58.95,134.25 57.95,135.26 52.17,135.26 51.44,136 49.74,136 47.72,138.02 43.75,138.02 40.74,141.04 38.67,141.04 37.06,142.65 37.06,142.74 v10(37.27,142.95)
  IN2 w0.081: v4(22.33,49.6) 22.15,49.77 22.15,50.12 20.76,51.51 20.76,60.52 18.53,62.75 18.53,93.1 17.17,94.46 17.17,100.27 14.36,103.08 14.36,114.95 14.16,115.15 14.16,116.99 11.92,119.23 11.92,124.65 18.66,131.38 24.57,131.38 34.97,141.79 36.24,141.79 37.09,142.63 37.09,142.77 v10(37.27,142.95)
  IN3 w0.081: v4(22.33,49.6) v5(22.33,49.21)
  BOTTOM w0.112: CV22.1 21.76,45.65 21.76,46.01 21.78,46.03 21.78,46.58 21.76,46.6 v11(21.76,47.6) 21.76,47.98 22.1,48.31 22.1,48.99 v5(22.33,49.21)
USB3RP1_C: length 1.9
  BOTTOM w0.112: CV22.2 21.79,44.68 21.79,44.55 22.2,44.15 22.2,43.74 22.3,43.64 UV1.5
USB3RP2: length 75.7
  IN1 w0.066: v8(57.56,130.15) 57.56,130.12 57.42,129.99 57.28,129.99 57.13,130.14 57.13,130.79 57.61,131.27 57.61,132.45 58.26,133.1 58.26,134 57.78,134.48 52.18,134.48 51.18,135.48 49.52,135.48 47.55,137.45 47.5,137.5 47.18,137.5 43.47,137.5 v10(43.34,137.62)
  IN2 w0.081: v10(43.34,137.62) 40.46,134.74 40.46,133.41 32.94,125.88 29.89,125.88 28.31,124.31 28.31,117.21 26.32,115.22 26.32,112.29 27.54,111.07 27.54,110.52 27.25,110.23 27.25,109.55 28.35,108.46 28.35,107.53 28.78,107.1 28.78,98.06 30.5,96.34 30.5,95.24 30.13,94.87 29.67,94.87 v3(29.49,95.05)
USB3RP3: length 92.6
  IN1 w0.066: v8(59.38,130.15) 59.38,130.06 59.5,129.95 59.65,129.95 59.9,130.2 59.9,130.25 61.98,132.33 61.98,135.21 60.44,136.75 58.87,138.32 55,138.32 54.39,138.93 50.66,138.93 50.15,139.44 44.42,139.44 40.81,143.04 40.2,143.04 39.86,143.38 39.86,143.6 v10(39.75,143.72)
  IN2 w0.081: v4(20.86,103.39) 20.78,103.31 20.78,103.01 20.42,102.66 19.89,102.66 19.43,103.11 19.43,103.39 15.33,107.49 15.33,115.38 15.13,115.58 15.13,120.44 14.4,121.17 14.4,125.35 18.78,129.73 24.3,129.73 35.22,140.65 36.78,140.65 39.75,143.62 v10(39.75,143.72)
  IN3 w0.081: v5(21.36,103.06) 21.03,103.39 v4(20.86,103.39)
  BOTTOM w0.112: ML4.1 v5(21.36,103.06)
USB3RP3_CONN: length 19.5
  IN3 w0.081: v5(22.12,96.88) 22.03,96.79 21.56,96.79 20.35,98.01 14.93,98.01 13.42,99.52 10.38,99.52 10.07,99.82 10.07,100.38 JUSB1.6
  BOTTOM w0.112: ML4.2 21.26,101.23 21.26,100.85 21.77,100.34 MD1.2 21.77,98.95 21.56,98.74 21.56,98.19 21.79,97.96 21.79,96.91 21.9,96.8 22.05,96.8 v5(22.12,96.88)
USB3RP4: length 169.8
  IN1 w0.066: v10(38.99,144.46) 38.89,144.36 38.89,143.83 40.04,142.67 40.65,142.67 44.25,139.07 50,139.07 50.51,138.56 54.03,138.56 54.93,137.66 59,137.66 61.63,135.03 61.63,132.51 60.71,131.59 59.52,131.59 v8(59.38,131.45)
  IN2 w0.081: v10(38.99,144.46) 38.92,144.39 38.92,144.17 38.72,143.97 35.49,143.97 24.08,132.56 18.17,132.56 10.74,125.13 10.74,118.74 12.98,116.5 12.98,114.56 13.18,114.36 13.18,100.94 15.82,98.29 15.82,94.13 17.35,92.6 17.35,51.76 23.09,46.02 23.09,44.66 23.88,43.87 23.88,33.85 23.09,33.06 v4(22.78,33.06)
  IN3 w0.081: v4(22.78,33.06) 22.73,33.01 v5(22.31,33.01)
  BOTTOM w0.112: CV43.1 21.89,31.3 21.89,33 22.03,33.15 22.17,33.15 v5(22.31,33.01)
USB3RP4_C: length 1.9
  BOTTOM w0.112: UV2.5 22.42,29.37 22.31,29.48 22.31,29.77 21.93,30.15 21.93,30.34 CV43.2
USB3TN1: length 147.4
  IN1 w0.066: v8(61.11,133.52) 61.11,133.34 61.04,133.27 60.71,133.27 60.53,133.45 60.53,134.16 58.17,136.51 52.63,136.51 52.07,137.07 49.4,137.07 47.93,138.54 44.01,138.54 40.4,142.15 39.46,142.15 38.6,143.01 38.24,143.01 v10(38.22,143.02)
  IN2 w0.081: v10(38.22,143.02) 38.13,142.93 37.93,142.93 36.4,141.4 35.13,141.4 24.73,131 18.82,131 12.31,124.49 12.31,119.39 14.54,117.15 14.54,115.31 14.74,115.11 14.74,103.48 17.6,100.62 17.6,94.58 18.92,93.26 18.92,62.91 21.15,60.68 21.15,51.67 22.53,50.28 22.53,50.27 22.89,49.91 24.86,49.91 25.02,49.75 25.02,49.4 v7(24.96,49.34)
  BOTTOM w0.112: v7(24.96,49.34) 25.02,49.28 25.02,48.83 v11(24.77,48.58) 24.46,48.27 24.15,47.96 24.15,47.58 24.13,47.56 24.13,47.01 24.15,46.99 24.15,45.33 CV21.1
USB3TN1_C: length 2.2
  BOTTOM w0.112: CV21.2 24.15,44.33 24.15,44.27 24.04,44.16 23.39,44.16 23.19,43.96 23.19,43.71 23.1,43.62 UV1.7
USB3TN2: length 63.2
  TOP w0.112: C215.1 23.98,108.65 23.98,108.5 24.09,108.38 v11(26.2,108.38) 26.47,108.38 26.62,108.54 26.62,109.64 26.87,109.89 26.87,110.51 v3(26.79,110.59)
  IN1 w0.066: v10(48.99,138.1) 49,138.1 49.22,137.88 49.22,137.78 49.52,137.48 51.56,137.48 51.71,137.63 53.9,137.63 54.58,136.95 58.29,136.95 60.69,134.55 61.04,134.55 61.11,134.48 v8(61.11,134.17)
  IN2 w0.081: v3(26.79,110.59) 26.91,110.71 26.91,110.87 25.51,112.26 25.51,115.25 27.7,117.44 27.7,124.5 27.72,124.52 27.72,124.55 29.64,126.47 32.69,126.47 39.85,133.63 39.85,134.98 42.97,138.09 43.79,138.09 43.88,138 48.12,138 48.32,137.8 49.03,137.8 49.12,137.89 49.12,137.99 49.01,138.1 v10(48.99,138.1)
USB3TN2_C: length 18.7
  TOP w0.112: v3(28.83,96.51) 28.97,96.37 29.98,96.37 30.23,96.13 30.23,95.76 30.02,95.55 U4.18
  IN2 w0.081: v3(24.13,109.39) 24.21,109.31 25.4,109.31 27.03,107.68 27.03,107.3 27.79,106.54 27.79,96.99 28.4,96.38 28.7,96.38 v3(28.83,96.51)
USB3TN3: length 89.4
  IN1 w0.066: v8(62.46,134.17) 62.46,134.29 62.57,134.41 62.8,134.41 63.01,134.62 63.01,135.12 61.26,136.87 61.26,137.66 59.94,138.99 56.96,138.99 55.9,140.04 55.14,140.04 54.7,139.6 50.94,139.6 50.43,140.11 44.85,140.11 42.15,142.81 41.45,143.51 41.45,143.8 41.55,143.91 41.75,143.91 v10(41.77,143.89)
  IN2 w0.081: v4(20.88,103.95) 20.73,104.1 20.73,104.89 17.77,107.85 17.77,111.54 16.88,112.42 16.88,114.94 15.93,115.9 15.93,120.88 15.27,121.54 15.27,125.09 18.61,128.44 24.12,128.44 35.55,139.86 37.11,139.86 40.63,143.39 41.27,143.39 41.45,143.57 41.45,143.76 41.58,143.89 v10(41.77,143.89)
  IN3 w0.081: v5(20.68,104.41) 20.68,104.15 v4(20.88,103.95)
  BOTTOM w0.112: C110.1 22.75,105.02 22.75,105.13 22.62,105.26 22.26,105.26 22.09,105.08 20.95,105.08 20.62,104.75 20.62,104.46 v5(20.68,104.41)
USB3TN3_C: length 1.4
  BOTTOM w0.112: C110.2 22.75,104.03 22.75,103.67 22.46,103.39 ML5.4
USB3TN3_CONN: length 21.8
  IN3 w0.081: JUSB1.8 10.88,105.69 10.88,106.21 10.76,106.34 10.49,106.34 9.42,105.28 9.42,104.75 10.12,104.05 11.3,104.05 15.85,99.51 15.85,99.5 16.08,99.28 16.08,99.28 16.1,99.25 19.81,99.25 20.26,99.7 21.45,99.7 21.95,99.2 22.3,99.2 22.49,99.39 22.49,99.5 22.34,99.65 v5(22.3,99.65)
  BOTTOM w0.112: v5(22.3,99.65) 22.3,100.59 22.53,100.83 22.53,101.25 ML5.3
USB3TN4: length 172.4
  IN1 w0.066: v10(42.18,143.98) 42.41,143.75 42.41,143.1 45.01,140.5 50.7,140.5 51.23,139.97 54.47,139.97 55.18,140.68 56.66,140.68 57.98,139.36 60.14,139.36 61.75,137.75 61.75,136.91 63.39,135.27 63.39,133.68 62.89,133.18 62.45,133.18 62.38,133.25 62.38,133.45 v8(62.46,133.52)
  IN2 w0.081: v10(42.18,143.98) 42.19,143.98 42.34,144.13 42.34,144.29 42.26,144.38 39.95,144.38 38.96,143.38 35.74,143.38 24.32,131.97 18.41,131.97 11.33,124.89 11.33,118.98 13.57,116.75 13.57,114.83 13.77,114.63 13.77,101.27 16.43,98.6 16.43,94.36 17.94,92.85 17.94,59.91 18.22,59.63 19.49,59.63 20.17,58.95 20.17,49.9 23.8,46.27 23.8,44.78 24.47,44.12 24.47,33.26 23.26,32.06 22.96,32.06 22.8,31.89 v4(22.76,31.89)
  IN3 w0.081: v4(22.76,31.89) 22.68,31.89 22.57,31.78 v5(22.31,31.78)
  BOTTOM w0.112: v5(22.31,31.78) 22.31,31.92 22.54,32.15 23.6,32.15 v11(23.81,31.94) 24.04,31.71 24.04,31.51 CV41.1
USB3TN4_C: length 1.9
  BOTTOM w0.112: CV41.2 23.8,30.33 23.8,30.14 23.33,29.67 23.33,29.37 23.22,29.27 UV2.7
USB3TP1: length 147.4
  IN1 w0.066: v10(38.22,142.64) 38.44,142.86 38.54,142.86 39.4,142 40.34,142 43.95,138.39 47.87,138.39 48.04,138.23 49.34,136.92 52.01,136.92 52.57,136.36 58.11,136.36 60.38,134.1 60.38,133.39 60.64,133.12 61.04,133.12 61.11,133.06 v8(61.11,132.87)
  IN2 w0.081: v7(25.55,49.34) 25.49,49.34 25.22,49.61 25.22,49.84 24.94,50.12 22.97,50.12 22.74,50.35 22.74,50.36 21.35,51.75 21.35,60.77 19.12,63 19.12,93.35 17.81,94.66 17.81,100.7 14.94,103.56 14.94,115.19 14.75,115.39 14.75,117.23 12.51,119.47 12.51,124.4 18.9,130.79 24.81,130.79 35.22,141.2 36.48,141.2 38.02,142.73 38.14,142.73 v10(38.22,142.64)
  BOTTOM w0.112: CV20.1 24.37,45.33 v11(24.37,47.28) 24.37,47.87 24.71,48.22 24.74,48.22 25.23,48.72 25.23,49.03 v7(25.55,49.34)
USB3TP1_C: length 2.2
  BOTTOM w0.112: UV1.8 23.5,43.61 23.41,43.7 23.41,43.87 23.47,43.93 24.15,43.93 24.36,44.15 24.36,44.33 CV20.2
USB3TP2: length 63.2
  TOP w0.112: v3(27.17,110.59) 27.09,110.51 27.09,109.8 26.84,109.55 26.84,108.45 26.54,108.15 25.84,108.15 25.82,108.17 24,108.17 23.77,108.41 23.77,108.53 C217.1
  IN1 w0.066: v8(61.11,134.82) 60.98,134.7 60.75,134.7 58.35,137.1 56.45,137.1 56.45,137.1 54.65,137.1 53.96,137.78 51.65,137.78 51.5,137.63 49.58,137.63 49.37,137.84 v10(49.37,138.1)
  IN2 w0.081: v10(49.37,138.1) 49.33,138.06 49.33,137.81 49.11,137.59 48.24,137.59 48.04,137.8 43.79,137.8 43.7,137.89 43.05,137.89 40.06,134.89 40.06,133.55 32.78,126.27 29.73,126.27 27.92,124.47 27.92,124.43 27.9,124.41 27.9,117.35 25.72,115.17 25.72,112.35 27.11,110.95 27.11,110.65 v3(27.17,110.59)
USB3TP2_C: length 18.6
  TOP w0.112: v3(28.77,96.05) U4.19
  IN2 w0.081: v3(23.5,109.39) 23.55,109.44 23.55,109.99 23.63,110.07 23.75,110.07 23.84,109.98 23.84,109.3 24.03,109.11 25.32,109.11 26.82,107.6 26.82,107.22 27.58,106.46 27.58,96.91 28.31,96.18 28.64,96.18 v3(28.77,96.05)
USB3TP3: length 89.4
  IN1 w0.066: v10(41.15,143.88) 41.3,143.72 41.3,143.45 42.09,142.66 44.79,139.96 50.37,139.96 50.88,139.45 54.76,139.45 55.21,139.89 55.84,139.89 56.9,138.84 59.87,138.84 61.11,137.59 61.11,136.81 62.87,135.06 62.87,134.69 62.74,134.56 62.58,134.56 62.46,134.68 v8(62.46,134.82)
  IN2 w0.081: v10(41.15,143.88) 41.25,143.78 41.25,143.65 41.19,143.59 40.55,143.59 37.03,140.06 35.46,140.06 24.04,128.64 18.53,128.64 15.06,125.18 15.06,121.45 15.72,120.79 15.72,115.82 16.68,114.86 16.68,112.34 17.56,111.46 17.56,107.77 20.52,104.81 20.52,104.13 v4(20.35,103.95)
  IN3 w0.081: v4(20.35,103.95) 20.31,103.99 v5(20.31,104.41)
  BOTTOM w0.112: v5(20.31,104.41) 20.41,104.51 20.41,104.84 20.87,105.3 22,105.3 22.17,105.48 22.71,105.48 22.96,105.22 22.96,104.99 C111.1
USB3TP3_C: length 1.4
  BOTTOM w0.112: ML5.1 23.26,103.42 22.96,103.72 22.96,104.05 C111.2
USB3TP3_CONN: length 21.8
  IN3 w0.081: JUSB1.9 10.31,106.45 9.22,105.36 9.22,104.67 10.04,103.85 11.22,103.85 15.65,99.42 15.65,99.42 15.99,99.07 15.99,99.07 16.02,99.05 19.9,99.05 20.34,99.49 21.37,99.49 21.86,99 22.39,99 22.68,99.29 22.68,99.48 22.85,99.65 v5(22.95,99.65)
  BOTTOM w0.112: v5(22.95,99.65) 22.95,100.48 23.26,100.8 ML5.2
USB3TP4: length 172.5
  IN1 w0.066: v10(42.56,143.98) 42.56,143.16 45.08,140.65 50.77,140.65 51.29,140.12 54.41,140.12 55.12,140.83 56.72,140.83 58.04,139.51 60.2,139.51 61.9,137.81 61.9,136.97 63.54,135.34 63.54,135.21 63.54,133.62 62.95,133.03 62.62,133.03 v8(62.46,132.87)
  IN2 w0.081: v10(42.56,143.98) 42.54,144 42.54,144.38 42.34,144.58 39.87,144.58 38.88,143.59 35.65,143.59 24.24,132.18 18.33,132.18 11.13,124.97 11.13,118.9 13.37,116.66 13.37,114.75 13.56,114.55 13.56,101.18 16.23,98.52 16.23,94.27 17.74,92.77 17.74,59.83 18.14,59.42 19.41,59.42 19.97,58.87 19.97,49.81 23.6,46.18 23.6,44.7 24.26,44.03 24.26,33.35 23.17,32.26 22.9,32.26 v4(22.76,32.4)
  IN3 w0.081: v4(22.76,32.4) 22.72,32.36 v5(22.31,32.36)
  BOTTOM w0.112: CV40.1 24.25,31.09 24.25,31.83 23.72,32.36 22.45,32.36 22.38,32.29 v5(22.31,32.36)
USB3TP4_C: length 1.9
  BOTTOM w0.112: UV2.8 23.63,29.31 23.55,29.39 23.55,29.58 24.01,30.05 24.01,30.26 CV40.2
USB20_N1: length 78.9
  IN1 w0.066: v8(58.66,123.64) 58.91,123.64 58.97,123.58 58.97,123.36 59.63,122.7 59.63,121.79 58.99,121.16 57.45,121.16 56.96,120.67 56.96,119.83 55.58,118.45 54.45,118.45 53.81,117.82 53.68,117.82 53.41,117.82 53.39,117.82 53.13,117.82 51.9,116.58 44.99,116.58 44.05,115.63 43.09,114.68 43.09,110 42.83,109.74 42.78,109.69 39.16,106.06 39.16,95.6 35.84,92.28 35.05,92.28 34.79,92.54 v7(34.79,92.75)
  IN4 w0.066: v7(34.79,92.75) 34.79,92.46 34.94,92.31 34.94,89.13 35.31,88.77 35.31,86.17 39.77,81.7 39.77,78.49 39.15,77.87 39.15,74.69 39.1,74.64 35.64,71.19 35.07,71.19 33.35,69.46 32.73,69.46 v1(32.56,69.3)
  BOTTOM w0.112: v1(32.56,69.3) ML7.1
USB20_N1_R: length 3.1
  BOTTOM w0.076: 34.95,67.88 34.95,67.08 UT1.K5
  BOTTOM w0.112: ML7.2 34.84,69.3 35.07,69.07 35.07,68.28 34.95,68.16 34.95,67.88
USB20_N2: length 119.5
  TOP w0.112: v7(75.69,57.58) 75.51,57.76 75.29,57.76 75.18,57.65 74.55,57.65 JIO2.10
  IN1 w0.066: v7(35.33,94.88) 35.52,94.68 36.37,94.68 38.08,96.39 38.08,104.17 38.64,104.72 38.64,107.09 42.57,111.02 42.57,114.9 44.78,117.1 51.68,117.1 52.92,118.34 53.6,118.34 54.09,118.83 54.84,118.83 55.11,119.1 55.48,119.1 55.55,119.17 55.55,119.54 56.19,120.19 56.19,120.72 56.96,121.49 56.96,122.51 56.89,122.58 v8(56.71,122.58)
  IN3 w0.081: v6(46.07,55.56) 45.96,55.68 45.96,56.12 47.62,57.79 75.49,57.79 v7(75.69,57.58)
  IN4 w0.066: v7(35.33,94.88) 35.52,94.68 35.83,94.68 35.98,94.53 35.98,89.56 36.35,89.2 36.35,86.6 39.94,83.01 40.45,83.01 41,82.45 41,72.68 45.71,67.98 45.71,57.99 45.93,57.77 45.93,55.71 v6(46.07,55.56)
USB20_N3: length 126.7
  IN1 w0.066: v8(55.61,120.04) 55.51,119.84 55.42,119.81 55.28,119.88 55.09,119.85 54.57,119.32 53.95,119.32 53.49,118.86 52.7,118.86 51.47,117.62 44.56,117.62 42.05,115.11 42.05,111.25 38.12,107.31 38.12,104.96 37.49,104.33 37.49,103.6 37.07,103.17 37.07,102.59 37.42,102.24 37.42,97.28 36.11,95.97 35.59,95.97 35.36,95.74 35.13,95.51 34.73,95.11 34.64,95.11 v7(34.4,95.35)
  IN4 w0.066: v7(34.4,95.35) 34.64,95.11 34.77,95.11 34.92,94.96 34.92,94.01 35.46,93.47 35.46,89.35 35.83,88.98 35.83,86.38 40.48,81.72 40.48,72.26 44.79,67.95 44.79,53.83 50.82,47.81 50.82,37.72 50.54,37.44 50.54,28.71 49.79,27.96 49.79,23.87 49.25,23.33 49.25,21.34 50.14,20.44 50.14,17.54 49.91,17.31 49.66,17.31 v1(49.58,17.24)
  BOTTOM w0.112: ML14.1 49.69,17.34 v1(49.58,17.24)
USB20_N3_R: length 2.9
  BOTTOM w0.076: 53.09,17.48 53.11,17.48 53.12,17.5 53.34,17.5 53.49,17.35 53.88,17.35 UT2.K5
  BOTTOM w0.112: ML14.2 51.82,17.34 51.96,17.48 53.09,17.48
USB20_N4: length 77.7
  TOP w0.112: L10.4 v8(30.82,110.15)
  IN1 w0.066: v8(58.66,122.58) 58.87,122.58 58.99,122.7 58.99,122.79 58.78,123 58.02,123 57.58,123.44 56.5,123.44 56.3,123.24 56.3,122.96 56.32,122.94 56.32,121.21 56.09,120.98 55.93,120.98 55.92,120.98 51.58,120.98 50.31,119.71 43.34,119.71 41.86,118.23 41.35,118.23 40.01,119.57 39.92,119.57 39.78,119.43 39.78,119.34 41.01,118.11 41.01,117.89 40.78,117.66 40.56,117.66 39.07,119.16 38.97,119.16 38.83,119.02 38.83,118.92 39.98,117.78 39.98,117.56 39.75,117.33 39.54,117.33 38.39,118.48 38.29,118.48 38.15,118.34 38.15,118.24 39.91,116.49 39.91,116.27 39.68,116.05 39.46,116.05 37.71,117.8 37.61,117.8 37.47,117.66 37.47,117.56 39.22,115.82 39.22,115.6 38.99,115.37 38.77,115.37 37.03,117.12 36.94,117.12 36.79,116.98 36.79,116.88 38.24,115.44 38.24,115.22 38.01,114.99 37.8,114.99 36.35,116.44 36.26,116.44 36.11,116.3 36.11,116.2 37.56,114.76 37.56,114.54 37.33,114.31 37.12,114.31 36.08,115.35 35.99,115.35 35.85,115.2 35.85,115.11 36.88,114.08 36.88,113.86 36.66,113.63 36.44,113.63 36.09,113.98 36,113.98 35.86,113.84 35.86,113.74 36.2,113.4 36.2,113.18 35.53,112.51 35.53,112.42 37.9,110.05 37.9,109.83 37.67,109.6 37.45,109.6 35.79,111.27 35.69,111.27 35.5,111.08 35.5,110.99 36.45,110.05 36.45,108.52 35.81,107.89 32.13,107.89 31.5,108.52 31.5,109.48 31.09,109.88 31.09,110.07 31.01,110.15 v8(30.82,110.15)
USB20_N4_CONN: length 2.9
  TOP w0.112: JNGFF1.9 30.88,113.85 31.02,113.71 31.02,113.44 31.13,113.33 v11(31.13,113.07) 31.13,112.45 30.82,112.14 L10.3
USB20_N5: length 61
  TOP w0.076: v8(52.96,120.21) 52.96,120.25 53.12,120.41 53.28,120.41 54.06,119.63 54.13,119.63 54.21,119.55 54.21,119.44 54.15,119.38 UCPU1.AJ1
  TOP w0.112: ML3.4 v8(29.93,103.34)
  IN1 w0.066: v8(52.96,120.21) 52.73,120.44 52.28,120.44 50.88,119.03 43.4,119.03 40.14,115.77 40.14,115.68 40.64,115.17 40.64,114.96 40.41,114.73 40.19,114.73 39.69,115.23 39.6,115.23 39.46,115.09 39.46,115 40.64,113.81 40.64,113.6 40.41,113.37 40.19,113.37 38.71,114.85 38.62,114.85 38.47,114.71 38.47,114.62 39.71,113.38 39.71,113.17 39.48,112.94 39.26,112.94 38.03,114.17 37.94,114.17 37.8,114.03 37.8,113.94 40.16,111.57 40.16,111.36 39.93,111.13 39.72,111.13 37.35,113.49 37.26,113.49 37.08,113.32 37.08,113.23 39.43,110.87 39.43,110.63 39.14,110.33 38.92,110.33 36.76,112.49 36.67,112.49 36.53,112.35 36.53,112.26 36.82,111.97 38.69,110.1 38.69,109.88 36.7,107.9 36.7,105.86 36.11,105.26 33.78,105.26 32.86,104.34 31.15,104.34 30.49,103.69 30,103.69 29.93,103.62 v8(29.93,103.34)
USB20_N5_CONN: length 17.6
  TOP w0.112: JIR1.10 15.72,100.55 v3(15.92,100.34) ; ML3.3 27.98,103.71 27.85,103.84 27.51,103.84 27.21,103.54 27.21,103.52 26.82,103.13 26.8,103.13 26.68,103.01 25.68,102.01 v11(25.68,101.53) 25.68,100.73 25.81,100.6 26.01,100.6 v7(26.38,100.97)
  IN2 w0.081: v4(16.24,100.25) 16.14,100.34 v3(15.92,100.34)
  IN3 w0.081: v7(26.38,100.97) 26,100.59 25.05,100.59 24.75,100.29 19.04,100.29 18.71,99.95 16.53,99.95 v4(16.24,100.25)
USB20_N7: length 103.5
  IN1 w0.066: v10(43.24,79.92) 43.11,80.05 42.8,80.05 40.69,77.95 31.51,77.95 29.38,80.07 29.38,81.93 33.64,86.19 33.64,93.42 33.31,93.76 33.31,97.57 34.57,98.84 34.57,99.96 35.86,101.25 35.86,102.92 36.34,103.39 36.5,103.39 36.91,103.8 36.91,104.56 37.59,105.25 37.59,107.53 41.32,111.25 41.53,111.47 41.53,115.33 44.35,118.14 51.25,118.14 52.49,119.38 53.38,119.38 53.78,119.78 54.48,119.78 54.56,119.86 54.56,119.98 54.49,120.04 v8(54.31,120.04)
  IN2 w0.081: v7(36.92,55.33) 37.11,55.52 37.11,55.67 34.99,57.79 34.99,61.95 35.98,62.94 37.99,62.94 40.73,65.68 40.73,68.86 43.61,71.74 43.61,79.95 43.55,80.01 43.33,80.01 v10(43.24,79.92)
  BOTTOM w0.112: ML8.1 36.97,54.59 37.1,54.71 37.1,55.15 v7(36.92,55.33)
USB20_N7_R: length 2.8
  TOP w0.112: JNGFF3.5 36.97,52.25 37.11,52.11 37.11,51.9 v7(36.93,51.72)
  BOTTOM w0.112: v7(36.93,51.72) 37.11,51.9 37.11,52.51 36.97,52.65 ML8.2
USB20_N9: length 40.6
  IN1 w0.066: v8(53.98,120.7) 54.11,120.7 54.18,120.64 54.18,120.51 54.11,120.44 53.81,120.44 53.26,119.9 52.27,119.9 51.03,118.66 43.84,118.66 41.01,115.84 41.01,111.68 37.07,107.75 37.07,105.67 34.79,103.39 34.19,103.39 33.99,103.19 33.99,102.73 34.12,102.59 35.24,102.59 35.31,102.53 35.31,102.33 35.24,102.26 33.87,102.26 33.71,102.11 33.71,101.79 33.87,101.63 35.19,101.63 35.25,101.57 35.25,101.37 35.19,101.3 33.87,101.3 33.71,101.15 33.71,100.06 33.91,99.87 34.09,99.87 v8(34.19,99.76)
USB20_N9_CONN: length 26.1
  IN3 w0.081: JUSB1.2 8.81,103.26 8.93,103.14 9.45,103.14 9.66,102.93 9.66,102.34 10.02,101.98 11.79,101.98 12.57,101.2 12.69,101.2 12.86,101.38 13.14,101.38 13.44,101.08 13.44,100.8 13.26,100.63 13.26,100.51 13.43,100.34 13.55,100.34 13.72,100.51 14.01,100.51 14.3,100.22 14.3,99.94 14.12,99.76 14.12,99.65 14.3,99.48 14.41,99.48 14.59,99.65 14.87,99.65 15.16,99.36 15.16,99.08 14.99,98.9 14.99,98.79 15.13,98.64 21.29,98.64 22.86,97.07 22.86,95.51 v5(23.07,95.3)
  BOTTOM w0.112: v5(23.07,95.3) 23.07,95.86 22.86,96.08 22.86,96.29 23.06,96.5 23.41,96.5 23.75,96.15 v11(24.38,96.15) 24.69,96.15 24.9,96.37 24.9,96.72 25.19,97.01 ML6.2
USB20_N9_PS: length 8.2
  TOP w0.112: v7(26.39,99.2) 26.61,99.42 27.4,99.42 28.31,100.33 30,100.33 30.28,100.05 30.43,100.05 30.56,99.92 30.56,99.86 30.65,99.76 US1.11
  BOTTOM w0.112: v7(26.39,99.2) 26.07,99.52 25.64,99.52 25.28,99.87 25.01,99.87 24.85,99.71 24.85,99.55 25.19,99.21 ML6.1
USB20_N10: length 116.8
  TOP w0.112: v3(132.41,93.48) 132.45,93.43 JIO1.30
  IN1 w0.066: v8(57.36,120.44) 57.64,120.17 57.64,119.77 57,119.13 57,118.58 56.61,118.2 56.07,118.2 55.65,117.78 54.77,117.78 53.93,116.94 53.52,116.94 v7(53.27,117.19)
  IN2 w0.081: v4(132.34,93.04) 132.51,93.21 132.51,93.38 v3(132.41,93.48)
  IN3 w0.081: v4(132.34,93.04) v6(132.34,92.67) ; v6(61.47,110.12) 61.41,110.06 60.3,110.06 58.04,112.32 56.37,112.32 53.95,114.74 53.95,116.77 53.72,117 53.46,117 v7(53.27,117.19)
  IN4 w0.066: v6(132.34,92.67) 132.49,92.82 132.49,93.13 131.9,93.71 128.85,93.71 128.36,94.2 127.09,94.2 126.73,94.56 123.22,94.56 122.56,93.89 111.82,93.89 108.14,90.21 104.25,90.21 103.84,89.8 95.73,89.8 95.03,90.5 82.45,90.5 81.87,91.08 77.69,91.08 74.7,88.09 66.13,88.09 63.97,90.24 63.97,104.12 61.85,106.24 61.85,108.45 61,109.3 61,109.85 61.15,110.01 61.35,110.01 v6(61.47,110.12)
