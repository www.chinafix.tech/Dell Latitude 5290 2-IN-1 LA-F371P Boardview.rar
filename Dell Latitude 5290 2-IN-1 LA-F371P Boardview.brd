# Allegro board Dell Latitude 5290 2-IN-1 LA-F371P Boardview.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
RH15  10K_0402_5%  [R_0402]  42.3 118.43 180 top
RH16  10K_0402_5%  [R_0402]  43.17 118.43 0 top
RH17  10K_0402_5%  [R_0402]  42.3 117.33 180 top
RH18  10K_0402_5%  [R_0402]  43.17 117.33 0 top
RH19  1K_0402_5%~D  [R_0402]  53.59 108.8 270 top
RH20  1K_0402_5%~D  [R_0402]  54.48 108.8 270 top
RH21  1K_0402_5%~D  [R_0402]  56.34 107.89 180 top
RH24  2.2K_0201_5%  [R_0201]  145.45 139.83 180 bottom
RH25  2.2K_0201_5%  [R_0201]  150.56 138.72 270 bottom
RH26  2.2K_0201_5%  [R_0201]  149.92 138.72 270 bottom
RH27  2.2K_0201_5%  [R_0201]  145.45 139.26 180 bottom
RH28  SHORT PADS  [SHORTPADS]  52.58 127.32 90 bottom
RH29  100K_0402_5%~D  [R_0402]  51.47 127.66 90 bottom
RH30  100K_0402_5%~D  [R_0402]  50.58 127.66 90 bottom
RH31  SHORT PADS  [SHORTPADS]  48.9 127.4 180 bottom
RH90  0_0201_5%  [R_0201]  51.82 121.07 270 top
RH91  1K_0201_5%  [R_0201]  51.82 121.69 90 top
RH505  10K_0201_5%  [R_0201]  47.18 122.01 90 bottom
RN1  2.2K_0402_5%  [R_0402]  42.6 124.78 0 top
RN2  2.2K_0402_5%  [R_0402]  42.6 125.67 0 top
RP2  33_0804_8P4R_5%  [RP_0804_8P4R]  50.05 106.93 90 top
RP3  33_0804_8P4R_5%  [RP_0804_8P4R]  53.48 105.03 90 top
RR1  6.2K_0402_1%  [R_0402]  65.52 37.09 0 bottom
RR2  0_0402_5%  [R_0402]  72.86 38.35 0 bottom
RR3  0_0402_5%  [R_0402]  72.86 37.46 0 bottom
RR4  0_0402_5%  [R_0402]  72.86 36.57 0 bottom
RR5  0_0402_1%  [R0402_0OHM]  63.36 34.16 0 bottom
RR6  0_0402_5%  [R_0402]  72.61 34.79 0 bottom
RR7  0_0402_1%  [R0402_0OHM]  63.36 33.15 0 bottom
RR8  0_0402_5%  [R_0402]  72.61 33.9 0 bottom
RR9  0_0402_5%  [R_0402]  72.61 33.01 0 bottom
RR10  10K_0402_5%  [R_0402]  69.22 28.44 90 bottom
RR11  10K_0402_5%  [R_0402]  67.18 29.35 270 bottom
RR12  0_0402_5%  [R_0402]  66.29 28.44 90 bottom
RS1  0_0402_1%  [R0402_0OHM]  117.08 156.07 90 bottom
RS2  0_0402_1%  [R0402_0OHM]  117.97 156.07 90 bottom
RS3  2.2K_0402_5%  [R_0402]  118.91 157.42 0 bottom
RS4  2.2K_0402_5%  [R_0402]  119.69 160.97 180 bottom
RS5  2.2K_0402_5%  [R_0402]  117.2 161.61 270 bottom
RS6  10K_0201_5%  [R_0201]  9.03 137.01 180 bottom
RS7  0_0201_5%  [R0201_0OHM]  9.03 138.15 180 bottom
RS8  0_0201_5%  [R0201_0OHM]  10.43 137 180 bottom
RS9  10K_0201_5%  [R_0201]  9.03 137.58 180 bottom
RS10  10K_0201_5%  [R_0201]  9.84 137.57 0 bottom
RS11  10K_0201_5%  [R_0201]  9.84 138.14 0 bottom
RS15  0_0201_5%  [R0201_0OHM]  5.84 119.7 0 top
RS16  0_0201_5%  [R0201_0OHM]  4.38 119.7 180 top
RS17  0_0402_1%  [R0402_0OHM]  5.65 113.15 90 top
RS18  2.2K_0201_5%  [R_0201]  4.38 120.27 180 top
RS19  2.2K_0201_5%  [R_0201]  5.84 120.27 0 top
RS20  0_0402_1%  [R0402_0OHM]  8.26 147.84 270 bottom
RS22  1K_0201_5%  [R_0201]  126.52 170.88 270 top
RS23  1K_0201_5%  [R_0201]  126.52 172.06 270 top
RS24  1K_0201_5%  [R_0201]  126.52 172.66 90 top
RS25  0_0201_5%  [R0201_0OHM]  125.95 170.88 270 top
RS26  0_0201_5%  [R0201_0OHM]  125.95 172.66 90 top
RS27  0_0201_5%  [R0201_0OHM]  125.95 172.06 270 top
RT2  1K_0201_5%  [R_0201]  30.92 70.3 270 bottom
RT3  0_0201_5%  [R_0201]  30.23 70.3 270 bottom
RT4  0_0201_5%  [R_0201]  29.65 70.3 270 bottom
RT5  0_0201_5%  [R_0201]  28.5 70.31 270 bottom
RT6  4.7K_0201_5%  [R_0201]  27.86 70.31 270 bottom
RT7  4.7K_0201_5%  [R_0201]  27.23 70.31 270 bottom
RT8  0_0201_5%  [R_0201]  26.56 70.31 270 bottom
RT10  4.7K_0201_5%  [R_0201]  24.9 69.92 90 bottom
RT11  0_0402_1%  [R0402_0OHM]  40.22 69.67 90 bottom
RT13  1K_0201_5%  [R_0201]  28.63 68.65 180 bottom
RT14  1K_0201_5%  [R_0201]  28.63 67.86 180 bottom
RT15  1M_0402_5%  [R_0402]  28.24 66.94 0 bottom
RT16  0_0402_5%  [R_0402]  42.35 66.79 90 bottom
RT17  0_0402_1%  [R0402_0OHM]  40.44 66.87 0 bottom
RT18  1M_0402_5%  [R_0402]  28.24 66.05 0 bottom
RT19  0_0402_5%  [R_0402]  42.34 65.85 0 bottom
RT20  0_0402_1%  [R0402_0OHM]  40.44 65.85 0 bottom
RT21  15K_0402_1%  [R_0402]  31.19 64.58 180 bottom
RT22  0_0402_5%  [R_0402]  30.28 63.69 0 bottom
RT23  0_0402_5%  [R_0402]  42.34 64.84 0 bottom
RT24  10K_0402_5%  [R_0402]  40.44 64.84 0 bottom
RT25  10K_0402_5%  [R_0402]  28.24 64.63 0 bottom
RT26  0_0201_5%  [R_0201]  28.54 65.34 0 bottom
RT27  0_0402_5%  [R_0402]  42.34 63.82 0 bottom
RT28  0_0402_1%  [R0402_0OHM]  40.44 63.82 0 bottom
RT29  10K_0402_5%  [R_0402]  28.24 63.74 0 bottom
RT30  0_0201_5%  [R_0201]  28.54 63.03 0 bottom
RT31  0_0402_1%  [R0402_0OHM]  42.34 62.8 0 bottom
RT32  10K_0402_5%  [R_0402]  28.31 60.77 0 bottom
RT33  0_0201_5%  [R_0201]  28.6 60.01 0 bottom
RT34  0_0402_1%  [R0402_0OHM]  42.34 61.79 0 bottom
RT35  4.7K_0201_5%  [R_0201]  28.54 62.45 0 bottom
RT36  4.7K_0201_5%  [R_0201]  28.54 61.88 0 bottom
RT37  0_0402_5%  [R_0402]  30.15 60.77 0 bottom
RT38  0_0201_5%  [R0201_0OHM]  37.21 60.1 90 bottom
RT39  0_0201_5%  [R0201_0OHM]  35.69 60.29 90 bottom
RT40  0_0201_5%  [R0201_0OHM]  35.12 60.29 90 bottom
RT41  0_1206_5%  [R_1206]  41.54 57.89 90 bottom
RT42  10K_0402_5%  [R_0402]  37.97 59.68 90 bottom
RT43  10K_0402_5%  [R_0402]  36.45 59.68 90 bottom
RT44  10K_0402_5%  [R_0402]  34.35 59.68 90 bottom
RT45  0_0402_1%  [R0402_0OHM]  33.46 60.59 270 bottom
RT46  0_0402_1%  [R0402_0OHM]  32.58 60.59 270 bottom
RT47  4.7K_0201_5%  [R_0201]  27.47 62.17 180 bottom
RT48  4.7K_0201_5%  [R_0201]  27.47 61.41 180 bottom
RT49  4.7K_0201_5%  [R_0201]  27.47 60.77 180 bottom
RT50  0_0402_5%  [R_0402]  30.15 59.88 0 bottom
RT51  0_0402_1%  [R0402_0OHM]  58.42 24.37 90 bottom
RT52  0_0402_1%  [R0402_0OHM]  57.4 24.37 90 bottom
RT53  0_0402_5%  [R_0402]  56.39 24.37 90 bottom
RT54  0_0402_5%  [R_0402]  55.37 24.37 90 bottom
RT55  0_0402_5%  [R_0402]  54.43 24.39 180 bottom
RT56  0_1206_5%  [R_1206]  56.96 28.64 0 bottom
RT57  0_0402_1%  [R0402_0OHM]  57.4 22.47 90 bottom
RT58  10K_0402_5%  [R_0402]  56.39 22.47 90 bottom
RT59  0_0402_1%  [R0402_0OHM]  55.37 22.47 90 bottom
RT60  0_0402_1%  [R0402_0OHM]  54.36 22.47 90 bottom
RT61  0_0201_5%  [R0201_0OHM]  63 20.12 180 bottom
RT62  10K_0402_5%  [R_0402]  60.63 20.12 0 bottom
RT63  0_0201_5%  [R0201_0OHM]  63.03 19.24 180 bottom
RT64  10K_0402_5%  [R_0402]  60.63 19.24 0 bottom
RT65  0_0402_1%  [R0402_0OHM]  48.84 20 0 bottom
RT66  0_0201_5%  [R0201_0OHM]  63.03 18.23 180 bottom
RT67  10K_0402_5%  [R_0402]  60.63 18.23 0 bottom
RT69  100K_0402_5%  [R_0402]  62.53 17.21 0 bottom
RT70  100K_0402_5%  [R_0402]  61.54 17.21 180 bottom
RT72  3.3K_0402_1%  [R_0402]  62.53 16.19 0 bottom
RT73  100K_0402_5%  [R_0402]  61.54 16.19 180 bottom
RT74  1K_0201_5%  [R_0201]  50.63 16.19 0 bottom
RT75  0_0402_1%  [R0402_0OHM]  62.53 15.18 0 bottom
RT76  0_0402_1%  [R0402_0OHM]  60.63 15.18 0 bottom
RT77  0_0402_5%  [R_0402]  50.98 15.18 0 bottom
RT78  0_0402_5%  [R_0402]  49.21 15.33 0 bottom
RT79  4.7K_0201_5%  [R_0201]  63.79 14.04 180 bottom
RT80  0_0402_5%  [R_0402]  51.64 14.04 180 bottom
RT81  4.7K_0201_5%  [R_0201]  49.36 14.04 0 bottom
RT82  1K_0201_5%  [R_0201]  53.47 13.36 90 bottom
RT83  4.7K_0201_5%  [R_0201]  63.79 13.4 180 bottom
RT84  0_0402_5%  [R_0402]  62.23 12.94 90 bottom
RT85  0_0402_5%  [R_0402]  61.21 12.94 90 bottom
RT86  10K_0402_5%  [R_0402]  59.05 13.86 270 bottom
RT87  10K_0402_5%  [R_0402]  58.1 13.86 270 bottom
RT88  15K_0402_1%  [R_0402]  56.11 13.86 270 bottom
RT89  0_0402_5%  [R_0402]  51.64 13.02 180 bottom
RT90  4.7K_0201_5%  [R_0201]  49.36 13.02 0 bottom
RT91  1K_0201_5%  [R_0201]  53.47 12.68 270 bottom
RT92  0_0201_5%  [R_0201]  59.05 11.58 90 bottom
RT93  0_0201_5%  [R_0201]  58.04 11.58 90 bottom
RT94  10K_0402_5%  [R_0402]  62.43 11.62 180 bottom
RT95  0_0201_5%  [R_0201]  60.03 11.62 0 bottom
RT96  0_0402_5%  [R_0402]  56.01 11.16 90 bottom
RT97  0_0402_1%  [R0402_0OHM]  40.77 56.28 270 bottom
RT98  0_0402_1%  [R0402_0OHM]  59.44 24.37 90 bottom
RT99  1M_0201_5%  [R_0201]  31.81 60.56 270 bottom
RT100  1M_0201_5%  [R_0201]  41.66 56.36 270 bottom
RT101  1M_0201_5%  [R_0201]  64.26 16.03 90 bottom
RT102  1M_0201_5%  [R_0201]  52.3 23.5 180 bottom
RT103  10K_0402_1%  [R_0402]  41.1 69.93 0 bottom
RT104  100K_0402_1%  [R_0402]  42.88 69.93 0 bottom
RT105  10K_0402_1%  [R_0402]  48.84 19.12 0 bottom
RT106  100K_0402_1%  [R_0402]  49.76 20.89 180 bottom
RT107  0_0603_5%  [R0603_0OHM]  39.37 54.1 90 bottom
RT108  0_0603_5%  [R0603_0OHM]  64.14 18.16 90 bottom
RT109  0_0402_5%  [R_0402]  42.25 68.95 0 bottom
RT110  100K_0402_5%  [R_0402]  40.07 59.2 270 bottom
RT111  0_0402_5%  [R_0402]  50.81 21.95 90 bottom
RT112  100K_0402_5%  [R_0402]  61.65 21.9 0 bottom
RT113  0_0402_5%  [R_0402]  38.44 69.99 270 bottom
RT114  0_0402_5%  [R_0402]  39.33 69.99 270 bottom
RT115  0_0402_5%  [R_0402]  50.67 20.92 270 bottom
RT116  0_0402_5%  [R_0402]  49.91 21.95 90 bottom
RT117  0_0402_5%  [R_0402]  37.57 68.92 90 bottom
RT118  0_0402_5%  [R_0402]  36.68 68.92 90 bottom
RT119  100K_0402_5%  [R_0402]  17.46 67.71 0 bottom
RT120  100K_0402_5%  [R_0402]  17.46 66.82 0 bottom
RT121  0_0402_5%  [R_0402]  50.88 25.57 180 bottom
RT122  0_0402_5%  [R_0402]  50.88 24.66 180 bottom
RT123  100K_0402_5%  [R_0402]  50.48 12.09 0 bottom
RT124  100K_0402_5%  [R_0402]  50.5 10.97 0 bottom
RT125  10K_0201_5%  [R_0201]  29.08 70.3 270 bottom
RT126  10K_0201_5%  [R_0201]  49.38 14.61 0 bottom
RTCD1  -  [BAT54HT1G_SOD323-2]  155.3 104.61 315 bottom
RTCD2  -  [BAT54HT1G_SOD323-2]  154.15 103.34 315 bottom
RTCR1  1.2K_0402_5%  [R_0402]  152.58 101.73 315 bottom
RV2  0_0603_5%  [R0603_0OHM]  23.37 50.29 270 bottom
RV5  4.7K_0402_5%  [R_0402]  20.45 44.95 90 bottom
RV6  4.7K_0402_5%  [R_0402]  20.45 46.7 90 bottom
RV7  4.99K_0402_1%  [R_0402]  18.67 44.95 90 bottom
RV11  0_0201_5%  [R0201_0OHM]  16.89 38.29 90 bottom
RV12  4.7K_0402_5%  [R_0402]  15.86 33.59 0 bottom
RV13  4.7K_0402_5%  [R_0402]  15.86 32.7 0 bottom
RV14  0_0402_5%  [R_0402]  15.86 31.82 0 bottom
RV15  100K_0201_5%  [R_0201]  23.11 34.82 90 bottom
RV16  100K_0201_5%  [R_0201]  21.21 34.82 90 bottom
RV17  2M_0201_5%  [R_0201]  20.03 35.24 0 bottom
RV18  2M_0201_5%  [R_0201]  19.34 35.24 180 bottom
RV19  0_0402_5%  [R_0402]  16.89 44.95 90 bottom
RV20  1K_0402_5%  [R_0402]  27.57 48.86 90 bottom
RV21  1K_0402_5%  [R_0402]  26.68 48.86 90 bottom
RV26  0_0603_5%  [R0603_0OHM]  17.78 34.93 90 bottom
RV27  1K_0402_5%  [R_0402]  26.8 47.82 270 bottom
RV28  1K_0402_5%  [R_0402]  25.91 47.82 270 bottom
RV30  4.99K_0402_1%  [R_0402]  19.68 30.47 90 bottom
RV31  4.7K_0402_5%  [R_0402]  20.57 31.38 270 bottom
RV32  4.7K_0402_5%  [R_0402]  20.57 32.25 90 bottom
RV34  1K_0402_5%  [R_0402]  17.98 29.4 180 bottom
RV35  1K_0402_5%  [R_0402]  17.98 28.51 180 bottom
RV37  1K_0402_5%  [R_0402]  15.57 20.55 0 bottom
RV38  1K_0402_5%  [R_0402]  15.34 22.01 180 bottom
RV39  0_0201_5%  [R0201_0OHM]  16.61 21.31 90 bottom
RV40  4.7K_0402_5%  [R_0402]  18.24 22.16 180 bottom
RV41  4.7K_0402_5%  [R_0402]  18.24 21.27 180 bottom
RV42  0_0402_5%  [R_0402]  18.24 20.39 180 bottom
RV43  0_0402_5%  [R_0402]  17.78 32.25 90 bottom
RV44  100K_0201_5%  [R_0201]  23.88 20.47 90 bottom
RV45  100K_0201_5%  [R_0201]  21.97 20.47 90 bottom
RV46  2M_0201_5%  [R_0201]  20.66 20.77 0 bottom
RV47  2M_0201_5%  [R_0201]  19.98 20.77 180 bottom
RV50  1K_0402_5%  [R_0402]  24.59 20.82 0 bottom
RV53  1K_0402_5%  [R_0402]  24.59 19.93 0 bottom
RV57  1K_0201_5%  [R_0201]  24.38 34.82 90 bottom
RV58  1K_0201_5%  [R_0201]  23.69 34.82 90 bottom
RV59  1K_0201_5%  [R_0201]  30.73 26.77 270 top
RV60  1K_0201_5%  [R_0201]  27.18 26.82 90 top
RV61  0_0402_5%  [R_0402]  16 45.86 270 bottom
RV62  0_0402_5%  [R_0402]  17.88 31.36 0 bottom
RV65  0_0201_5%  [R_0201]  28.13 43.79 180 bottom
RV66  0_0201_5%  [R_0201]  25.86 43.46 0 bottom
RV67  0_0201_5%  [R_0201]  28.83 43.88 90 bottom
RV68  0_0201_5%  [R_0201]  25.86 44.65 0 bottom
RV69  0_0201_5%  [R_0201]  26.47 22.75 0 bottom
RV70  0_0201_5%  [R_0201]  26.47 22.15 0 bottom
RV71  0_0402_5%  [R_0402]  27.3 31.76 270 bottom
RV72  0_0402_5%  [R_0402]  28.19 30.85 90 bottom
RV73  0_0402_5%  [R_0402]  28.12 36.27 90 bottom
RV74  0_0402_5%  [R_0402]  29.11 37.15 270 bottom
RV75  1K_0201_5%  [R_0201]  19.46 46.57 90 bottom
RV76  1K_0201_5%  [R_0201]  19.46 45.32 90 bottom
RV77  1K_0201_5%  [R_0201]  26.92 45.52 90 bottom
RV78  1K_0201_5%  [R_0201]  28.12 44.97 180 bottom
RV79  1K_0201_5%  [R_0201]  26.35 45.51 90 bottom
RV80  1K_0201_5%  [R_0201]  25.78 46.1 270 bottom
RV81  1K_0201_5%  [R_0201]  20.31 33.9 0 bottom
RV82  1K_0201_5%  [R_0201]  19.72 32.81 270 bottom
RV83  1K_0201_5%  [R_0201]  26.59 29.41 90 bottom
RV84  1K_0201_5%  [R_0201]  27.19 30 270 bottom
RV85  1K_0201_5%  [R_0201]  25.98 29.41 90 bottom
RV86  1K_0201_5%  [R_0201]  25.41 30 270 bottom
RV87  0_0201_5%  [R_0201]  28.13 44.39 180 bottom
RV88  0_0201_5%  [R_0201]  25.86 44.06 0 bottom
RV89  0_0201_5%  [R_0201]  16.04 21.9 270 bottom
RV90  0_0201_5%  [R_0201]  18.69 27.83 90 bottom
RV91  0_0201_5%  [R_0201]  30.23 38.8 0 top
RV92  0_0201_5%  [R_0201]  31.62 35.63 180 top
RV93  0_0201_5%  [R_0201]  28.99 24.96 180 top
RV94  0_0201_5%  [R_0201]  28.54 28.01 0 top
RV95  0_0201_5%  [R0201_0OHM]  19.27 34.44 180 bottom
RV96  0_0201_5%  [R0201_0OHM]  19.27 33.86 180 bottom
RV97  0_0201_5%  [R0201_0OHM]  20.03 20.18 270 bottom
RV98  0_0201_5%  [R0201_0OHM]  20.61 20.18 270 bottom
RZ1  0_0402_1%  [R0402_0OHM]  69.11 97.65 90 top
RZ2  100K_0402_5%  [R_0402]  59.39 139 180 bottom
SW1  TAFG3-12WQR_3P  [SW_TAFG3-12WQR_3P]  3.65 154.28 270 top
SW2  TAFG3-12WQR_3P  [SW_TAFG3-12WQR_3P]  3.65 140.18 270 top
SW3  SKSFABE010_4P  [SW_SKSFABE010_4P]  41.89 104.12 270 top
SW5  BTE-PQR2_4P  [SW_BTE-PQR2_4P]  19.17 73.7 270 bottom
T1  PAD~D  [TPC12]  120.51 156.15 90 bottom
T2  PAD~D  [TPC12]  115.73 159.7 90 bottom
T3  PAD~D  [TPC12]  117.2 159.78 90 bottom
T4  PAD~D  [TPC12]  118.14 161.84 90 bottom
T5  PAD~D  [TPC12]  83.26 137.83 0 top
T6  PAD~D  [TPC12]  83.3 136.51 0 top
T7  PAD~D  [TPC12]  99.57 137.38 0 top
T8  PAD~D  [TPC12]  68.83 136.84 0 top
T9  PAD~D  [TPC12]  84.47 137.1 0 top
T10  PAD~D  [TPC12]  83.36 140.21 0 top
T15  PAD~D  [TPC12]  52.12 123.41 0 top
T18  PAD~D  [TPC12]  71.91 118.11 180 bottom
T20  PAD~D  [TPC12]  16.33 112.84 0 top
T22  PAD~D  [TPC12]  50.47 113.12 0 top
T23  PAD~D  [TPC12]  97.8 116.37 0 top
T24  PAD~D  [TPC12]  16.48 111.52 0 top
T25  PAD~D  [TPC12]  17.88 111.09 0 top
T26  PAD~D  [TPC12]  61.95 109.78 0 top
T27  PAD~D  [TPC12]  98.65 108.45 0 top
T28  PAD~D  [TPC12]  100.55 116.07 0 top
T29  PAD~D  [TPC12]  98.87 115.56 0 top
T30  PAD~D  [TPC12]  101.89 115.57 0 top
T31  PAD~D  [TPC12]  99.48 116.83 0 top
T32  PAD~D  [TPC12]  62.99 73.22 180 bottom
T33  PAD~D  [TPC12]  60.83 120.59 180 bottom
T34  PAD~D  [TPC12]  60.07 118.9 180 bottom
T36  PAD~D  [TPC12]  61.47 115.14 180 bottom
T37  PAD~D  [TPC12]  57.54 116.03 180 bottom
T38  PAD~D  [TPC12]  59.35 115.97 180 bottom
T39  PAD~D  [TPC12]  57 110.39 0 top
T40  PAD~D  [TPC12]  56.97 109.82 0 top
T41  PAD~D  [TPC12]  50.8 114.11 180 bottom
T42  PAD~D  [TPC12]  13.13 105.93 0 top
T57  PAD~D  [TPC12]  19.3 115.19 180 bottom
T58  PAD~D  [TPC12]  20 107.35 180 bottom
T59  PAD~D  [TPC12]  19.35 111.37 180 bottom
T60  PAD~D  [TPC12]  46.63 73.34 180 bottom
TC1  PAD~D  [TPC12]  52.17 125.03 0 top
TC2  PAD~D  [TPC12]  25.53 140.4 180 bottom
TC3  PAD~D  [TPC12]  23.95 140.6 180 bottom
TC4  PAD~D  [TPC12]  19.27 66.11 0 bottom
TC5  PAD~D  [TPC12]  19.27 67.5 0 bottom
TC6  PAD~D  [TPC12]  41.44 68.05 0 bottom
TC7  PAD~D  [TPC12]  31.76 68.96 0 bottom
TC8  PAD~D  [TPC12]  27.19 65.57 0 bottom
TC9  PAD~D  [TPC12]  26.85 64.34 0 bottom
TC10  PAD~D  [TPC12]  26.86 63.06 0 bottom
TC11  PAD~D  [TPC12]  25.91 61.03 0 bottom
TC12  PAD~D  [TPC12]  51.75 24.45 90 bottom
TC13  PAD~D  [TPC12]  49.4 16.19 90 bottom
TC14  PAD~D  [TPC12]  54.25 10.9 90 bottom
TC15  PAD~D  [TPC12]  52.86 10.99 90 bottom
TC16  PAD~D  [TPC12]  56.96 26.27 180 bottom
TC17  PAD~D  [TPC12]  40.77 54.29 180 bottom
TC18  PAD~D  [TPC12]  59.59 26.32 180 bottom
TC19  PAD~D  [TPC12]  42.74 70.66 180 bottom
TC20  PAD~D  [TPC12]  39.45 64.52 180 bottom
TC21  PAD~D  [TPC12]  55.6 26.3 180 bottom
TC22  PAD~D  [TPC12]  49.33 23.78 180 bottom
U1  SX9310ICSTRT_WLCSP9  [SX9310ICSTRT_WLCSP_9P]  117.61 158.83 180 bottom
U2  -  [TPS22967DSGR_SON8_2X2]  125.01 135.56 270 top
U3  -  [LIS2MDLTR_LGA12_2X2]  4.76 117.64 270 top
U4  -  [PI3PCIE3212ZBEX_TQFN20_2P5X4P5]  27.94 96.6 270 top
U7  -  [G517G1TO1U_TSOT23-5]  71.69 58.27 180 top
U8  -  [SY6288C20AAC_SOT23-5]  39.05 20.19 180 top
U9  -  [TPS79801QDGNRQ1_MSOP8]  143.6 139.11 180 bottom
U10  -  [EC646_LGA10_1P1X1P5]  109 167.11 90 top
U11  -  [TPS22967DSGR_SON8_2X2]  140.12 148.03 90 bottom
U12  TPS68470YFFR_DSBGA56  [TPS68470YFFR_DSBGA_56P]  151.95 143.96 180 bottom
U13  AOZ1331_DFN_14P  [TPS22966DPUR_SON14_2X3]  34.63 137.18 270 bottom
U14  AOZ1331_DFN_14P  [TPS22966DPUR_SON14_2X3]  22.32 134.89 180 bottom
U15  -  [TC7SH08FU_SSOP5]  35.13 122.62 180 bottom
U16  -  [G916T1UF_SOT23-5]  22.42 128.4 270 bottom
U17  AOZ1331_DFN_14P  [TPS22966DPUR_SON14_2X3]  19.04 85.1 90 bottom
U21  AOZ1331_DFN_14P  [TPS22966DPUR_SON14_2X3]  52.46 88.64 270 bottom
U22  -  [W25Q80DVZPIG_WSON8]  25.4 62.39 180 bottom
U23  -  [TC7SH08FU_SSOP5]  21.34 52.92 180 bottom
U44  -  [NL17SZ14DFT2G_SOT353-5]  144.41 130.69 180 bottom
U4245  -  [MC74VHC1G32DFT2G_SC70-5]  30.23 125.85 180 bottom
U4246  NPCT750JAAYX QFN 32P TPM  [NPCT650JBAYX_QFN32_5X5]  37.52 95.84 270 bottom
U4247  -  [G527ATP1U_TSOT23-6]  148.4 89.05 180 bottom
U4248  -  [G527ATP1U_TSOT23-6]  150.43 92.62 0 bottom
U4249  -  [G527ATP1U_TSOT23-6]  143.2 92.62 0 bottom
U4250  -  [G527ATP1U_TSOT23-6]  141.16 89.05 180 bottom
U4251  -  [G516A1Y51U_TSOT23-8]  127.15 89.62 180 bottom
U4252  -  [MC74VHC1G32DFT2G_SC70-5]  69.11 137.86 90 bottom
U4255  -  [TPS22967DSGR_SON8_2X2]  68.59 85.31 270 bottom
UA1  ALC3253-VA3-CG_MQFN48_6X6  [ALC3253-CG_MQFN48_6X6]  26.71 144.33 90 bottom
UC1  -  [74AUP1G07GW_TSSOP5]  98.29 119.21 270 top
UC2  -  [TC7SH08FU_SSOP5]  55.25 137.72 90 bottom
UC3  -  [74AHC1G09GW_TSSOP5]  46.29 137.65 90 bottom
UC4  -  [TC7SH08FU_SSOP5]  45.91 120.6 270 bottom
UC5  -  [TC7SH08FU_SSOP5]  37.91 119.71 270 bottom
UC7  -  [TC7SH08FU_SSOP5]  37.91 114.89 270 bottom
UC8  -  [TC7SH08FU_SSOP5]  37.91 112.41 270 bottom
UCPU1  SKL-U_BGA1356  [SKL-U_BGA_1356P-T]  53.98 134.82 180 top
UD1  H9CCNNN8JTMLAR-NTM_FBGA178~D  [H9CCNNN8JTMLAR-NTM_FBGA_178P]  84.64 92.38 180 top
UD2  H9CCNNN8JTMLAR-NTM_FBGA178~D  [H9CCNNN8JTMLAR-NTM_FBGA_178P]  90.86 102.72 0 top
UD3  H9CCNNN8JTMLAR-NTM_FBGA178~D  [H9CCNNN8JTMLAR-NTM_FBGA_178P]  84.64 102.78 180 bottom
UD4  H9CCNNN8JTMLAR-NTM_FBGA178~D  [H9CCNNN8JTMLAR-NTM_FBGA_178P]  90.86 92.32 0 bottom
UE3  MEC5105_WFBGA169_11X11  [MEC5105_WFBGA_169P]  30.33 108.8 90 bottom
UE5  -  [74AUP1G07GW_TSSOP5]  17.92 97.91 180 bottom
UE7  -  [74AUP1G07GW_TSSOP5]  36.56 124.21 0 bottom
UH1  -  [W25Q128JVEIQ_WSON8_8X6]  56.64 91.06 180 bottom
UR1  -  [RTS5242-GR_QFN32_4X4-S]  66.91 31.81 0 bottom
US1  TPS2544RTER_WQFN16_3X3  [TPS2544RTER_WQFN16_3X3-S]  34.19 99.26 90 top
UT1  TPS65982DCZQZR BGA 96P  [TPS65982_BGA_96P]  33.19 62.33 0 bottom
UT2  TPS65982DCZQZR BGA 96P  [TPS65982_BGA_96P]  58.63 15.6 90 bottom
UV1  PS8743AQFN40GTR-B1_QFN40_4X6  [PS8743AQFN40GTR-B0_QFN40_4X6]  20.7 43.25 270 bottom
UV2  PS8743AQFN40GTR-B1_QFN40_4X6  [PS8743AQFN40GTR-B0_QFN40_4X6]  20.82 28.9 270 bottom
UZ1  -  [TPS22961DNYR_WSON8]  67.17 100.07 0 top
UZ2  -  [TPS22961DNYR_WSON8]  60.82 136.89 90 bottom
UZ3  -  [TPS22961DNYR_WSON8]  51.14 132.95 180 bottom
UZ4  AOZ1331_DFN_14P  [TPS22966DPUR_SON14_2X3]  74.64 21.83 180 bottom
Y1  20MHZ_12PF_7V20000015  [Y_X3G024000DC1H_4P]  155.74 142.6 90 bottom
Y2  32.768KHZ_9.0PF_9H03200033  [Y_9H03200031_2P]  34.04 108.78 90 bottom
YC1  24MHZ_12PF_7M24090001  [Y_X3G024000DC1H_4P]  72.43 139.42 0 top
YC2  9PF 20PPM 9H03280012  [Y_9H03220008_2P]  58.82 102.05 0 top
YC3  24MHZ_18PF_XRCGB24M000F2P51R0  [Y_XRCGB24M000F2P51R0_4P]  49.62 129.5 0 top

## Library data of the parts
C1-C3 C5 C14 C15 C17 C18 = C_0201: room: UFCAM
C4 C6 = C_0402: room: UFCAM
C7 C11 C16 = C_0201: room: WFCAM
C8 = C_0201: room: SENSOR-PROXIMITY
C9 C101 C102 C105 C106 C108 = C_0201: room: WWAN
C10 = C_0402: room: WFCAM
C19 C20 = C_0201: room: VOLKEY
C21 = C_0402: room: FAN
C22-C24 = C_0402: room: DCDC1-TOUCH-PAD
C27 C29 = C_0402: room: TYPE-A
C28 C48 C215 C217 C219-C224 C226 C230 C236 C1036 C1037 C1039 C1121-C1124 C1126-C1129 C1133 C1134 CA6 CA49 CA50 CC5 CC7 CC8 CC11 CC13 CC40-CC42 CC64 CC92-CC94 CC96 CC97 CD100-CD103 CD105-CD108 CE8 CE10 CE15 CE18 CE19 CE25 CE48 CE49 CE54 CE55 CE88 CS1-CS3 CS5 CS7 CS9 CS10 CT5 CT7 CT8 CT13 CT14 CT25 CT26 CT28 CT33-CT37 CV19-CV36 CV39-CV60 CV63 CV64 PC1401-PC1420 = C_0201
C30 C31 C37 C39-C41 C47 C51 C59 C60 C73 C74 C83 C112 C135 C137 C147 C148 C154 C155 C167 C182 C188 C198 C200 C201 C205-C212 C225 C227 C228 C231 C232 C500-C504 C1034 C1035 C1040 C1120 C1125 C1130-C1132 C1136-C1138 CA10 CA12 CA37 CA46-CA48 CC95 CC98 CC99 CD104 CD109 CE1-CE4 CE9 CE11-CE14 CE21 CE24 CE26-CE30 CE57 CE64 CE65 CE78 CE86 CE87 CR12 CR14 CR22 CR23 CS4 CS6 CS8 CT6 CT9-CT12 CT15-CT24 CT27 CT29-CT32 CV1 CV2 CV9 CV10 CV17 CV18 CV61 CV62 PC127 PC140 PC144-PC151 PC281-PC286 PC327 PC328 PC337 PC338 PC348-PC352 PC416 PC526-PC528 PC531 PC536 PC818 PC819 PC1011 PC1012 PC1211-PC1216 PC1218 PC1221 PC1225 PC1229 PC1250 PC1423-PC1440 = C_0402
C32 C139-C143 CD42-CD45 = C_0402: room: PCIE
C38 PC1223 PC1224 PC1227 PC1228 PC1232 PC1248 PC1316 PC1317 PC1324 PC1325 PC1374 PC1375 = C_0805
C42 C169 C172 C174 C189 C190 C193 C196 MC1 = C_0402: room: EDP TS
C43 C44 C52 C56 C61-C64 C67 C71 C76 C88 = C_0402: room: CAM-PMIC
C45 C46 C49 C50 C53 C54 C57 C58 C65 C66 C68-C70 C72 C75 C77-C80 C86 C87 = C_0201: room: CAM-PMIC
C55 = C_0603: room: CAM-PMIC
C81 C82 C84 C85 C93 C94 = C_0402: room: DCDC1-3VAUDIO
C89-C92 C95 C96 = C_0402: room: DCDC1-5VAUDIO
C97 C98 = C_NEC: room: WWAN
C99 C103 = C_0603: room: WWAN
C100 C104 C107 = C_0402: room: WWAN
C110 C111 C115 = C_0201: room: TYPE-A
C113 C114 = C_0805: room: TYPE-A
C116-C121 = C_0402: room: DCDC1-WIFI-3VLS
C124 C126 C127 C129 C131 C132 = C_0402: room: DCDC1-SSD-LOADSW
C125 C128 = C_0201: room: TPM
C130 = C_0603: room: TPM
C133 C134 C136 C138 C144 C145 = C_0402: room: SIM
C146 C149 C152 C153 = C_0402: room: WLAN
C150 C151 C156 = C_0201: room: WLAN
C159 C163 = C_0201: room: TYPEC-P1
C160 C161 = C_0201: room: TBT-PORT
C165 CT2 = C_0402: room: TYPEC-P1
C175-C180 C191 = C_0201: room: EDP TS
C192 C195 C197 C199 = C_0201: room: TYPEC-P2
C194 C203 = C_0402: room: DCDC1-TOUCHLS
C202 CT3 = C_0402: room: TYPEC-P2
C229 C233 CA15 CA18 CA21 CA25 CA32 CC27 CC30 CE46 CE47 PC133 PC309 PC310 PC312 PC529 PC530 PC532-PC535 PC537 PC736 PC1010 PC1013 PC1014 PC1110 PC1125 PC1256 PC1322 PC1326-PC1328 PC1336 PC1363 PC1376 PC1377 PC1384-PC1395 PC1421 PC1422 = C_0603
C1038 = C_1206
CA1 CA2 CA5 CA13 CA14 CA16 CA23 CA24 CA26 CA27 CA30 CA33-CA36 CA41 = C_0201: room: AUDIOCODEC
CA3 CA4 CC3 CC4 CC14-CC20 CC22-CC26 CC28 CC32-CC39 CC44-CC46 CC48 CC50 CC51 CC54 CC56-CC58 CC60-CC63 CC67 CC69 CC70 CC78 CC79 CC81-CC85 CC90 CC91 = C_0402: room: MCP
CA7 CA8 = C_0201: room: JACK
CA9 CA11 = C_0402: room: JACK
CA17 CA28 CA38-CA40 = C_0402: room: AUDIOCODEC
CA19 CA20 CA22 CA29 CA31 = C_0603: room: AUDIOCODEC
CA42-CA45 = C_0402: room: SPK
CC1 CC2 CC49 CC53 CC65 CC66 CC68 CC71 CC72 CC74-CC77 CC80 = C_0201: room: MCP
CC29 CC43 CC47 CC52 CC73 = C_0805: room: MCP
CC55 CC59 CC86-CC88 = C_0603: room: MCP
CD1 CD17 CD49 CD73 = C_0603: room: CHB-DRAM0
CD2 CD31 CD32 CD40 CD41 CD59 = C_0603: room: CHA-DRAM0
CD3 CD12 CD50 CD80 = C_0603: room: CHA-DRAM1
CD4 CD8 CD25 CD26 CD34 CD52 CD53 CD55 CD66 CD68 CD70 CD72 CD75 CD78 CD85 = C_0402: room: CHB-DRAM1
CD5-CD7 CD13 CD15 CD19 CD28-CD30 CD33 CD35 CD47 CD51 CD76 CD82 = C_0402: room: CHB-DRAM0
CD9-CD11 CD14 CD16 CD18 CD21-CD24 CD27 CD36-CD38 CD83 = C_0402: room: CHA-DRAM0
CD20 CD46 CD67 = C_0402: room: DDR-VREF
CD39 CD54 CD56-CD58 CD60 CD61 CD63 CD65 CD69 CD71 CD74 CD77 CD79 CD84 = C_0402: room: CHA-DRAM1
CD48 CD62 CD64 CD81 = C_0603: room: CHB-DRAM1
CLIP1 CLIP2 CLIP13 = EMIST_SU-27AS_1P
CLIP3-CLIP12 CLIP14 = EMIST_SUL-12A2M_1P
CLRP1 PR118 PR142 PR143 PR156 PR158 PR160 PR166 PR172 PR174-PR179 PR213-PR215 PR220-PR222 PR228 PR229 PR250-PR252 PR259 PR262-PR264 PR269-PR272 R73 R74 R76 R83-R88 R428-R431 R434 R435 R447 R480 R481 R487-R490 R492-R494 R2745 R5751-R5759 R5767 R5771-R5776 R5778 R5779 RA10 RA15 RA19 RA27 RA28 RA30 RA40 RC180-RC183 RC187 RC188 RC192-RC196 RC198 RC205 RC206 RC374 RC377 RC378 RC380 RC381 RC391-RC393 RC396-RC399 RD21-RD82 RE1-RE8 RE16 RE17 RE20 RE24-RE27 RE30-RE33 RE35 RE38 RE40 RE42 RE45 RE46 RE51-RE56 RE61-RE65 RE67-RE70 RE110-RE113 RE115-RE118 RE122 RE123 RE250 RE251 RE258 RE259 RE262 RE266-RE270 RH5 RH7 RH8 RH90 RH91 RH505 RS6 RS9-RS11 RS18 RS19 RS22-RS24 RT2-RT8 RT10 RT13 RT14 RT26 RT30 RT33 RT35 RT36 RT47-RT49 RT74 RT79 RT81-RT83 RT90-RT93 RT95 RT99-RT102 RT125 RT126 RV15-RV18 RV44-RV47 RV57-RV60 RV65-RV70 RV75-RV94 = R_0201
CMOS1 RH28 RH31 = SHORTPADS: User Part Number: PART#; room: MCP
CR1-CR11 CR13 CR15-CR21 = C_0402: room: CARD READER
CT1 = C_0603: room: TYPEC-P1
CT4 = C_0603: room: TYPEC-P2
CZ1 CZ4 CZ6 = C_0402: room: DCDC2-VCCSTG
CZ2 CZ3 = C_0402: room: DCDC2-VCCPLL
CZ5 CZ8 = C_0402: room: DCDC2-1.0V
CZ7 CZ9 CZ10 = C_0402: room: DCDC2-1.0MPHYGT
D1-D19 = ESD101-B1-02ELS_TSSLP-2-4-2
D20 D21 = ESD207-B1-02EL_TSLP-2-19-2: room: VOLKEY
D22 = RB520SM-30T2R_EMD2-2: room: FAN
D39 D40 D60 = BAT54CW-7-F_SOT323-3: room: EDP TS
D48-D53 D68-D70 D72-D78 = ESD101-B1-02ELS_TSSLP-2-4-2: room: TYPEC-P1
D54-D59 D79-D81 D83-D89 = ESD101-B1-02ELS_TSSLP-2-4-2: room: TYPEC-P2
D61 D115 = BAT54CW-7-F_SOT323-3
D62-D65 = ESD207-B1-02EL_TSLP-2-19-2: room: SIM
D71 = ESD3V3S1B-02LS_PG-TSSLP-2-1-2: room: TYPEC-P1
D82 = ESD3V3S1B-02LS_PG-TSSLP-2-1-2: room: TYPEC-P2
D91 D92 D94 D95 D105-D114 D116 PD103 PD106 PD110 PD111 PD302 PD303 = RB520SM-30T2R_EMD2-2
DA1 DA3-DA6 = ESD207-B1-02EL_TSLP-2-19-2: room: JACK
DA8 DA9 = TVNST52302AB0_SOT523-3: room: SPK
DI1 = TVNST52302AB0_SOT523-3: room: EDP TS
FD1-FD4 = FIDUCIAL_C40M80: room: SCREW
H1 H3 H4 H6 H9 = H_2P3-G: room: SCREW
H2 = H_2P3-G
H5 H10 H11 H13 = H_3P3: room: SCREW
H7 = H_4P0-G: room: SCREW
H8 = H_4P0-G
H12 = H_3P6-G
H14 H15 = H_6P0N
H16 H17 = H_1P5N
JANT1 JANT2 = CLIP_2P8X2P5-S: room: SENSOR-PROXIMITY
JANT3 = BELLW_10093-1021_4P: room: WWAN
JANT7 = CLIP_2P8X2P5-S
JAPS1 = ACES_50506-01841-P01_18P: room: MCP
JCR1 = T-SOL_158-1000902614_23P-T: room: CARD READER
JDEG3 JESPI1 JSPI2 = ACES_50521-01041-P01_10P
JEDP1 = ACES_50398-05071-001_50P-T: room: EDP TS
JFAN1 = ACES_50224-00401-001_4P: room: FAN
JIO1 = JAE_WP7B-S040VA1-R6000_40P-T: room: IOB-CONN
JIO2 = ACES_51522-03001-P01_30P
JIR1 = ACES_50208-01201-P01_12P
JNGFF1 = LOTES_APCI0144-P007A_75P: room: WWAN
JNGFF2 = LOTES_APCI0146-P004A_75P: room: PCIE
JNGFF3 = LOTES_APCI0145-P004A_75P: room: WLAN
JP1 = SINGA_2SJ3157-001111F_6P-T
JRTC1 = ACES_50278-00201-001_2P: room: RTC
JSIM1 = JAE_SF56S006V4A_6P-T: room: SIM
JSPK = ACES_50376-00601-001_6P-T
JT100 = ACES_50278-01201-001_12P-T: room: PWR_DCIN
JUART = CVILU_CI1804M1VRA-NH_4P
JUFC1 = HRS_DF37NC-30DS-0P4V-51_30P-T
JUSB1 = TAIWI_USB036-10B7CRL-TW_10P-T: room: TYPE-A
JUSBC1 = JAE_DX07S024XJ2_24P-T: room: TYPEC-P1
JUSBC2 = JAE_DX07S024XJ2_24P-T: room: TYPEC-P2
JWFC1 = JAE_WP7B-S034VA1_34P-T
JXDP1 = JXT_FP270H-061G1AM_61P: room: MCP
L9 L10 = MURAT_DLW21HN900HQ2L_4P: room: WWAN
L12 L15 = MURAT_BLM15PX330SN1D_2P: room: JACK
L13 L14 = MURAT_LQG15HS22NJ02D_2P
L16 L17 = MURAT_BLM15AG121SN1D_L0402_2P
L18 L19 = MURAT_BLM15AX100SN1D_2P: room: JACK
L20 L21 = MURAT_BLM15HD182SN1D_2P: room: CAM-PMIC
L22 = TOKO_1269AS-H-1R0M-P2_2P: room: CAM-PMIC
L23 L30 = MURAT_BLM18EG221SN1D_2P
L24 ML8 = INPAQ_HCM1012GH900BP_4P: room: WLAN
L31 L32 = MURAT_BLM18SG221TN1D_2P
L80 L81 = MURAT_LQP03TN1N8B00D_2P
LA1 = MURAT_BLM21PG600SN1D_2P: room: AUDIOCODEC
LA2 LA3 = R_0603: room: AUDIOCODEC
LA5-LA8 = MURAT_BLM15PX181SN1D_2P: room: SPK
LED4 LED5 = LED_HT-191UD5_2P
LGA1 = LSM6DS3USTR_LGA14_2P5X3
LS1 = MURAT_LQG15HS10NJ02D_2P
LT1 = TAI-T_HCB2012KF-121T50_2P: room: TYPEC-P1
LT2 = TAI-T_HCB2012KF-121T50_2P: room: TYPEC-P2
MD1 = AZ1065-06QPRDG_MSOP8: room: TYPE-A
MIC1-MIC3 = CIRRU_WM7216IMSE-RV_5P: room: AUDIOCODEC
ML1 ML2 = MURAT_DLW21SN670HQ2L_4P: room: WWAN
ML3 = MURAT_DLW21HN900HQ2L_4P
ML4 ML5 = MURAT_DLW21SN670HQ2L_4P: room: TYPE-A
ML6 = MURAT_DLW21HN900HQ2L_4P: room: TYPE-A
ML7 ML14 = INPAQ_HCM1012GH900BP_4P
ML9 ML10 = INPAQ_MCM1012B900F06BP_4P: room: TYPEC-P1
ML11 ML12 = INPAQ_MCM1012B900F06BP_4P: room: TYPEC-P2
PC100 PC101 PC103 PC106 PC108-PC112 PC116 PC117 PC120-PC124 PC126 PC129 PC131 PC132 = C_0402: room: PWR_DCIN
PC102 PC104 PC105 PC114 PC118 PC119 PC125 PC130 = C_0201: room: PWR_DCIN
PC107 PC115 PC128 PC134 = C_0603: room: PWR_DCIN
PC280 = C_0402: room: PWR_BATT_SHIP
PC301 PC303 PC306 PC313 PC314 PC321 PC329 PC331 PC334 PC335 PC339-PC343 PC345 PC347 = C_0402: room: PWR_CHARGER
PC302 PC304 PC305 PC307 PC308 PC315-PC320 PC322-PC326 PC330 PC332 PC333 PC336 PC346 = C_0603: room: PWR_CHARGER
PC400 PC403-PC406 PC418 = C_0603: room: PWR_LCD
PC401 = C_0805: room: PWR_LCD
PC402 PC407-PC415 PC417 = C_0402: room: PWR_LCD
PC500-PC502 PC505 PC510 = C_0402: room: PWR_+3VALW
PC503 PC504 PC506-PC509 PC511 = C_0603: room: PWR_+3VALW
PC513-PC515 PC518 PC523 = C_0402: room: PWR_+5VALW
PC516 PC517 PC519-PC522 PC524 = C_0603: room: PWR_+5VALW
PC600-PC602 PC608-PC615 PC700 PC701 PC703 PC704 PC707 PC712 PC720 PC721 PC723 PC724 PC726-PC729 PC731 PC732 PC734 PC735 PC800 PC806-PC810 PC816 PC817 = C_0402: room: ISL95908
PC603-PC607 PC702 PC705 PC706 PC708-PC711 PC713 PC722 PC725 PC730 PC733 PC801-PC805 PC811-PC815 = C_0603: room: ISL95908
PC900 PC903-PC906 PC911 PC931-PC933 = C_0402: room: ISL95859
PC901 PC902 PC907 = C_0603: room: ISL95859
PC1003 PC1028 PC1030 = C_PSKV151D476M045C: room: VCC_VCORE
PC1007 PC1008 = C_0402: room: VCC_VCORE
PC1009 = C_0603: room: VCC_VCORE
PC1103-PC1105 PC1107-PC1109 PC1111 PC1113-PC1117 PC1119-PC1122 PC1124 PC1126 = C_0603: room: VCC_GT_SA
PC1106 PC1112 PC1118 PC1123 = C_0402: room: VCC_GT_SA
PC1200-PC1202 = C_B2: room: VCC_MLCC-VCC_CORE
PC1203 = C_B2
PC1207-PC1209 = C_B2: room: VCC_MLCC-VCCGT
PC1210 = C_0402: room: VCC_MLCC-VCCGT
PC1217 = C_B2: room: VCC_MLCC-VCCSA
PC1220 PC1222 PC1246 PC1247 PC1251-PC1255 PC1258 PC1279 PC1306 PC1329-PC1331 PC1335 PC1337 PC1361 PC1366 PC1368 PC1369 = C_0603: room: VCC_MLCC-VCC_CORE
PC1230 PC1231 PC1312 PC1314 PC1315 PC1319-PC1321 PC1357-PC1359 = C_0805: room: VCC_MLCC-VCCGT
PC1233 PC1234 PC1313 PC1318 = C_0603: room: VCC_MLCC-VCCGT
PC1237 = C_0603: room: VCC_MLCC-VCCSA
PC1259-PC1263 PC1265-PC1270 PC1285 PC1287-PC1296 PC1339-PC1341 PC1355 PC1356 PC1360 = C_0201: room: VCC_MLCC-VCCGT
PC1272-PC1276 PC1278 PC1281-PC1284 PC1297-PC1305 PC1309 PC1311 PC1323 PC1362 PC1364 PC1365 PC1370 = C_0201: room: VCC_MLCC-VCC_CORE
PD104 PD105 = TVNST52302AB0_SOT523-3
PD280 = BAT54CW_SOT323-3: room: PWR_BATT_SHIP
PD300 PD301 = DB2J31400L_SOD323-2
PD400 = DFLS160-7_POWERDI123-2: room: PWR_LCD
PD906 = SMF22A-SOD123FL-2-S
PJP500 = JUMP_43X118: room: PWR_+3VALW
PJP501 = JUMP_43X118: room: PWR_+5VALW
PJP502 = JUMP_43X118
PJP600 PJP700 PJP800 = JUMP_43X79: room: ISL95908
PJP601 PJP720 PJP721 = JUMP_43X39
PJP801 = JUMP_43X79
PL100-PL103 = TAI-T_HCB2012KF-121T50_2P: room: PWR_DCIN
PL301 = MAG_MMD-10BZN2R2M-M1L_2P
PL302 PL801 PL803 = TOKO_1277AS-H-1R0N-P2_2P
PL400 = MAG_MLPS-5020-100M-E_2P: room: PWR_LCD
PL500 = TAI-T_HCB2012KF-121T50_2P: room: PWR_+3VALW
PL501 = MAG_MMD-05AHN1R5M-M1L_2P: room: PWR_+3VALW
PL502 PL504 = TAI-T_HCB2012KF-121T50_2P: room: PWR_+5VALW
PL503 = MAG_MMD-05AHN1R5M-M1L_2P: room: PWR_+5VALW
PL505 = MAG_MMD-05AHN1R5M-M1L_2P
PL600 = CHILI_MHCI05015B-1R0M-R8A_2P: room: ISL95908
PL601 PL700 = TAI-T_HCB2012KF-121T50_2P: room: ISL95908
PL701 = CHILI_MHCI04012-1R0M-R8EQ_2P: room: ISL95908
PL720 PL722 PL802 = TAI-T_HCB1608KF-121T3_L0603_2P
PL721 PL723 = TOKO_1239AS-H-2R2N-P2_2P
PL800 = TAI-T_HCB1608KF-121T3_L0603_2P: room: ISL95908
PL1000 PL1002 = TAI-T_HCB2012KF-121T50_2P
PL1100-PL1102 = MAG_MMD-10BD-R15MEM2L_2P: room: VCC_GT_SA
PL1103 = CHILI_MHCI06015-R47MR8A7R45_2P
PQ100-PQ103 PQ113 PQ114 = AON7405_DFN8-5: room: PWR_DCIN
PQ104 PQ115 = SI1303DL-T1-E3_SOT323-3: room: PWR_DCIN
PQ106 PQ108 PQ110-PQ112 PQ118 PQ119 PQ126 = DMN65D8LW-7_SOT323-3: room: PWR_DCIN
PQ109 PQ120 PQ121 PQ125 PQ127 = DMN66D0LDW-7_SOT363-6: room: PWR_DCIN
PQ122 PQ128 PQ129 PQ134 PQ136 PQ139 QC2 QC3 QE13 QE14 = DMN66D0LDW-7_SOT363-6
PQ123 PQ124 PQ133 PQ135 PQ138 = SI1303DL-T1-E3_SOT323-3
PQ130-PQ132 PQ140-PQ142 PQ308 = DMN65D8LW-7_SOT323-3
PQ280 = DMN65D8LW-7_SOT323-3: room: PWR_BATT_SHIP
PQ302 = AON6380_DFN5X6-8-5: room: PWR_CHARGER
PQ304 = AON7405_DFN8-5: room: PWR_CHARGER
PQ305 PQ306 = AON6508_DFN8-5: room: PWR_CHARGER
PQ307 = AON6508_DFN8-5
PR100 PR102-PR106 PR108-PR110 PR112 PR119 PR121 PR122 PR128 PR130 PR132-PR134 PR137 PR149 PR150 PR152-PR154 = R_0402: room: PWR_DCIN
PR101 PR107 PR115 PR124 PR127 PR129 PR139 PR148 PR151 PR155 = R_0201: room: PWR_DCIN
PR111 PR113 PR117 PR120 PR126 PR157 PR161-PR165 PR167 PR182-PR185 PR192 PR200 PR202-PR204 PR206-PR209 PR216 PR218 PR219 PR225 PR230 PR248 PR249 PR253 PR255-PR258 PR261 PR265-PR267 PR312 PR331-PR334 PR336 PR338 PR341-PR343 PR345-PR347 PR351 PR410-PR415 PR418-PR420 PR514-PR519 PR612 PR720-PR722 PR724 PR725 PR727-PR729 PR731 PR732 PR734 PR735 PR820-PR823 PR825 PR826 PR944 PR945 PR951-PR956 PR1200-PR1202 R31 R32 R154-R157 R214-R218 R233-R235 R279 R280 R411 R418 R427 R439 R442 R444 R446 R449 R451 R460 R464-R468 R470-R474 R479 R485 R486 R495 R2751 R5764-R5766 R5768 R5769 R5777 R5780 RA12 RA16 RA17 RA24 RA26 RA29 RA31-RA33 RA36 RA39 RC8 RC15 RC16 RC68 RC84 RC149 RC178 RC179 RC189-RC191 RC197 RC199 RC200 RC202 RC204 RC383-RC386 RC389 RC394 RC395 RE9 RE10 RE12-RE15 RE29 RE36 RE44 RE48 RE50 RE58 RE97-RE100 RE114 RE120 RE124 RE125 RE141 RE142 RE152 RE154 RE157 RE168 RE172 RE174 RE183 RE193 RE194 RE196 RE215 RE219 RE222 RE246 RE247 RE253 RE264 RE265 RH6 RR12 RS3-RS5 RT15 RT16 RT18 RT19 RT21-RT25 RT27 RT29 RT32 RT37 RT42-RT44 RT50 RT53-RT55 RT58 RT62 RT64 RT67 RT69 RT70 RT72 RT73 RT77 RT78 RT80 RT84-RT89 RT94 RT96 RT103-RT106 RT109-RT124 RTCR1 RV5-RV7 RV12-RV14 RV19-RV21 RV27 RV28 RV30-RV32 RV34 RV35 RV37 RV38 RV40-RV43 RV50 RV53 RV61 RV62 RV71-RV74 = R_0402
PR114 PR123 PR135 PR136 PR138 PR145 = R0402_0OHM: room: PWR_DCIN
PR116 = R_0603: room: PWR_DCIN
PR125 PR144 PR146 PR201 PR217 PR224 PR416 PR417 PR709 PR726 PR733 PR824 R219 R412-R417 R419-R421 R432 R433 R438 R443 R445 R450 R455 R456 R475 R476 R5749 RA38 RA41-RA43 RC170 RE19 RE47 RE248 RE252 RS1 RS2 RS17 RS20 RT11 RT17 RT20 RT28 RT31 RT34 RT45 RT46 RT51 RT52 RT57 RT59 RT60 RT65 RT75 RT76 RT97 RT98 = R0402_0OHM
PR147 = R_0805: room: PWR_DCIN
PR231 = R_0805: room: PWR_BATT_LOW
PR268 PR507 PR512 PR723 PR1204 R425 R448 R453 R484 R501 R502 RC104 RC105 RC117 RC118 RC185 RC186 RE195 = R_0603
PR280-PR285 = R_0402: room: PWR_BATT_SHIP
PR300 PR310 = R_1206_4P-D: room: PWR_CHARGER
PR301 PR302 PR305 PR307 PR308 PR313-PR315 PR318 PR319 PR322-PR325 PR327-PR330 = R_0402: room: PWR_CHARGER
PR303 PR309 PR316 PR317 = R_1206: room: PWR_CHARGER
PR306 PR311 = R_0603: room: PWR_CHARGER
PR400 = R_0603: room: PWR_LCD
PR401-PR405 PR407 PR408 = R_0402: room: PWR_LCD
PR406 = R_0201: room: PWR_LCD
PR409 = R0402_0OHM: room: PWR_LCD
PR500 = R0402_0OHM: room: PWR_+3VALW
PR501 = R_0603: room: PWR_+3VALW
PR502 = R_0805: room: PWR_+3VALW
PR503 = R_0402: room: PWR_+3VALW
PR504-PR506 PR509 PR510 = R_0402: room: PWR_+5VALW
PR508 = R_0805: room: PWR_+5VALW
PR511 = R0402_0OHM: room: PWR_+5VALW
PR513 PR730 PR1203 R275-R278 = R_0805
PR600 PR603-PR609 PR611 PR700 PR701 PR704-PR708 PR800 PR801 PR803-PR805 PR807-PR809 PR812-PR818 = R_0402: room: ISL95908
PR601 PR702 PR703 PR806 PR819 = R_0603: room: ISL95908
PR602 = R_0805: room: ISL95908
PR610 PR810 PR811 = R0402_0OHM: room: ISL95908
PR900 PR901 PR903 PR904 PR906 PR907 PR910-PR943 PR946-PR950 = R_0402: room: ISL95859
PR1101 PR1103 PR1118 PR1126 = R_0402: room: VCC_GT_SA
PR1106 PR1108 PR1117 PR1125 = R_0805: room: VCC_GT_SA
PT100-PT103 T1-T4 T20 T42 T57-T60 TC1 TC4-TC22 = TPC12
PU101 = RT9069-33GB_SOT23-5: room: PWR_DCIN
PU103-PU105 = AS331KTR-G1_SOT23-5
PU280 = SN74LVC1G123DCUR_VSSOP8: room: PWR_BATT_SHIP
PU300 = ISL88738HRTZ-T_TQFN32_4X4
PU301 = MC74VHC1G08DFT2G_SC70-5
PU400 = TPS61188ARUYR_QFN28_4X4-S: room: PWR_LCD
PU500 = NB680GD-Z_QFN12_2X3: room: PWR_+3VALW
PU501 = NB679AGD-Z_QFN12_2X3: room: PWR_+5VALW
PU502 = NB679GD-Z_QFN12_2X3
PU600 = NB685GQ-Z_QFN16_3X3: room: ISL95908
PU700 = SY8286RAC_QFN20_3X3
PU720 PU721 = TLV62150RGTR_QFN16_3X3-S
PU800 = TPS62134ARGT_QFN16_3X3-S
PU801 = TPS62134BRGT_QFN16_3X3-S
PU900 = MP2949GU-LF-Z_QFN48_6X6: room: ISL95859
PU1005 PU1006 PU1107 = MP86901-CGLT-Z_TQFN21_3X4
PU1108 = MP86901-AGQT-Z_TQFN13_3X3
Q1 = DMN2400UV-7_SOT-563-6: room: SENSOR-PROXIMITY
Q2 Q6-Q8 Q11 Q31 QE16 = MMBT3904WH_SOT323-3
Q9 = DMN2400UV-7_SOT-563-6: room: CAM-PMIC
Q10 Q12 Q16 Q22 Q29 Q32 Q348 Q351 Q353 Q356 Q357 QE15 = SSM3K7002FU_SC70-3
Q25 Q26 Q354 = DMN2400UV-7_SOT-563-6
Q33 = SI3457BDV-T1-E3_TSOP6
Q349 Q352 QZ9 = DMG2301U-7_SOT23-3
QR1 = DMN2400UFB4-7_DFN1006H4-3: room: CARD READER
R1 R2 R4 R6-R8 = R0402_0OHM: room: UFCAM
R3 R5 RH1 RH2 = R_0201: room: UFCAM
R9 R12 R13 R16-R22 = R0402_0OHM: room: WFCAM
R11 = R0201_0OHM: room: WFCAM
R14 R15 = R_0201: room: WFCAM
R23 R24 = R_0201: room: VOLKEY
R26 = R0402_0OHM: room: DCDC2-VCCSTG
R27-R29 = R_0402: room: FAN
R30 = R0603_0OHM: room: DCDC1-TOUCH-PAD
R33 R35 R124 R125 = R_0201: room: WWAN
R38 R122 = R0402_0OHM: room: WWAN
R48 = R0603_0OHM: room: DCDC2-VCCPLL
R50 R51 R54 R56 = R_0402: room: TYPE-A
R57 R64 R65 = R_0402: room: PCIE
R59 R60 R66 = R0402_0OHM: room: PCIE
R61 R67 = R_0201: room: EDP TS
R72 = R0805_0OHM
R75 = R0603_0OHM: room: EDP TS
R77 R78 R104 R107 R108 = R_0402: room: CAM-PMIC
R79 R90 R98 R102 R105 R106 R113 R116 = R0603_0OHM: room: CAM-PMIC
R81 R82 R477 R478 R513 R5770 RA44 RE119 RE121 RE245 RE261 RS7 RS8 RS15 RS16 RS25-RS27 RT38-RT40 RT61 RT63 RT66 RV11 RV39 RV95-RV98 = R0201_0OHM
R91-R93 R95-R97 R99 R100 RH24-RH27 = R_0201: room: CAM-PMIC
R94 R205 R223 R266 R454 R457 R5750 R5781 RE11 RT107 RT108 RV2 RV26 = R0603_0OHM
R101 R115 = R0402_0OHM: room: CAM-PMIC
R109 R110 R117 = R_0402: room: DCDC1-5VAUDIO
R111 R112 = R0603_0OHM: room: DCDC1-3VAUDIO
R114 = R0805_0OHM: room: DCDC1-5VAUDIO
R118 = R0603_0OHM: room: DCDC2-1.0V
R119 = R0603_0OHM: room: DCDC1-5VAUDIO
R120 = R0603_0OHM: room: DCDC2-1.0MPHYGT
R121 RC35 RC41 RC58 RC60-RC65 RC85 RC89 RE49 RH3 RH4 RH11 RH14 = R_0201: room: MCP
R123 = R_0402: room: WWAN
R139 = R_0402: room: DCDC1-WIFI-3VLS
R140 = R0805_0OHM: room: DCDC1-WIFI-3VLS
R145 R152 = R0805_0OHM: room: DCDC1-SSD-LOADSW
R146-R151 = R_0402: room: DCDC1-SSD-LOADSW
R153 = R_0603: room: TPM
R158-R160 = R_0201: room: WLAN
R161 = R0402_0OHM: room: WLAN
R204 = R0603_0OHM: room: DCDC1-TOUCHLS
R209 = R_0402: room: DCDC1-TOUCHLS
R210 R211 = R_0402: room: DCDC1-TOUCH-PAD
RA1 RA2 = R_0201: room: JACK
RA3 RA6 = R_0402: room: JACK
RA7 = R0201_0OHM: room: JACK
RA8 RA9 RA21 = R_0201: room: AUDIOCODEC
RA11 RA22 RA23 RA25 = R0402_0OHM: room: AUDIOCODEC
RA13 RA14 RA18 = R_0402: room: AUDIOCODEC
RC1 RC47 RC128 RC129 RC156 = R0402_0OHM: room: MCP
RC2 RC3 RC5-RC7 RC9-RC14 RC17-RC34 RC36-RC40 RC42-RC46 RC48-RC51 RC53 RC55 RC56 RC59 RC66 RC67 RC69-RC78 RC80-RC83 RC86-RC88 RC90-RC97 RC99 RC100 RC102 RC106-RC109 RC111-RC116 RC119-RC124 RC126 RC127 RC131 RC132 RC136-RC138 RC140-RC144 RC147 RC150-RC155 RC157-RC169 RH9 RH10 RH12 RH13 RH15-RH21 RH29 RH30 RN1 RN2 = R_0402: room: MCP
RC103 RC125 RC130 RC133 RC134 RC139 = R0603_0OHM: room: MCP
RD1 RD2 = R_0402: room: CHA-DRAM1
RD3-RD6 RD9-RD12 RD15-RD18 = R_0402: room: DDR-VREF
RD7 RD8 = R_0402: room: CHB-DRAM1
RD13 RD14 = R_0402: room: CHB-DRAM0
RD19 RD20 = R_0402: room: CHA-DRAM0
RE41 = SHORTPADS: User Part Number: PART#
RP2 RP3 = RP_0804_8P4R: room: MCP
RR1-RR4 RR6 RR8-RR11 = R_0402: room: CARD READER
RR5 RR7 = R0402_0OHM: room: CARD READER
RT41 RT56 = R_1206
RTCD1 RTCD2 = BAT54HT1G_SOD323-2
RZ1 = R0402_0OHM: room: DCDC2-VCCPLL
RZ2 = R_0402: room: DCDC2-VCCSTG
SW1 SW2 = SW_TAFG3-12WQR_3P: room: VOLKEY
SW3 = SW_SKSFABE010_4P
SW5 = SW_BTE-PQR2_4P
T5-T10 T15 T18 T22 T23 T26-T31 T33 T34 T36-T41 = TPC12: room: MCP
T24 T25 = TPC12: room: WWAN
T32 = TPC12: room: PCIE
TC2 TC3 = TPC12: room: AUDIOCODEC
U1 = SX9310ICSTRT_WLCSP_9P: room: SENSOR-PROXIMITY
U2 U11 U4255 = TPS22967DSGR_SON8_2X2
U3 = LIS2MDLTR_LGA12_2X2: room: SENSOR-ECOMPASS
U4 = PI3PCIE3212ZBEX_TQFN20_2P5X4P5
U7 = G517G1TO1U_TSOT23-5
U8 = SY6288C20AAC_SOT23-5: room: EDP TS
U9 = TPS79801QDGNRQ1_MSOP8: room: CAM-PMIC
U10 = EC646_LGA10_1P1X1P5
U12 = TPS68470YFFR_DSBGA_56P: room: CAM-PMIC
U13 = TPS22966DPUR_SON14_2X3: room: DCDC1-5VAUDIO
U14 = TPS22966DPUR_SON14_2X3: room: DCDC1-3VAUDIO
U15 UC5 UC7 UC8 = TC7SH08FU_SSOP5
U16 = G916T1UF_SOT23-5
U17 = TPS22966DPUR_SON14_2X3: room: DCDC1-WIFI-3VLS
U21 = TPS22966DPUR_SON14_2X3: room: DCDC1-SSD-LOADSW
U22 = W25Q80DVZPIG_WSON8: room: USH-PWR
U23 = TC7SH08FU_SSOP5: room: WLAN
U44 = NL17SZ14DFT2G_SOT353-5
U4245 U4252 = MC74VHC1G32DFT2G_SC70-5
U4246 = NPCT650JBAYX_QFN32_5X5
U4247-U4250 = G527ATP1U_TSOT23-6
U4251 = G516A1Y51U_TSOT23-8
UA1 = ALC3253-CG_MQFN48_6X6: room: AUDIOCODEC
UC1 = 74AUP1G07GW_TSSOP5: room: MCP
UC2 = TC7SH08FU_SSOP5: room: DCDC2-VCCSTG
UC3 = 74AHC1G09GW_TSSOP5: room: MCP
UC4 = TC7SH08FU_SSOP5: room: MCP
UCPU1 = SKL-U_BGA_1356P-T: room: MCP
UD1 = H9CCNNN8JTMLAR-NTM_FBGA_178P: room: CHB-DRAM1
UD2 = H9CCNNN8JTMLAR-NTM_FBGA_178P: room: CHA-DRAM1
UD3 = H9CCNNN8JTMLAR-NTM_FBGA_178P: room: CHB-DRAM0
UD4 = H9CCNNN8JTMLAR-NTM_FBGA_178P: room: CHA-DRAM0
UE3 = MEC5105_WFBGA_169P
UE5 UE7 = 74AUP1G07GW_TSSOP5
UH1 = W25Q128JVEIQ_WSON8_8X6: room: MCP
UR1 = RTS5242-GR_QFN32_4X4-S: room: CARD READER
US1 = TPS2544RTER_WQFN16_3X3-S: room: TYPE-A
UT1 UT2 = TPS65982_BGA_96P
UV1 = PS8743AQFN40GTR-B0_QFN40_4X6: room: RE-TYPEC
UV2 = PS8743AQFN40GTR-B0_QFN40_4X6
UZ1 = TPS22961DNYR_WSON8: room: DCDC2-VCCPLL
UZ2 = TPS22961DNYR_WSON8: room: DCDC2-VCCSTG
UZ3 = TPS22961DNYR_WSON8: room: DCDC2-1.0V
UZ4 = TPS22966DPUR_SON14_2X3: room: DCDC1-TOUCHLS
Y1 = Y_X3G024000DC1H_4P: room: CAM-PMIC
Y2 = Y_9H03200031_2P: room: EC
YC1 = Y_X3G024000DC1H_4P: room: MCP
YC2 = Y_9H03220008_2P: room: MCP
YC3 = Y_XRCGB24M000F2P51R0_4P

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
74AHC1G09GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
74AUP1G07GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
ACES_50208-01201-P01_12P
  oval 0.508x0.991 smd: 1(0,0) 2(0.8,0) 3(1.6,0) 4(2.4,0) 5(3.2,0) 6(4,0) 7(4.8,0) 8(5.6,0) 9(6.4,0) 10(7.2,0) 11(8,0) 12(8.8,0)
  rect 1.194x1.702 smd: 13(10.1,-1.95) 14(-1.3,-1.95)
ACES_50224-00401-001_4P
  oval 0.61x1.549 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0)
  rect 1.194x1.803 smd: 5(4.3,-3.875) 6(-1.3,-3.875)
ACES_50278-00201-001_2P
  oval 0.787x1.905 smd: 1(0,0) 2(1.25,0)
  rect 1.295x3.353 smd: 3(-2.85,-4.925) 4(4.1,-4.925)
ACES_50278-01201-001_12P-T
  oval 0.787x1.905 smd: 1(0,0) 2(1.25,0) 3(2.5,0) 4(3.75,0) 5(5,0) 6(6.25,0) 7(7.5,0) 8(8.75,0) 9(10,0) 10(11.25,0) 11(12.5,0) 12(13.75,0)
  rect 1.295x3.353 smd: 13(-2.85,-4.925) 14(16.6,-4.925)
ACES_50376-00601-001_6P-T
  oval 0.406x0.61 smd: 1(0,0) 2(0.6,0) 3(1.2,0) 4(1.8,0) 5(2.4,0) 6(3,0)
  rect 0.711x1.041 smd: 7(-0.95,-1.375) 8(3.95,-1.375)
ACES_50398-05071-001_50P-T
  oval 0.254x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0) 27(13,0) 28(13.5,0) 29(14,0) 30(14.5,0) 31(15,0) 32(15.5,0) 33(16,0) 34(16.5,0) 35(17,0) 36(17.5,0) 37(18,0) 38(18.5,0) 39(19,0) 40(19.5,0) 41(20,0) 42(20.5,0) 43(21,0) 44(21.5,0) 45(22,0) 46(22.5,0) 47(23,0) 48(23.5,0) 49(24,0) 50(24.5,0)
  rect 1.194x3.2 smd: 51(-2.4,1.95) 55(26.9,1.95)
  rect 2.311x1.295 smd: 52(0.85,3.9) 53(12.25,3.9) 54(23.65,3.9)
ACES_50506-01841-P01_18P
  oval 0.305x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0)
  rect 0.991x2.007 smd: 19(-2.1,-3.05) 20(10.6,-3.05)
ACES_50521-01041-P01_10P
  oval 0.305x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0)
  rect 0.406x0.787 smd: 11(-1,-2.5) 12(5.5,-2.5)
ACES_51522-03001-P01_30P
  oval 0.305x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0) 27(13,0) 28(13.5,0) 29(14,0) 30(14.5,0)
  rect 2.489x1.905 smd: 31(-2.15,-3.3) 32(16.65,-3.3)
ALC3253-CG_MQFN48_6X6
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 25(6.1,-4.4) 26(6.1,-4) 27(6.1,-3.6) 28(6.1,-3.2) 29(6.1,-2.8) 30(6.1,-2.4) 31(6.1,-2) 32(6.1,-1.6) 33(6.1,-1.2) 34(6.1,-0.8) 35(6.1,-0.4) 36(6.1,0)
  oval 0.203x0.889 smd: 13(0.85,-5.25) 14(1.25,-5.25) 15(1.65,-5.25) 16(2.05,-5.25) 17(2.45,-5.25) 18(2.85,-5.25) 19(3.25,-5.25) 20(3.65,-5.25) 21(4.05,-5.25) 22(4.45,-5.25) 23(4.85,-5.25) 24(5.25,-5.25) 37(5.25,0.85) 38(4.85,0.85) 39(4.45,0.85) 40(4.05,0.85) 41(3.65,0.85) 42(3.25,0.85) 43(2.85,0.85) 44(2.45,0.85) 45(2.05,0.85) 46(1.65,0.85) 47(1.25,0.85) 48(0.85,0.85)
  rect 4.394x4.394 smd: 49(3.05,-2.2)
AON6380_DFN5X6-8-5
  oval 0.508x0.66 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.15x1.15 smd: 5(1.905,2.755)
AON6508_DFN8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.715)
AON7405_DFN8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
AS331KTR-G1_SOT23-5
  oval 0.711x0.991 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.6) 5(0,2.6)
AZ1065-06QPRDG_MSOP8
  oval 0.381x1.575 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,4.35) 6(1.3,4.35) 7(0.65,4.35) 8(0,4.35)
BAT54CW-7-F_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
BAT54CW_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
BAT54HT1G_SOD323-2
  rect 0.635x0.838 smd: 1(0,0) 2(2.225,0)
BELLW_10093-1021_4P
  rect 0.61x0.559 smd: 1(0,0)
  custom 0.145x0.145 smd: 2(0.96,0.975) 4(-0.96,0.975)
  rect 0.508x0.508 smd: 3(0,1.975)
C_0201
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
C_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
C_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
C_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
C_1206
  rect 1.016x1.778 smd: 1(0,0) 2(2.667,0)
C_B2
  rect 1.346x2.692 smd: 1(0,0) 2(-2.75,0)
C_NEC
  rect 0.787x1.092 smd: 1(0,0) 2(2.45,0)
C_PSKV151D476M045C
  rect 2.057x2.896 smd: 1(0,0) 2(6.15,0)
CHILI_MHCI04012-1R0M-R8EQ_2P
  rect 1.499x2.489 smd: 1(0,0) 2(3.7,0)
CHILI_MHCI05015B-1R0M-R8A_2P
  rect 1.905x2.489 smd: 1(0,0) 2(4.095,0)
CHILI_MHCI06015-R47MR8A7R45_2P
  rect 2.362x3.505 smd: 1(0,0) 2(6.05,0)
CIRRU_WM7216IMSE-RV_5P
  rect 0.94x0.457 smd: 1(0,0) 2(1.35,0) 3(1.35,0.85) 4(0,0.85)
  rect 0.356x1.295 smd: 5(-1.05,0.425) 7(2.4,0.425)
  rect 2.311x0.356 smd: 6(0.675,1.65) 8(0.675,-0.8)
CLIP_2P8X2P5-S
  rect 2.794x2.489 smd: 1(0,0)
CVILU_CI1804M1VRA-NH_4P
  oval 0.508x0.991 smd: 1(0,-0.05) 2(-0.8,-0.05) 3(-1.6,-0.05) 4(-2.4,-0.05)
  rect 1.194x1.702 smd: 5(-3.7,1.4) 6(1.3,1.4)
DB2J31400L_SOD323-2
  rect 0.991x1.092 smd: 1(0,0)
  rect 0.991x0.889 smd: 2(2.1,0)
DFLS160-7_POWERDI123-2
  rect 2.21x1.397 smd: 1(0,0)
  rect 0.889x1.397 smd: 2(-2.55,0)
DMG2301U-7_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
DMN65D8LW-7_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
DMN66D0LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
DMN2400UFB4-7_DFN1006H4-3
  rect 0.406x0.711 smd: 1(0,0)
  rect 0.406x0.254 smd: 2(0.7,-0.225) 3(0.7,0.225)
DMN2400UV-7_SOT-563-6
  oval 0.305x0.61 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1,1.6) 5(0.5,1.6) 6(0,1.6)
EC646_LGA10_1P1X1P5
  rect 0.203x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0.4,-1.2) 6(0.8,-1.2) 7(0.8,-0.8) 8(0.8,-0.4) 9(0.8,0) 10(0.4,0)
EMIST_SU-27AS_1P
  rect 4.496x2.997 smd: 1(0,0)
EMIST_SUL-12A2M_1P
  rect 6.909x1.194 smd: 1(0,0)
ESD3V3S1B-02LS_PG-TSSLP-2-1-2
  rect 0.279x0.381 smd: 1(0,0) 2(0.38,0)
ESD101-B1-02ELS_TSSLP-2-4-2
  rect 0.279x0.381 smd: 1(0,0) 2(0.38,0)
ESD207-B1-02EL_TSLP-2-19-2
  rect 0.356x0.61 smd: 1(0,0) 2(0.65,0)
FIDUCIAL_C40M80
  round 1.016 smd: 1(0,0)
G516A1Y51U_TSOT23-8
  oval 0.305x1.194 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,3) 6(1.3,3) 7(0.65,3) 8(0,3)
G517G1TO1U_TSOT23-5
  oval 0.533x1.194 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,3) 5(0,3)
G527ATP1U_TSOT23-6
  oval 0.508x1.194 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,3) 5(0.95,3) 6(0,3)
G916T1UF_SOT23-5
  oval 0.508x0.889 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.43) 5(0,2.43)
H9CCNNN8JTMLAR-NTM_FBGA_178P
  round 0.343 smd: A1(0,0) A2(0.8,0) A3(1.6,0) A4(2.4,0) A5(3.2,0) A6(4,0) A8(5.601,0) A9(6.401,0) A10(7.201,0) A11(8.001,0) A12(8.801,0) A13(9.601,0) B1(0,-0.65) B2(0.8,-0.65) B3(1.6,-0.65) B4(2.4,-0.65) B5(3.2,-0.65) B6(4,-0.65) B8(5.601,-0.65) B9(6.401,-0.65) B10(7.201,-0.65) B11(8.001,-0.65) B12(8.801,-0.65) B13(9.601,-0.65) C2(0.8,-1.3) C3(1.6,-1.3) C4(2.4,-1.3) C5(3.2,-1.3) C6(4,-1.3) C8(5.601,-1.3) C9(6.401,-1.3) C10(7.201,-1.3) C11(8.001,-1.3) C12(8.801,-1.3) D2(0.8,-1.95) D3(1.6,-1.95) D4(2.4,-1.95) D5(3.2,-1.95) D6(4,-1.95) D8(5.601,-1.95) D9(6.401,-1.95) D10(7.201,-1.95) D11(8.001,-1.95) D12(8.801,-1.95) E2(0.8,-2.6) E3(1.6,-2.6) E4(2.4,-2.6) E5(3.2,-2.6) E6(4,-2.6) E8(5.601,-2.6) E9(6.401,-2.6) E10(7.201,-2.6) E11(8.001,-2.6) E12(8.801,-2.6) F2(0.8,-3.25) F3(1.6,-3.25) F4(2.4,-3.25) F5(3.2,-3.25) F6(4,-3.25) F8(5.601,-3.25) F9(6.401,-3.25) F10(7.201,-3.25) F11(8.001,-3.25) F12(8.801,-3.25) G2(0.8,-3.9) G3(1.6,-3.9) G4(2.4,-3.9) G5(3.2,-3.9) G6(4,-3.9) G8(5.601,-3.9) G9(6.401,-3.9) G10(7.201,-3.9) G11(8.001,-3.9) G12(8.801,-3.9) H2(0.8,-4.55) H3(1.6,-4.55) H4(2.4,-4.55) H5(3.2,-4.55) H6(4,-4.55) H8(5.601,-4.55) H9(6.401,-4.55) H10(7.201,-4.55) H11(8.001,-4.55) H12(8.801,-4.55) J2(0.8,-5.2) J3(1.6,-5.2) J4(2.4,-5.2) J5(3.2,-5.2) J6(4,-5.2) J8(5.601,-5.2) J9(6.401,-5.2) J10(7.201,-5.2) J11(8.001,-5.2) J12(8.801,-5.2) K2(0.8,-5.85) K3(1.6,-5.85) K4(2.4,-5.85) K5(3.2,-5.85) K6(4,-5.85) K8(5.601,-5.85) K9(6.401,-5.85) K10(7.201,-5.85) K11(8.001,-5.85) K12(8.801,-5.85) L2(0.8,-6.5) L3(1.6,-6.5) L4(2.4,-6.5) L5(3.2,-6.5) L6(4,-6.5) L8(5.601,-6.5) L9(6.401,-6.5) L10(7.201,-6.5) L11(8.001,-6.5) L12(8.801,-6.5) M2(0.8,-7.15) M3(1.6,-7.15) M4(2.4,-7.15) M5(3.2,-7.15) M6(4,-7.15) M8(5.601,-7.15) M9(6.401,-7.15) M10(7.201,-7.15) M11(8.001,-7.15) M12(8.801,-7.15) N2(0.8,-7.8) N3(1.6,-7.8) N4(2.4,-7.8) N5(3.2,-7.8) N6(4,-7.8) N8(5.601,-7.8) N9(6.401,-7.8) N10(7.201,-7.8) N11(8.001,-7.8) N12(8.801,-7.8) P2(0.8,-8.45) P3(1.6,-8.45) P4(2.4,-8.45) P5(3.2,-8.45) P6(4,-8.45) P8(5.601,-8.45) P9(6.401,-8.45) P10(7.201,-8.45) P11(8.001,-8.45) P12(8.801,-8.45) R2(0.8,-9.1) R3(1.6,-9.1) R4(2.4,-9.1) R5(3.2,-9.1) R6(4,-9.1) R8(5.601,-9.1) R9(6.401,-9.1) R10(7.201,-9.1) R11(8.001,-9.1) R12(8.801,-9.1) T1(0,-9.75) T2(0.8,-9.75) T3(1.6,-9.75) T4(2.4,-9.75) T5(3.2,-9.75) T6(4,-9.75) T8(5.601,-9.75) T9(6.401,-9.75) T10(7.201,-9.75) T11(8.001,-9.75) T12(8.801,-9.75) T13(9.601,-9.75) U1(0,-10.4) U2(0.8,-10.4) U3(1.6,-10.4) U4(2.4,-10.4) U5(3.2,-10.4) U6(4,-10.4) U8(5.601,-10.4) U9(6.401,-10.4) U10(7.201,-10.4) U11(8.001,-10.4) U12(8.801,-10.4) U13(9.601,-10.4)
