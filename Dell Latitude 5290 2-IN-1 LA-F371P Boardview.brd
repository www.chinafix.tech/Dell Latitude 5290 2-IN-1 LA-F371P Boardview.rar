# Allegro board Dell Latitude 5290 2-IN-1 LA-F371P Boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_SIGNAL: length 28.7
  TOP w0.203: v8(74.03,83.31) 73.91,83.2 PU400.11
  TOP w0.508: v8(76.71,84.98) PC410.2 ; PC410.2 PC412.2 ; PC410.2 75.79,85 PC408.2 ; v8(71.3,84.14) PR418.2 71.04,85.28 PR408.2 PC411.2 70.52,86.17 70.97,86.63 72.64,86.63 73.15,86.12 PC414.2 PC413.2 PC412.2 ; PR420.2 74.88,85.03 PC412.2 ; PR412.2 PR414.2 PR415.2 PC417.2 v8(69.39,83.5) ; PR401.1 v8(78.63,81.83)
  IN1 w0.508: v8(74.03,83.31) 72.9,83.31 72.07,84.14 v8(71.3,84.14) 70.66,83.5 v8(69.39,83.5) ; v8(76.71,84.98) 77.86,83.83 77.86,82.6 v8(78.63,81.83) 78.63,80.43 v8(78.55,80.35)
VBUS1_ECOK: length 316.8
  IN2 w0.066: v4(143.28,130.65) 143.11,130.82 v3(143,130.82) ; v3(28.14,41.72) v4(28.14,41.34)
  IN3 w0.066: v6(134.84,132.49) 135.13,132.21 140.32,132.21 140.67,131.85 140.89,131.85 141.57,131.17 142.77,131.17 v4(143.28,130.65) ; v6(31.06,101.72) 33.2,101.72 34.33,102.85 35.6,102.85 35.97,103.22 38.79,103.22 v6(39.14,102.87) ; v6(46.81,41.85) 45.97,41.85 45.32,41.19 42.06,41.19 41.11,42.14 34.99,42.14 34.34,41.49 28.3,41.49 v4(28.14,41.34)
  IN4 w0.066: v6(46.81,41.85) 46.88,41.91 46.88,46.69 41.08,52.5 41.08,53.3 39.09,55.28 39.09,55.8 37.53,57.36 37.32,57.36 36.77,57.92 36.77,61.67 35.24,63.2 33.99,63.2 33.45,63.74 33.45,66.74 31.34,68.84 31.34,73.09 32.43,74.18 32.43,84.92 32.36,84.99 32.36,88.19 31.56,88.99 31.56,90.73 31.64,90.81 31.64,96.72 32.25,97.32 32.25,99.69 31.06,100.88 v6(31.06,101.72) 30.26,102.52 30.26,102.87 30.02,103.12 30.02,103.77 27.69,106.1 27.69,108.7 27.82,108.83 27.82,109.48 27.65,109.64 27.65,110.01 27.19,110.48 27.19,110.94 27.01,111.11 26.82,111.11 26.47,111.47 25.72,111.47 25.51,111.68 25.26,111.93 25.06,111.93 23.68,111.93 23.31,111.56 23.05,111.56 22.44,110.94 22.22,110.94 21.84,111.32 v1(21.84,112.28) ; v6(134.84,132.49) 134.84,132.64 135.46,133.26 135.46,146.35 135.57,146.46 135.57,148.4 135.58,148.41 135.58,148.77 135.32,149.03 128.83,149.03 122.28,155.59 122.28,160.9 122.28,161.32 118.11,165.49 106.88,165.49 106.39,165 41.36,165 40,163.63 40,163.27 40,156.48 40.37,156.11 40.37,149.25 40.14,149.03 40.14,145.88 39.55,145.29 39.55,144.81 36.9,142.15 36.9,136.33 36.74,136.17 36.74,132.72 35.86,131.85 35.86,129.49 36.15,129.21 36.15,125.31 36.84,124.62 36.84,122.79 37.11,122.52 37.11,122.21 37.11,121.94 37.11,121.93 37.11,121.66 37.22,121.55 37.22,118.04 37.78,117.48 37.78,113.34 38.96,112.16 38.96,107.13 39.14,106.95 v6(39.14,102.87)
  BOTTOM w0.076: 20.12,113.09 21.24,113.09 UE3.M6 21.84,112.49 v1(21.84,112.28)
  BOTTOM w0.112: RE24.2 18.76,113.23 18.86,113.23 19.06,113.44 19.77,113.44 20.12,113.09
VBUS2_ECOK: length 334.3
  TOP w0.112: PR135.2 v3(24.77,20.4)
  IN2 w0.066: v3(24.77,20.4) 25.4,21.03 v4(25.4,21.91) ; v3(144.02,132.58) v4(143.65,132.58)
  IN3 w0.066: v6(51.92,25.95) 51.66,25.95 51.29,25.58 48.32,25.58 47.92,25.17 47.57,25.17 47.32,25.42 41.42,25.42 41.12,25.13 38.7,25.13 35.42,21.85 28.66,21.85 28.22,21.4 25.91,21.4 v4(25.4,21.91) ; v6(135.22,132.49) 135.56,132.83 136.65,132.83 136.78,132.7 140.29,132.7 140.76,132.23 143.31,132.23 v4(143.65,132.58) ; v5(21.69,110.83) 21.69,110.67 22.56,109.79 25.2,109.79 25.93,109.06 26.26,109.06 26.38,108.95 27.84,108.95 28.1,108.69 28.97,108.69 29.78,109.49 29.78,109.77 32.12,112.1 35.15,112.1 38.31,108.94 38.62,108.94 v6(38.68,108.88)
  IN4 w0.066: v6(51.92,25.95) 51.73,26.13 51.73,48.23 46.86,53.11 46.86,68.53 45.37,70.01 45.37,70.23 45.22,70.38 45.01,70.38 42.73,72.66 42.73,76.29 42.73,76.31 42.75,76.41 42.75,78.43 42.38,78.79 42.38,82.11 42.1,82.39 42.1,84.14 41.18,85.06 41.18,85.47 39.74,86.91 39.74,89.52 40.27,90.05 40.27,92.74 40.37,92.83 40.37,93.74 40.27,93.84 40.27,96.05 40.46,96.24 40.46,99.51 38.8,101.17 38.8,106.49 38.8,106.62 38.73,106.69 38.73,108.83 v6(38.68,108.88) 38.53,109.03 38.53,112.33 37.61,113.24 37.61,117.29 37.06,117.84 37.06,121.34 37.06,121.48 36.94,121.59 36.94,122 36.94,122.45 36.68,122.72 36.68,124.55 35.98,125.24 35.98,129.03 35.33,129.68 35.33,130.04 35.33,130.05 35.33,130.26 35.33,130.26 35.33,130.73 35.47,130.87 35.47,131.69 36.57,132.79 36.57,136.24 36.73,136.4 36.73,142.22 39.39,144.88 39.39,145.4 39.98,145.99 39.98,146.77 39.98,146.78 39.98,146.91 39.98,149.1 40.16,149.28 40.16,156.08 39.83,156.41 39.83,163.2 39.83,163.7 41.29,165.16 106.32,165.16 106.81,165.65 118.18,165.65 122.45,161.39 122.45,160.83 122.45,155.66 128.9,149.2 135.11,149.2 135.39,149.2 135.75,148.84 135.75,148.34 135.74,148.33 135.74,146.34 135.63,146.23 135.63,133.19 135.22,132.78 v6(135.22,132.49)
  BOTTOM w0.076: UE3.N3 20.83,110.4 21.26,110.83 v5(21.69,110.83)
VBUSSENSE: length 7.7
  TOP w0.076: 52.45,121.3 53.14,121.3 53.53,121.69 55.03,121.69 55.93,120.79 UCPU1.AG4
  TOP w0.112: 52.45,121.3 52.21,121.3 RH91.1 51.67,121.84 49.66,121.84 RC61.1
VCC_GT_SENSE: length 64.4
  TOP w0.076: UCPU1.J70 94.15,129.94 94.39,129.7 95.55,129.7
  TOP w0.254: 95.55,129.7 95.65,129.6 95.89,129.6 96.19,129.3 RC44.2 97.99,129.3 v2(98.42,129.73) v8(98.86,130.16)
  IN1 w0.254: v8(98.86,130.16) 100.18,131.48 100.18,139.54 94.13,145.58 v10(94.13,146.04)
  IN2 w0.254: v4(68.4,157.57) 72.95,157.57 74.37,156.15 79.58,156.15 80.11,156.68 82.47,156.68 83.46,157.67 90.53,157.67 94.13,154.07 v10(94.13,146.04)
  IN3 w0.254: v5(65.57,158.94) 66.08,158.43 67.69,158.43 68.4,157.72 v4(68.4,157.57)
VCCDSW_EN_GPIO: length 43.8
  IN3 w0.066: v5(19.91,114.29) 19.46,113.84 19.46,112.05 20.7,110.81 21.28,110.81 22.92,109.18 24.18,109.18 24.43,108.92 25.36,108.92 25.72,108.56 26.01,108.56 26.13,108.44 27.63,108.44 27.89,108.18 28.45,108.18 28.45,108.18 29.18,108.18 30.29,109.29 30.29,109.56 30.7,109.97 31.93,109.97 32.57,109.33 32.57,109.11 32.57,109.11 32.57,108.72 32.57,108.72 32.57,108.07 32.9,107.75 38.45,107.75 38.84,107.35 40.72,107.35 41.42,106.65 v5(41.42,106.54)
  BOTTOM w0.076: v5(19.91,114.29) 20.26,113.95 20.92,113.95 21.26,113.6 21.53,113.6
  BOTTOM w0.112: v5(41.42,106.54) 45.41,106.54 45.64,106.77 Q353.2 50.95,107.24 51.14,107.43 52.77,107.43 R235.1
VCCIO_SENSE: length 66
  TOP w0.254: PR810.2 120.31,122.84 v7(120.28,122.84)
  IN2 w0.254: v4(66.99,118.3) 67.25,118.56 v3(67.61,118.56)
  IN3 w0.254: v7(120.28,122.84) 119.74,122.84 113.61,128.97 108.96,128.97 103.18,123.19 99,123.19 98.12,124.08 94.78,124.08 93.49,122.79 93.49,121.77 93.1,121.37 92.22,121.37 90.98,120.13 89.05,120.13 88.08,119.16 76.79,119.16 76.38,118.75 73.59,118.75 73.18,119.16 71.7,119.16 71.17,118.63 69.87,118.63 69.34,119.16 67.84,119.16 66.99,118.31 v4(66.99,118.3)
  GND3 w0.254: v4(66.99,118.3) 67.44,118.75 v13(67.44,119.05)
  BOTTOM w0.127: v2(119.65,123.06) 119.87,122.84 v7(120.28,122.84)
VCCSENSE: length 32.8
  TOP w0.152: 70.27,134.43 70.27,134.09 70.15,133.97 70.15,133.72 70.33,133.54 70.57,133.54 70.89,133.22 71.13,133.22 71.37,132.98 71.37,132.65 71.93,132.1 UCPU1.E32
  TOP w0.254: 70.27,134.43 70.27,135.87 70.14,136 70.14,136.3 68.64,137.8 v2(68.64,138.24) 68.64,139.37 RC5.2
  IN2 w0.254: v3(68.61,139.74) 68.63,139.77 68.63,140.32 64.62,144.34 64.62,145.27 62.69,147.2 62.69,154.65 63.22,155.18 v4(63.22,155.49)
  IN3 w0.254: v4(63.22,155.49) v6(63.22,155.82)
  IN4 w0.254: v6(63.22,155.82) 63.22,157.98 62.26,158.94 62.26,159.64 v1(62.06,159.83)
VCCST_EN: length 48.2
  IN3 w0.066: v5(30.67,128.65) 30.67,128.65 31.03,129.01 35.16,129.01 v6(35.23,128.94) ; v5(46.29,130.18) 44.81,130.18 42.64,132.35 41.99,132.35 41.22,131.58 35.81,131.58 v6(35.2,130.98)
  IN4 w0.066: v1(38.07,110.56) 37.95,110.56 37.84,110.67 37.84,112.78 37.44,113.18 37.44,117.01 37.38,117.07 37.38,117.19 36.89,117.69 36.89,121.41 36.78,121.52 36.78,122.38 36.51,122.65 36.51,124.48 35.69,125.3 35.69,128 35.26,128.44 35.26,128.92 v6(35.23,128.94) 35.23,129.05 35.08,129.2 35.08,130.85 v6(35.2,130.98)
  BOTTOM w0.112: v1(38.07,110.56) 37.69,110.56 37.14,111.11 UC8.4 36.01,110.62 35.88,110.49 RE48.1 ; UZ3.4 48.94,132.95 48.41,132.42 48.39,132.37 48.39,131.28 v2(47.43,130.33) 47.37,130.27 46.38,130.27 v5(46.29,130.18) ; v5(30.67,128.65) 30.67,128.65 30.3,128.28 R427.2
VCCST_PWRGD_CPU: length 6.2
  TOP w0.076: UCPU1.B65 90.54,134.48 90.54,135.08 91.67,136.21 91.67,137.45 91.8,137.57 93.2,137.57 RC26.2
VCCSTG_EN: length 86.4
  TOP w0.112: v7(70.28,95.38) 69.11,96.55 RZ1.1
  IN3 w0.066: v6(47.22,118.13) 49.6,118.13 49.73,118 53.25,118 54.33,116.93 54.33,114.89 56.51,112.71 59.02,112.71 59.96,111.77 62.16,111.77 62.69,111.24 63.03,111.24 v6(63.11,111.16)
  IN4 w0.066: v7(70.28,95.38) 65.93,95.38 65.54,95.76 65.54,104.64 64.69,105.49 64.69,106.68 63.18,108.19 63.18,111.09 v6(63.11,111.16) ; v1(57.1,139.03) 56.82,139.03 56.49,138.7 54.23,138.7 53.23,139.7 50.08,139.7 49.71,140.07 47.93,140.07 45.51,137.65 43.99,137.65 42.73,136.4 42.73,136.1 42.73,136.1 42.73,132.26 44.83,130.16 44.83,129.22 43.99,128.38 43.99,121.7 47.22,118.47 v6(47.22,118.13)
  BOTTOM w0.112: UZ2.4 59.55,138.84 RZ2.1 59.39,139.37 59.25,139.51 58.19,139.51 57.7,139.02 UC2.4 57.11,139.02 v1(57.1,139.03) ; v7(70.28,95.38) v2(69.88,95.78)
VDD: length 4.9
  TOP w0.127: 133.63,129.99 133.3,129.99 133.15,130.14 131.97,130.14 v2(131.72,130.38)
  BOTTOM w0.203: v7(134.29,129.37) 134.38,129.28 PU300.18
  BOTTOM w0.457: v7(134.29,129.37) 132.89,130.77 PR331.1
VDD18_CORE: length 2.4
  BOTTOM w0.112: v2(64.36,146.8) 64.29,146.88 PR935.1 64.67,147.73 PR937.1
VIN_1.0VA:
  vias: v2(127.1,141.56) v7(126.43,140.59) v7(126.43,140.02)
VIN_1.8VA: length 2.3
  TOP w0.112: v2(138.3,136.46) 138.77,136.93 138.77,137.85 139.22,138.29 PC724.1
VIN_PRIM: length 1.2
  BOTTOM w0.112: PC811.1 v2(52.64,147.72)
  vias: v7(51.88,146.37) v7(51.88,145.8)
VIN_VCCIO: length 1.3
  TOP w0.112: v2(128.37,130.07) 127.72,130.07 127.47,129.82 PL800.2
  vias: v7(126.11,128.27) v7(126.11,127.51)
VSS_GT_SENSE: length 63.6
  TOP w0.076: UCPU1.J69 93.55,129.94 93.83,130.22 94.07,130.22 94.14,130.19 94.8,130.19 95,129.99 95.37,129.99 95.38,129.99 95.44,129.99 95.54,130.1 95.54,130.15 95.63,130.23 95.89,130.23
  TOP w0.254: v8(98.12,130.16) RC42.1 v2(96.48,130.16) 96.22,130.16 96.15,130.23 95.89,130.23
  IN1 w0.254: v8(98.12,130.16) 99.67,131.71 99.67,139.33 93.62,145.37 v10(93.62,146.01)
  IN2 w0.254: v10(93.62,146.01) 93.62,153.85 90.32,157.16 83.67,157.16 82.68,156.17 80.37,156.17 79.83,155.64 74.14,155.64 72.72,157.06 68.17,157.06 67.87,157.37 v4(67.87,157.52)
  IN3 w0.254: v4(67.87,157.52) 67.46,157.93 65.27,157.93 v5(65.1,158.09)
VSSIO_SENSE: length 67.3
  TOP w0.254: v7(67.16,117.6) 67.16,117.95 66.7,118.42 UCPU1.AM22 ; v7(121.21,122.84) 122.05,123.68 PR811.2
  IN3 w0.254: v7(121.21,122.84) 120.57,122.2 119.47,122.2 113.34,128.34 109.22,128.34 103.44,122.55 98.74,122.55 97.85,123.44 95.05,123.44 94.13,122.52 94.13,121.51 93.36,120.74 92.37,120.74 91.2,119.57 88.99,119.57 88.25,118.83 76.99,118.83 76.51,118.36 73.5,118.36 73.02,118.83 71.93,118.83 71.37,118.28 69.7,118.28 69.14,118.83 67.98,118.83 67.56,118.42 67.56,118 v7(67.16,117.6)
  BOTTOM w0.127: v7(121.21,122.84) v2(121.21,123.36)
  BOTTOM w0.254: v7(67.16,117.6) 67.11,117.55 RC155.1
VSSSENSE: length 33.1
  TOP w0.152: UCPU1.E33 72.88,132.1 72.52,132.46 72.2,132.46 72.01,132.65 72.01,132.97 71.15,133.83 70.93,133.83 70.91,133.85 70.9,133.85 70.74,134.01 70.74,134.02 70.65,134.11 70.65,134.44
  TOP w0.254: v3(69.34,139.56) 69.15,139.37 69.15,138.01 v2(70.18,136.97) 70.65,136.51 70.65,134.44
  IN2 w0.254: v3(69.34,139.56) 69.14,139.77 69.14,140.55 65.13,144.57 65.13,145.48 63.2,147.41 63.2,154.42 63.73,154.95 v4(63.73,155.49)
  IN3 w0.254: v4(63.73,155.49) v6(63.73,155.84)
  IN4 w0.254: v6(63.73,155.84) 63.73,158.21 62.76,159.17 62.76,159.67 v1(62.93,159.83)
32KHZ_OUT: length 4.6
  BOTTOM w0.076: 27.25,107.02 27.56,106.72 CE57.1 ; UE3.F3 25.97,110.04 25.97,108.31 26.26,108.02
  BOTTOM w0.112: 26.26,108.02 27.25,107.02
+BAT_TABLET: length 18.5
  IN1 w0.508: v7(138.33,110.82) 139.24,111.74 139.24,118.18 138.3,119.11 138.3,123.19 139.64,124.53 v8(140.16,124.53)
  BOTTOM w0.127: v7(138.33,110.82) 137.73,110.82 v2(137.2,111.36)
  BOTTOM w0.508: PC127.1 138.94,111.11 PR126.1 138.62,111.11 v7(138.33,110.82)
+BATT: length 2.7
  BOTTOM w0.127: v7(140.59,107.63) v9(140.59,106.82) ; v7(138.3,108.78) 138.25,108.83 v9(137.49,108.83) ; v9(138.44,106.77) 138.87,107.2 v7(138.87,107.63)
  vias: v7(138.3,108.21) v7(138.3,107.63) v7(138.87,108.78) v7(138.87,108.21) v7(139.45,108.78) v7(139.45,108.21) v7(139.45,107.63) v7(140.02,108.78) v7(140.02,108.21) v7(140.02,107.63) v7(140.59,108.78) v7(140.59,108.21) v7(141.16,108.78) v7(141.16,108.21) v7(141.16,107.63) v7(146.62,103.13) v7(146.62,102.55) v7(146.62,101.98) v7(146.62,101.41) v7(146.62,100.84) v7(146.62,100.27) v7(147.19,103.13) v7(147.19,102.55) v7(147.19,101.98) v7(147.19,101.41) v7(147.19,100.84) v7(147.19,100.27) v7(147.76,103.13) v7(147.76,102.55) v7(147.76,101.98) v7(147.76,101.41) v7(147.76,100.84) v7(147.76,100.27)
+BMC_LDO_PD1: length 2.6
  BOTTOM w0.254: CT15.1 31.5,62.8 33.03,64.33 UT1.E1
+BMC_LDO_PD2: length 1.9
  BOTTOM w0.254: CT30.1 57.09,14.48 56.63,14.93 UT2.E1
+CHG_SRC_20V:
  vias: v7(123.19,102.05) v7(124.21,102.05) v7(124.84,102.05) v7(127.15,99.71) v7(128.07,99.66) v7(128.91,99.66) v9(123,101.47)
+CHG_VIN_20V: length 170.7
  TOP w0.381: PQ104.3 22.37,38.91 21.72,39.56 PR101.1 ; PR130.1 25.4,24.58 25.83,25.01 25.83,29.94 ; PR130.1 PC124.1 24.21,24.7 PR129.1 ; PR130.1 25.98,24.4 PQ115.3
  TOP w0.508: v3(26.8,38.55) 23.75,38.55 23.38,38.91 PQ104.3 ; PD300.2 137.6,131.26 138.51,132.16 138.51,132.6 139.13,133.22 139.13,135.55 v7(138.94,135.74)
  IN2 w0.508: v7(138.94,135.74) 138.09,135.74 137.99,135.64 136.78,135.64 136.56,135.87 133.96,135.87 133.47,136.36 130.43,136.36 129.15,135.08 v4(127.91,135.08)
  IN3 w0.508: v7(117.17,99.85) 117.12,99.9 111.09,99.9 110.64,100.34 110.64,102.58 113.7,105.64 v6(113.7,122.43) ; v4(127.91,135.08) v5(127.34,135.08)
  IN3 w1.016: 111.57,88.01 117.16,93.6 117.16,97.77
  IN3 w1.27: 111.57,88.01 110.87,87.31 97.09,87.31 94.79,87.64 92.83,88.31 82.48,88.31 80.39,86.22 80.39,80.25
  IN3 w3.048: 44.96,45.12 45.51,44.57 72.93,44.57 78.47,50.1
  IN4 w0.508: v6(113.7,122.43) 115.32,122.43 v1(115.68,122.8)
  BOTTOM w0.508: v1(115.68,122.8) 119.48,126.6 119.48,127.33 121.02,128.87 124.61,128.87 v9(125.38,129.64) PR303.1 126.87,132.69 127.33,133.15 v9(127.33,133.88) 127.33,135.07 v5(127.34,135.08)
  vias: v3(26.54,36.9) v3(26.54,36.51) v3(26.8,36.9) v3(26.8,36.51) v3(27.64,36.79) v3(27.94,36.79) v4(29.03,43.58) v4(29.34,43.88) v4(29.34,43.25) v4(29.77,43.88) v4(29.77,43.42) v4(29.79,42.99) v4(80.62,79.34) v4(80.62,78.83) v4(81.13,79.34) v4(81.13,78.83) v7(79.26,53.53) v7(79.26,52.95) v7(79.26,52.37) v7(79.84,53.53) v7(79.84,52.95) v7(79.84,52.37) v7(117.17,99.2) v7(117.17,98.62) v7(117.76,99.85) v7(117.76,99.2) v7(117.76,98.62)
+INV_PWR_SRC: length 4
  TOP w0.102: v9(74.8,70.98) 75.77,71.94 PL400.1
+LCDVDD: length 169.8
  TOP w0.381: v3(47.62,88.28) 47.65,88.25 R5766.1 R411.1
  IN1 w1.016: 40.64,23.05 41.78,21.91 48.39,21.91 60.07,10.23 65.01,10.23 66.03,9.22 72.88,9.22 83.28,19.62
  IN2 w0.508: v4(37.06,41.09) 36.83,41.31 36.83,41.95 36.58,42.2 36.58,43.47 47.73,54.63 47.73,86.76 47.62,86.87 v3(47.62,88.28)
  IN2 w0.762: 85.6,20.01 85.6,25.36 83.91,27.05 83.91,33.12
  IN3 w0.508: v4(37.06,41.09) 37.52,41.54 40.69,41.54 41.61,40.63 49.07,40.63 49.36,40.34 63.51,40.34 65.25,42.08 79.97,42.08 82.42,39.63 83.76,39.63
  vias: v3(85.03,39.7) v3(85.03,39.2) v4(84.01,34.16) v4(84.01,33.66) v4(84.65,39.69) v4(84.65,39.24) v5(83.63,34.55) v5(83.95,34.55) v5(84.26,39.63) v5(84.26,39.31) v7(39.75,23.69) v7(39.75,23.05) v9(40.35,23.48) v10(84.14,19.81) v10(84.39,20.07)
+LED_AN: length 57
  TOP w0.508: PR410.1 69.39,78.88 v8(69.93,78.35)
  IN1 w0.508: v8(69.93,78.35) 70.27,78.35 70.61,78 70.61,68.87 71.56,67.92
  IN1 w0.762: 83.52,29.86 76.53,29.86 74.68,31.71 74.68,40.9 72.83,42.74 72.83,49.53 ; 71.3,66.51 70.68,65.89 70.68,64.14 69.91,63.37 69.91,56.39 72.01,54.29 72.01,52.52 72.83,51.69
  vias: v3(85.03,30.7) v3(85.03,30.2) v3(85.03,29.7) v4(84.65,30.74) v4(84.65,30.23) v4(84.65,29.72) v5(84.26,30.74) v5(84.26,30.23) v5(84.26,29.72) v8(71.37,67.12) v8(71.56,67.44) v8(71.75,67.12) v8(72.83,51.06) v8(72.83,50.61) v8(72.83,50.17) v9(80.12,30)
+PECI_VREF: length 7
  IN3 w0.203: v5(23.93,116.8) 22.76,117.97 22.76,118.68 22.1,119.34 21.16,119.34 v5(20.64,118.82)
  BOTTOM w0.203: RE261.1 20.4,119.06 v5(20.64,118.82)
+RTCBATT: length 190
  IN1 w0.508: v7(152.78,100.64) 152.78,98.9 146.61,92.72 144.58,92.72 144.16,92.31 138.77,92.31 138.11,91.64 135.62,91.64 135.02,91.05 132.23,91.05 130.64,89.46 128.64,89.46 127.74,90.36 123.4,90.36 120.39,93.37 118.63,93.37 116.61,93.37 111.26,88.03 104.37,88.03 104.06,88.34 95.63,88.34 94.06,88.86 76.91,88.86 75.7,87.66 v10(67.18,87.66)
  IN2 w0.508: v10(67.18,87.66) 66.72,88.12 v4(66.72,90.28)
  IN3 w0.508: v4(66.72,90.28) 66.32,90.28 65.27,91.32 65.08,91.32 64.38,92.02 60.35,92.02 59.3,92.02 57,94.32 51.73,94.32 49.95,96.1 46.27,96.1 v6(46.04,95.88) ; 42.85,143.15 40.44,143.15 40.43,143.14 37.56,143.14 37.5,143.19 31.7,143.19 31.33,143.56 29.23,143.56 v5(28.98,143.82)
  IN4 w0.508: 43.43,142.65 43.43,140.46 42.29,139.31 41.52,139.31 40.89,138.68 40.89,137.45 41.45,136.89 41.45,129.32 42.78,127.99 42.78,123.07 42.64,122.94 42.3,122.59 42.3,117.78 42.23,117.7 42.23,110.5 43.15,109.58 43.15,106.6 45.8,103.95 45.8,99.4 45.66,99.26 45.66,96.8 46.06,96.39
  BOTTOM w0.127: v7(152.78,100.64) 152.78,100.64 v9(152.33,100.19)
  BOTTOM w0.508: JRTC1.1 153.86,100.28 153.86,100.46 RTCR1.2 v7(152.78,100.64)
  vias: v6(42.92,143.07) v6(43.24,143.08)
+RTCVCC: length 82.3
  TOP w0.127: RC85.1 65.11,104.6 65.41,104.89 v2(65.85,104.89)
  TOP w0.254: v7(64.39,118.78) 64.71,119.1 UCPU1.AK19 ; v7(62.1,111.22) 62.09,111.22 61.96,111.35 UCPU1.BB14
  TOP w0.279: RC88.2 64.79,102.36 RC89.1 64.98,104.6 RC85.1
  TOP w0.356: v8(63.09,102.88) 63.62,102.36 RC88.2
  IN1 w0.508: v7(62.1,111.22) 62.1,111.1 62.13,111.07 62.13,109.21 62.13,108.65 62.51,108.27 62.51,103.91 63.09,103.33 v8(63.09,102.88)
  IN3 w0.508: v6(31.14,99.83) 31.55,100.25 43.13,100.25 44.35,99.02 44.35,97.73 45.36,96.71 50.2,96.71 51.98,94.93 57.25,94.93 59.45,92.73 64.99,92.73 v6(65.14,92.89)
  IN4 w0.508: v6(65.14,92.89) 65.14,104.49 63.92,105.72 63.92,106.85 62.79,107.97 62.79,110.14 62.1,110.84 v7(62.1,111.22) 62.1,113.09 62.93,113.92 62.93,114.17 ; v6(31.14,99.83) 31.14,98.03 30.73,97.63
  BOTTOM w0.508: v7(64.39,118.78) 64.39,118.63 63.88,118.12 CC70.1 ; CC79.1 61.34,111.86 61.98,111.22 v7(62.1,111.22)
  vias: v1(30.33,97.05) v1(30.61,97.09)
+RTCVCC_EC: length 205.3
  TOP w0.381: RE267.1 RE268.1 124.51,91.19 v3(124.78,91.45)
  IN2 w0.508: v7(154.69,103.95) 154.64,103.9 154.64,101.97 155.42,101.18 155.42,94.26 150.33,89.17 139.67,89.17 137.06,91.78 131.04,91.78 130.12,92.7 128.27,92.7 127.2,91.63 124.96,91.63 v3(124.78,91.45)
  IN3 w0.508: v6(65.17,90.51) 64.88,90.51 63.97,91.41 59.03,91.41 56.76,93.68 51.51,93.68 49.69,95.49 48.72,95.49
  IN4 w0.508: v6(65.17,90.51) 66.61,89.07 74.27,89.07 77.23,92.03 82.31,92.03 82.75,91.58 92.95,91.58 93.2,91.33 95.59,91.33 96.18,90.74 103.31,90.74 103.85,91.28 107.86,91.28 109.41,92.83 109.41,94.08 110.77,95.44 128.58,95.44 129.04,94.99 146.8,94.99 151.13,99.32 151.13,100.4 v7(154.69,103.95) ; 47.87,95.95 47.03,96.79 47.03,101.21 47.5,101.68 47.5,103.39 45.68,105.21 45.68,106.91 45.36,107.23 44.98,107.23 ; v1(34.19,100.2) 34.19,101.04 33.44,101.78 33.44,105.51 v5(33.31,105.64)
  BOTTOM w0.508: RTCD1.1 154.69,104 v7(154.69,103.95) 154.69,103.87 RTCD2.1 153.22,102.41 C112.1 RTCR1.1 ; RE141.2 37.72,107.72 ; 37.72,107.72 37.48,107.62 35.55,107.62 RE27.1 34.81,107 34.71,107.1 RE19.1 34.1,106.73 33.31,105.94 v5(33.31,105.64) ; 37.72,107.72 37.89,107.72 38.23,107.38 38.27,107.38 38.4,107.25 43.46,107.25 43.54,107.18 ; R2751.2 32.69,95.09 32.69,96.05 Q349.3 33.53,96.89 33.53,97.27 33.91,97.65 33.91,98.34 34.19,98.62 v2(34.19,99.68) v1(34.19,100.2)
  vias: v1(44.22,107.18) v1(44.5,107.18) v5(29.15,105.68) v5(29.35,105.48) v6(47.74,95.44) v6(48.06,95.44)
+RTCVCC_VBAT: length 4
  BOTTOM w0.254: UE3.A2 31.84,108.09 32.12,108.09 CE18.1
  BOTTOM w0.457: CE18.1 32.45,107.61 32.46,107.6 32.46,107.5 32.86,107.1 RE19.2
+SD_VDD1: length 56.6
  IN1 w1.016: 69.34,37.4 69.34,38.88 64.72,43.5 64.72,52.08 60.6,56.2 60.6,61.15 62.56,63.11 62.56,67.2 63.88,68.52 63.88,74.13 62.81,75.2 62.81,79.95
  BOTTOM w1.016: 63.06,82.36 63.37,82.68 70.99,82.68 71.37,82.3
  vias: v2(63.36,81.15) v7(62.99,81.47) v7(62.99,80.84) v7(69.03,36.54) v7(69.61,36.54)
+SD_VDD2: length 2
  TOP w0.127: v2(73.08,66.35) 72.61,66.35 72.17,65.91 v7(72.17,65.7)
  BOTTOM w0.203: UR1.13 v5(69.16,35.97)
  vias: v7(71.59,65.7) v7(71.63,64.84) v7(72.01,64.39) v7(73.72,40.07) v7(73.72,39.49)
+SIM_PWR: length 96.5
  TOP w0.254: JNGFF1.36 24.13,121.1 23.85,120.82
  TOP w0.508: v3(17.12,120.41) 23.44,120.41 23.85,120.82
  IN2 w0.508: v3(17.12,120.41) 16.88,120.17 16.88,119.3 18.01,118.18 18.01,112.83 18.72,112.11 18.72,108.87 22.05,105.54 22.05,102.83 21.46,102.25 21.46,92.83 20.65,92.02 20.65,77.34 21.95,76.04 v4(21.95,74.38)
  IN3 w0.508: v5(51.02,69.06) 47.58,69.06 v5(42.99,73.65) 41.83,74.8 v5(40.07,74.8) 39.2,73.93 24.65,73.93 24.04,74.54 22.1,74.54 v4(21.95,74.38)
  BOTTOM w0.508: v5(40.07,74.8) 39.59,75.29 39.59,77.75 v2(39.76,77.93) 40.13,78.3 R154.1 ; JSIM1.1 v5(51.02,69.06) ; C145.1 v5(42.99,73.65)
+TPM_LPM: length 1.2
  BOTTOM w0.112: v2(41.54,99.53) 41.91,99.16 C225.1
+V_DDR_REF_CA: length 6.5
  TOP w0.203: UCPU1.AY67 91.85,113.15 91.85,111.75 v7(91.73,111.63)
  BOTTOM w0.508: v7(91.73,111.63) v2(91.73,110.82) 91.73,108.8 CD46.1 91.2,107.47 RD10.1
+V_DDR_REFA_R: length 34.3
  TOP w0.178: 92.83,112.85 93.17,112.51 93.17,112 93.22,111.95 93.22,111.57 93.6,111.19
  TOP w0.203: UCPU1.AY68 92.83,112.85
  TOP w0.508: RD15.1 CD67.1 105.84,100.34 v7(106.17,100.01) ; v7(107.57,108.4) 107.21,108.4 106.68,108.93 106.68,112.25 v2(106.14,112.79) 106.13,112.79 105.12,113.81 104.53,114.24 103.26,114.85 100.56,114.85 96.9,111.19 93.6,111.19
  IN4 w0.508: v7(106.17,100.01) 105.79,100.4 105.79,106.62 v7(107.57,108.4)
+V_DDR_REFB_R: length 93.2
  TOP w0.203: UCPU1.BA67 92.5,112.54 92.5,111.67
  TOP w0.508: 92.5,111.67 92.5,110.64 93.6,109.54 96.4,109.54 98.26,107.68 99.15,107.68 100.54,106.29 105.97,106.29 106.91,105.35 v7(107.57,105.35)
  IN4 w0.508: v7(106.81,94.68) 105.64,95.85 105.64,98.04 107.19,99.59 107.19,100.43 106.81,100.82 106.81,104.59 v7(107.57,105.35) ; v1(66.4,98.15) v1(70.45,98.15)
  BOTTOM w0.508: v1(66.4,98.15) v2(66.4,97.49) 64.39,95.48 64.39,90.69 65.91,89.17 106.05,89.17 106.81,89.93 v7(106.81,94.68) ; v1(70.45,98.15) RD5.1
+VR_CAP: length 16.5
  IN3 w0.305: v6(24.58,111.6) 23.92,112.27 23.92,114.89 25.01,115.99 26.05,115.99 26.54,116.47 27,116.47 27.09,116.38 28.32,116.38 28.7,116 v5(28.73,116)
  IN4 w0.305: v6(24.58,111.6) 24.35,111.36 24.35,109.58 23.93,109.16 v1(23.93,108.8)
  BOTTOM w0.305: CE64.1 24.05,104.89 24.05,108.68 v1(23.93,108.8)
+VREFCA: length 38
  TOP w0.381: CD22.1 86.61,96.73 v7(86.23,97.11)
  IN1 w0.381: 87.63,97.32 87.22,96.92 86.42,96.92 v7(86.23,97.11) 85.63,96.51 84.1,96.51 84,96.41 83.62,96.41 83.24,96.79 82.39,96.79 v8(82.24,96.93) ; 87.63,97.32 88.03,97.32 88.35,96.99 88.35,96.41 88.72,96.04 89.7,96.04 89.98,96.32 91.43,96.32 91.69,96.05 93.17,96.05 v7(93.67,96.54) 93.76,96.64 93.76,97.8 93.4,98.17 v8(93.26,98.17) ; 87.63,97.32 87.63,102.98 87.9,103.25 89.48,103.25 v7(89.7,103.47)
  IN4 w0.381: v7(86.23,97.11) 86.23,98.27 85.83,98.67 83.52,98.67 83.08,98.23 v1(82.24,98.23)
  BOTTOM w0.381: CD69.1 CD72.1 86.6,97.47 v7(86.23,97.11) ; CD47.1 RD11.1 91.11,106.49 RD10.2 91.24,106.36 RD12.2 v2(90.23,104.84) 90.07,104.84 89.7,104.47 v7(89.7,103.47) ; v7(93.67,96.54) 93.34,96.87 UD4.H4
+VREFDQ_A: length 7.3
  TOP w0.152: 100.33,97.6 v7(100.33,97.28) 100.24,97.19 99.18,97.19 UD2.J11 99.18,97.84 100.09,97.84 100.33,97.6
  BOTTOM w0.152: UD2.J11 99.18,97.84 100.03,97.84 100.33,97.54 v7(100.33,97.28) 100.24,97.19 99.19,97.19 UD2.J11
+VREFDQ_B: length 2.1
  TOP w0.102: v2(70.66,96.52) 72.11,96.52 RD6.2
  vias: v7(74.68,97.6)
AC1_DISC#: length 255.8
  TOP w0.112: PR123.1 19.11,43.06 19.84,43.78 v3(19.84,44.24)
  TOP w0.254: v8(150.76,117) 150.86,117 152.22,118.37 152.22,118.91 PT103.1 153.27,119.39 PR342.1
  IN1 w0.066: v7(78.82,68.14) 78.59,68.37 78.59,74.23 80.01,75.66 80.01,81.5 81.18,82.66 81.18,85.96 82.9,87.69 92.88,87.69 96.23,86.57 111.51,86.57 117.1,92.17 119.88,92.17 124.52,87.53 149.28,87.53 159.47,97.71 159.47,104.85 150.6,113.72 150.6,116.84 v8(150.76,117) 150.6,117.16 150.6,120.88 147.47,124 147.47,127.74 145.43,129.79 145.43,130.22 145.33,130.32 144.52,130.32 144.27,130.57 144.27,131.46 v8(143,132.73)
  IN2 w0.066: v3(19.84,44.24) 19.84,44.29 v4(20.07,44.52)
  IN3 w0.066: v4(20.07,44.52) 22.86,44.52 23.67,45.33 26.95,45.33 27.24,45.62 27.24,46.92 27.61,47.28 28.78,47.28 29.99,48.5 32.36,48.5 33.12,47.74 39.78,47.74 40.46,48.43 49.91,48.43 50.24,48.1 v6(60.66,48.1) ; v5(41.35,65.85) 60.26,65.85 v7(61.53,64.58) 63.51,66.56 77.24,66.56 v7(78.82,68.14)
  IN4 w0.066: v7(61.53,64.58) 60.66,63.7 v6(60.66,48.1)
AC1_OVP: length 4.2
  TOP w0.112: v3(30.33,48.82) 30.65,48.5 PR146.1 PR117.2
  IN2 w0.066: v3(30.33,48.82) 30.44,48.82 30.91,49.29 v4(31.09,49.29)
  IN3 w0.066: v4(31.09,49.29) 31.06,49.26 30.81,49.26 v5(30.73,49.34)
  BOTTOM w0.112: v5(30.73,49.34) v2(29.76,49.34)
AC2_DISC#: length 270.2
  TOP w0.112: v8(150.97,116.57) 151.04,116.5 151.75,116.5 151.94,116.69 151.94,117.32 152.5,117.88 154.14,117.88 154.97,118.71 PR343.1 ; PR136.1 21.64,20.93 22.21,21.5 v8(22.25,21.5) ; v7(82.49,48.93) 82.44,48.93 v2(81.98,49.39)
  TOP w0.254: PR144.1 v8(144.55,130.67)
  IN1 w0.066: v8(22.25,21.5) 24.1,21.5 24.43,21.83 25.5,21.83 26.18,21.15 27.11,21.15 28.63,22.67 30.61,22.67 33.17,25.24 34.29,25.24 34.77,25.72 44.83,25.72 v10(46.29,24.26) ; v8(144.55,130.67) 144.74,130.49 145.4,130.49 145.59,130.29 145.59,129.86 147.64,127.81 147.64,124.07 150.77,120.94 150.77,117.72 151.07,117.42 151.07,116.67 v8(150.97,116.57) 150.96,116.57 150.96,115.94 150.77,115.74 150.77,113.79 159.63,104.92 159.63,97.64 149.35,87.36 124.45,87.36 119.81,92 117.17,92 111.58,86.4 96.2,86.4 92.86,87.52 82.97,87.52 81.34,85.89 81.34,82.5 80.24,81.4 80.24,75.29 79.35,74.4 79.35,72.4 79.5,72.25 79.5,71.79 78.92,71.21 78.92,68.75 79.27,68.39 79.27,67.25 82,64.53 82,53.46 82.87,52.59 82.87,49.31 v7(82.49,48.93)
  IN2 w0.066: v7(82.49,48.93) 82.49,44.98 83.9,43.56 83.9,38.44 82.61,37.14 82.61,31.26 79.57,28.23 74.69,28.23 74.36,28.56 58.29,28.56 55.71,25.98 47.94,25.98 46.29,24.33 v10(46.29,24.26) v4(46.29,23.81)
  IN3 w0.066: v5(55.37,23.38) 54.94,23.81 v4(46.29,23.81)
AC2_OVP: length 4.4
  TOP w0.254: PR125.1 38.73,48.52 PC147.1 39.62,47.63 39.62,46.68 38.84,45.89 PR270.1 38.37,45.66 PR120.2
AC_DIS: length 195.6
  TOP w0.112: PR338.1 150.01,128.46 148.89,127.34 v2(148.89,126.61) 148.89,126.46 151.89,123.46 151.89,118.56 150.88,117.54 149.82,117.54 149.48,117.2 v8(149.48,116.4)
  IN1 w0.066: v10(109.55,91.12) 109.78,91.35 110.87,91.35 115.47,95.95 129.29,95.95 131.11,94.12 132.94,94.12 133.58,94.76 139.85,94.76 140.26,94.35 143.79,94.35 144.5,93.64 146.2,93.64 149.35,96.79 149.35,114.78 149.46,114.89 149.46,115.1 149.32,115.25 149.32,116.24 v8(149.48,116.4)
  IN2 w0.066: v4(110.49,88.61) 110.08,89.02 109.5,89.02 108.41,90.11 108.41,90.92 108.61,91.12 v10(109.55,91.12)
  IN3 w0.066: v4(110.49,88.61) 110.23,88.35 101.86,88.35 101.22,88.99 93.98,88.99 93.72,89.25 82,89.25 80.82,88.07 73.58,88.07 69.76,91.89 69.32,91.89 69.04,92.16 69.04,92.45 65.75,95.74 62.43,95.74 62.12,96.05 61.19,96.05 58.61,98.63 55.8,98.63 50.94,103.48 48.08,103.48 45.76,105.81 43.15,105.81 42.46,106.5 42.46,107.03 39.72,109.77 39.7,109.77 37.47,112.01 37.47,112.46 37.01,112.92 v6(36.5,112.92)
  IN4 w0.066: v1(24.41,119.7) 24.56,119.7 24.77,119.5 25.88,119.5 27.24,118.14 28.47,118.14 28.47,118.16 28.76,118.45 28.76,118.84 28.75,118.85 28.75,119.14 29.32,119.71 29.32,120.71 29.51,120.91 32.12,120.91 32.8,120.23 32.8,119.39 34.3,117.89 34.3,117.35 35.06,116.58 35.06,114.68 35.6,114.14 35.6,113.82 v6(36.5,112.92)
  BOTTOM w0.076: 24.41,119.32 24.41,118.25 24.73,117.93 UE3.H12
  BOTTOM w0.112: 24.41,119.32 v1(24.41,119.7)
AC_DIS#: length 21.8
  TOP w0.254: v7(147.26,132.09) 146.8,132.09 145.99,131.28 145.99,129.76 145.5,129.27 145.03,129.27 144.65,128.89 v8(144.02,128.89) 143.26,128.89 PR174.2 143.03,128 PC140.1 143.03,127.15 142.8,126.93 142.38,126.93 142.2,126.75 142.2,125.15 142.66,124.69 PR200.2 143.14,124.54 143.24,124.64 PQ122.3
  IN1 w0.254: v14(141.26,132.09) 142.35,132.09 143.56,130.88 143.56,130.02 143.71,129.87 143.71,129.2 v8(144.02,128.89)
  GND1 w0.254: v4(141.26,132.58) v14(141.26,132.09)
  GND3 w0.254: v4(141.26,132.58) 141.26,132.51 v13(140.96,132.21)
  BOTTOM w0.112: 140.96,133.16 140.96,134.05 v2(140.8,134.2)
  BOTTOM w0.254: v7(147.26,132.09) 147.26,132.01 PR230.2 ; v13(140.96,132.21) 140.96,133.16
AC_DISC#: length 194.9
  IN3 w0.066: v6(36.09,120.33) 35.69,120.74 32.48,120.74 31.52,121.71 29.44,121.71 28.78,122.37 v6(27.9,122.37) ; v5(145.78,131.45) 145.35,131.45 144.78,132.02 140.74,132.02 140.39,132.37 136.02,132.37 v6(135.86,132.53)
  IN4 w0.066: v6(135.86,132.53) 135.86,132.73 135.97,132.83 135.97,146.01 136.09,146.14 136.09,148.99 135.9,149.18 135.9,149.18 135.74,149.33 135.74,149.34 135.54,149.54 129.04,149.54 122.78,155.79 122.78,161.52 118.32,165.99 106.66,165.99 106.21,165.53 41.19,165.53 39.4,163.74 39.4,156.25 39.8,155.85 39.8,149.45 39.27,148.92 39.27,146.02 38.94,145.69 38.94,144.91 36.4,142.36 36.4,136.54 36.24,136.37 36.24,132.93 34.74,131.44 34.74,131.23 34.74,128.37 35.33,127.78 35.33,125.11 35.63,124.82 35.63,122.82 36.27,122.17 36.27,121.27 36.32,121.22 36.32,120.64 36.09,120.41 v6(36.09,120.33) ; v1(27.36,119.85) 27.36,120.45 27.76,120.85 27.76,122.23 v6(27.9,122.37)
  BOTTOM w0.076: UE3.E13 26.93,118.6 26.93,118.85 27.37,119.29 27.37,119.32
  BOTTOM w0.112: v1(27.36,119.85) 27.37,119.84 27.37,119.32
AC_DISC_OUT#: length 6.4
  BOTTOM w0.254: PR208.2 144.4,128.92 v2(141.16,128.92) 140.72,128.92 PR332.1
AC_IN: length 1.9
  TOP w0.508: PR248.1 35.81,22.67 PR266.1 34.57,23.05 PR108.2
  vias: v8(34.34,21.01) v8(34.66,21.01) v8(35.69,22.24) v8(35.66,19.09) v8(35.95,22.06) v8(35.98,18.98)
AC_PRESENT: length 72
  TOP w0.076: UCPU1.AY15 62.78,113.3 62.78,113.15 62.85,113.04 62.85,112.98 63.3,112.53 63.3,110.43
  TOP w0.112: v3(63.09,99.74) 64.37,99.74 64.58,99.95 64.58,100.79 RC91.1 63.57,101.8 63.22,101.8 v2(62.7,102.32) 62.43,102.59 62.43,105.41 62.51,105.49 62.51,109.27 63.3,110.06 63.3,110.43
  IN2 w0.066: v3(63.09,99.74) 63.19,99.63 63.19,99.32 63.02,99.15 63.02,97.73 v4(63.12,97.64)
  IN3 w0.066: v4(63.12,97.64) 61.99,97.64 59.43,100.2 56.75,100.2 50.05,106.9 49.83,106.9 45.68,106.9 45.2,107.39 42.83,107.39 40.71,109.51 40.71,110.56 38.73,112.54 38.73,113.17 38.33,113.58 35.01,113.58 34.37,112.94 31.32,112.94 29.5,111.11 28.52,111.11 28.45,111.04 28.01,111.04 27.21,110.24 26.45,110.24 24.2,112.48 24.2,114.64 v5(24.46,114.9)
  BOTTOM w0.076: UE3.K8 23.41,114.4 23.6,114.59 23.71,114.59 23.81,114.69 24.05,114.69 24.05,114.68 24.12,114.75 24.31,114.75 v5(24.46,114.9)
ACAV_IN: length 188.5
  TOP w0.112: v8(149.58,116.04) 149.63,116.04 149.86,116.27 157.23,116.27 157.72,116.77 v2(157.72,121.65) 157.72,123.78 PR346.1 PR351.2
  IN1 w0.066: v10(110.99,90.83) 110.99,91.21 115.53,95.76 129.22,95.76 131.04,93.94 133.45,93.94 133.63,94.12 143.72,94.12 144.5,93.33 146.13,93.33 149.71,96.91 149.71,115.43 149.58,115.56 v8(149.58,116.04)
  IN2 w0.066: v4(112.62,90.72) 112.51,90.83 v10(110.99,90.83)
  IN3 w0.066: v4(112.62,90.72) 112.62,90.27 110.54,88.18 98.42,88.18 97.84,88.76 93.9,88.76 93.58,89.08 82.07,89.08 80.88,87.9 73.51,87.9 69.7,91.71 69.25,91.71 68.87,92.09 68.87,92.38 65.68,95.57 62.37,95.57 62.06,95.87 61.13,95.87 58.54,98.46 55.73,98.46 50.87,103.31 48.01,103.31 45.7,105.63 43.05,105.63 42.25,106.43 42.25,107 39.66,109.58 39.65,109.58 v6(36.78,112.46)
  IN4 w0.066: v1(32.52,119.91) 32.59,119.85 32.59,119.36 34.13,117.82 34.13,117.28 34.89,116.51 34.89,114.61 35.43,114.07 35.43,113.56 36.53,112.46 v6(36.78,112.46)
  BOTTOM w0.076: 31.83,119.32 31.83,119.28 30.68,118.14 30.68,116.75 30.3,116.37 29.49,116.37 29.18,116.06 29.18,115.26 28.73,114.8 28.72,114.8 28.44,114.52 28.44,113.89 28.73,113.6
  BOTTOM w0.112: 31.83,119.32 32.42,119.91 v1(32.52,119.91)
ACAV_IN1: length 31.3
  TOP w0.112: v8(138.99,132.2) 138.99,131.94 138.43,131.38 138.43,129.61 138,129.17 PR341.1 136.35,129.54 PR319.2
  TOP w0.254: PR345.1 154.48,123.8 PR312.1 153.56,124.46 PQ308.1 151.2,125.28 v2(150.81,125.67) 149.89,126.59 v8(149.36,126.59)
  IN1 w0.066: v8(149.36,126.59) 149.45,126.68 149.45,132.26 147.72,133.99 145.69,133.99 145.45,134.23 139.79,134.23 138.99,133.43 v8(138.99,132.2)
ACCEL_INT1#: length 75.1
  TOP w0.076: v3(57.57,111.32) 58.18,111.92 58.18,112.6 58.64,113.06 58.64,113.49 UCPU1.AY8
  IN2 w0.066: v4(57.47,110.6) 57.47,111.21 v3(57.57,111.32)
  IN3 w0.066: v5(9.83,132.63) 9.83,129.82 11.97,127.67 19.33,127.67 20.03,126.97 20.59,126.97 20.85,127.23 20.85,127.55 21.62,128.31 29.18,128.31 30.1,127.39 32.19,127.39 32.6,127.8 34.41,127.8 34.72,127.49 36.34,127.49 36.34,127.49 36.75,127.49 37.28,127.49 37.73,127.04 37.86,127.04 38,127.04 38,127.04 40.01,127.04 40.12,127.16 41.91,127.16 41.95,127.2 42.47,127.2 42.89,126.78 42.89,124.99 42.89,123.53 42.89,122.52 42.89,122.38 42.89,121.83 42.89,121.83 42.89,121.74 42.89,121.59 44.99,119.49 44.99,119.42 46.75,117.66 49.41,117.66 53.34,113.73 53.68,113.73 56.01,111.4 56.88,111.4 57.47,110.81 v4(57.47,110.6)
  BOTTOM w0.112: v5(9.83,132.63) 10.67,132.63 v2(12.05,134.01) 12.26,134.22 12.26,136.81 12.45,137 D107.2 13.36,137.71 RC182.1
ACCEL_INT1#_C: length 32.7
  IN4 w0.066: v7(9.62,134.21) 12.73,134.21 14.35,135.83 14.35,146.08 11.9,148.53 v7(8.82,148.53)
  BOTTOM w0.112: v7(9.62,134.21) v2(9.97,134.56) 9.97,136.04 9.84,136.17 RS8.2 RS10.1 RS11.1 ; LGA1.4 10.47,148.29 10.22,148.53 v7(8.82,148.53)
ACCEL_INT1#_D: length 2.5
  BOTTOM w0.112: v2(11.98,138.18) 11.66,137.86 D107.1 RS8.1
ACCEL_INT2#: length 73.6
  TOP w0.076: v3(57.57,111.7) 57.96,112.09 57.96,112.6 58.31,112.95 UCPU1.BA8
  IN2 w0.066: v3(57.57,111.7) 56.96,111.09 v4(56.96,110.6)
  IN3 w0.066: v4(56.96,110.6) 56.96,110.93 56.68,111.22 55.96,111.22 53.61,113.56 53.27,113.56 49.34,117.49 46.68,117.49 44.82,119.35 44.82,119.42 42.72,121.52 42.72,121.67 42.72,121.76 42.72,122.45 42.72,122.59 42.72,123.6 42.72,125.06 42.72,126.71 42.4,127.03 42.02,127.03 41.9,126.9 40.73,126.9 39.79,125.97 38.44,125.97 38.23,126.18 37.34,126.18 36.49,127.02 34.58,127.02 34.27,127.33 33.92,127.33 33.91,127.32 v6(33.81,127.32) ; v6(33.46,135.17) 29.71,135.17 28.95,134.41 23.72,134.41 23.24,134.89 19.56,134.89 19.55,134.89 19.55,134.89 11.1,134.89 11.02,134.97 10.23,134.97 9.54,135.66 v5(9.07,135.66)
  IN4 w0.066: v6(33.46,135.17) 33.68,134.95 33.68,127.65 33.67,127.64 33.67,127.46 v6(33.81,127.32)
  BOTTOM w0.112: D108.2 7.57,137.2 RC183.1 7.76,136.78 v2(8.53,136.01) 8.88,135.66 v5(9.07,135.66)
ACCEL_INT2#_C: length 4.7
  BOTTOM w0.112: LGA1.9 v2(9.97,139.73) 9.03,138.79 RS7.1 RS9.1 RS6.1
ACCEL_INT2#_D: length 4
  BOTTOM w0.112: v2(8.6,139.17) 8.6,138.3 RS7.2 8.14,138.46 6.42,138.46 D108.1
AK52: length 1.1
  GND1 w0.203: v4(83.62,119.88) 83.24,119.5 v12(83.16,119.5)
  GND3 w0.203: v4(83.62,119.88) 83.79,119.7 v13(84.02,119.7)
ALS_I2C1_ALERT#: length 3.5
  TOP w0.112: v8(125.95,173.24) RS24.2 ; D110.1 v8(125.48,175.58)
  IN1 w0.066: v8(125.48,175.58) 125.6,175.58 126.11,175.07 126.11,173.41 v8(125.95,173.24)
ALS_I2C1_ALERT#_PCH: length 123.7
  TOP w0.076: v7(61.73,116.97) 61.72,116.97 61.43,117.26 UCPU1.AP13
  TOP w0.112: D110.2 v8(124.08,175.58)
  IN1 w0.066: v10(116.91,148.98) 116.76,148.83 116.76,147.18 115.8,146.22 115.8,144.46 112.27,140.93 112.27,140.53 111.91,140.17 111.35,140.17 110.08,138.9 110.08,132.83 109.04,131.79 108.36,131.79 103.96,127.4 103.02,127.4 102.71,127.08 102.71,126.47 100.15,123.92 96.24,123.92 94.72,125.44 88.32,125.44 87.86,124.98 71.75,124.98 71.09,124.32 71.09,123.51 67.73,120.15 64.58,120.15 64.37,120.35 63.57,120.35 63.37,120.16 62.2,120.16 62.05,120 62.05,119.47 62.56,118.96 62.76,118.96 63.4,118.33 63.4,117.79 63.22,117.62 62.97,117.62 62.71,117.87 62.28,117.87 62.08,117.67 62.08,117.34 61.73,116.99 v7(61.73,116.97) ; v8(124.08,175.58) 124.21,175.58 124.46,175.33 125.22,175.33 125.86,174.69 125.86,173.59 125.68,173.41 125.68,173.08 125.86,172.9 125.86,170.37 126.7,169.53 126.7,168.89 126.89,168.71 127.08,168.71 127.51,168.28 127.51,157.16 126.49,156.15 126.49,150.56 125.98,150.05 123.57,150.05 123.44,149.93 v10(122.94,149.93)
  IN2 w0.066: v10(122.94,149.93) 122.81,149.8 117.98,149.8 117.17,148.98 v10(116.91,148.98)
  BOTTOM w0.076: 61.98,114.82 62.2,115.05 62.2,115.46 62.19,115.48 62.19,115.78 62.2,115.8 62.2,115.89
  BOTTOM w0.112: RC392.1 60.52,113.74 61.29,114.52 61.68,114.52 61.98,114.82 ; 62.2,115.89 61.73,116.36 v7(61.73,116.97)
ALS_I2C1_SCL: length 117.3
  TOP w0.112: RS22.2 RS25.2 125.49,170.3 v7(125.43,170.36)
  IN1 w0.066: v8(54.96,128) 55.03,127.92 55.99,127.92 56.42,127.5 58.4,127.5 58.47,127.43 59.69,127.43 61.59,129.33 62.18,129.33 62.53,128.97 63.37,128.97 63.84,129.44 65.73,129.44 66.04,129.13 66.04,128.61 66.31,128.34 67.06,128.34 67.25,128.14 69.07,128.14 69.54,127.67 87.17,127.67 88.44,128.94 89.64,128.94 90.4,128.18 97.63,128.18 98.23,128.78 100.5,128.78 101.25,129.52 103.61,129.52 106.5,132.41 106.5,135.7 106.16,136.04 106.16,139.06 113.42,146.32 115.24,146.32 116.02,147.1 116.02,150.63 112.41,154.24 112.41,154.7 112.17,154.94 111.78,154.94 v7(111.41,154.57)
  BOTTOM w0.112: v7(111.41,154.57) 111.64,154.35 111.64,154.12 112.04,153.71 120.32,153.71 121.92,155.31 121.92,168.76 123.52,170.36 v2(124.94,170.36) v7(125.43,170.36)
ALS_I2C1_SDA: length 116.7
  TOP w0.112: RS23.2 RS27.2 125.54,171.48 v7(125.41,171.6)
  IN1 w0.066: v8(54.31,128) 54.55,128.25 55.24,128.25 55.37,128.12 56.07,128.12 56.5,127.69 58.48,127.69 58.55,127.62 59.61,127.62 60.35,128.36 60.35,128.61 60.71,128.97 60.71,129.07 61.19,129.55 62.33,129.55 62.69,129.2 63.22,129.2 63.65,129.63 65.81,129.63 66.23,129.21 66.23,128.69 66.39,128.53 67.14,128.53 67.33,128.33 69.15,128.33 69.62,127.87 87.09,127.87 88.36,129.14 89.72,129.14 90.48,128.38 97.55,128.38 98.15,128.97 100.42,128.97 101.17,129.71 103.53,129.71 106.31,132.49 106.31,135.62 105.97,135.96 105.97,139.14 113.34,146.51 115.16,146.51 115.83,147.18 115.83,150.55 112,154.38 v7(112,154.57)
  BOTTOM w0.112: v7(125.41,171.6) 124.4,171.6 v2(123.62,170.82) 121.6,168.81 121.6,155.33 120.22,153.95 112.14,153.95 111.87,154.22 111.87,154.45 v7(112,154.57)
ALWON: length 3.7
  BOTTOM w0.112: UE3.A5 31.05,112 31.45,112.4 RE25.2 32.41,112.39 32.74,112.06 33.28,112.06 RE26.2
ALWON_PWR: length 224.8
  TOP w0.112: v2(123.66,116.7) 123.32,117.04 v7(123.32,117.29)
  TOP w0.254: PR504.1 v7(123.32,117.29)
  IN1 w0.066: v7(107.8,164.94) 108.03,164.71 110.68,164.71 113.66,161.72 113.66,157.31 114.3,156.67 114.3,155.1 114.96,154.44 114.96,153.6 115.67,152.89 116.22,152.89 119.76,149.35 119.76,146.81 120.38,146.19 122.72,146.19 123.9,145.01 v8(123.9,144.49) 124.49,143.91 124.49,137.83 125.15,137.17 125.15,134.61 125.54,134.22 125.54,133.3 125.25,133.01 125.25,132.13 125.59,131.79 125.59,130.76 125.09,130.27 125.09,126.62 123.76,125.29 123.76,124.4 124.41,123.75 124.41,118.38 v7(123.32,117.29)
  IN2 w0.066: v4(38.69,151.26) 39.01,151.58 v3(41.71,151.58) 41.78,151.65 41.78,159.45 41.02,160.21 41.02,163.07 43.22,165.27 53.71,165.27 54.34,165.9 106.84,165.9 v7(107.8,164.94)
  IN3 w0.066: v4(38.69,151.26) 36.05,153.9 27.03,153.9 v6(26.63,153.51)
  IN4 w0.066: v1(36.8,111.62) 36.8,111.95 35.27,113.49 35.27,114 34.73,114.54 34.73,116.44 33.96,117.21 33.96,117.75 32.36,119.35 32.36,119.68 32.2,119.84 32.2,119.88 31.6,120.48 30.58,120.48 29.85,119.75 29.85,119.33 28.99,118.47 28.99,117.94 28.84,117.79 28.57,117.79 28.43,117.93 27.21,117.93 25.92,119.22 22.56,119.22 20.24,121.54 20.24,122.78 19.99,123.03 19.99,123.61 20.22,123.84 20.22,124.93 20.28,124.99 20.28,125.55 21.49,126.76 21.49,129.88 21.9,130.3 21.9,138.06 23.08,139.23 23.08,140.23 23.77,140.93 23.77,143.57 22.88,144.46 22.3,144.46 21.83,144.93 21.83,149.59 22.31,150.07 23.55,150.07 26.63,153.14 v6(26.63,153.51)
  BOTTOM w0.112: RE26.1 34.5,112.1 35.11,112.1 35.58,111.62 v1(36.8,111.62)
  BOTTOM w0.254: v7(123.32,117.29) 123.33,117.3 PR505.1
ANA2_EN: length 12.2
  IN4 w0.066: v1(143,145.29) 144.34,143.96 147.38,143.96 148.91,142.43 149.1,142.43
  IN4 w0.076: v1(150.75,143.16) 150.75,142.75 150.43,142.43 149.1,142.43
  BOTTOM w0.112: U9.5 141.65,144.56 v2(142.01,144.92) 142.38,145.29 v1(143,145.29)
ANT_CS0: length 58.2
  TOP w0.112: v3(67.66,167.44) JANT1.1
  IN2 w0.066: v3(67.66,167.44) 67.93,167.17 107.77,167.17 108.06,167.46 v7(108.06,168.49)
  BOTTOM w0.254: v7(108.06,168.49) v2(113.32,168.49) 114.94,168.49 115.82,167.62 116.32,167.12 LS1.1
ANTCTRL0: length 143.5
  TOP w0.112: v7(107.82,163.64) v2(108.35,164.17) 108.76,164.58 109.37,164.58 109.68,164.28 113.54,164.28 113.87,164.61 113.87,166.84 113.64,167.07 R86.2 ; v8(17.15,119.06) 18.06,119.06 18.38,118.74 JNGFF1.59
  IN1 w0.066: v8(17.15,119.06) 17.58,119.49 17.58,120.87 16.33,122.12 16.33,123.86 16.64,124.17 16.64,124.8 16.51,124.93 16.51,128.31 18.47,130.27 18.47,134.97 21.18,137.67 23.9,137.67 25.85,139.63 29.22,139.63 32.44,142.85 32.44,150.99 40.03,158.59 40.03,163.44 41.58,164.99 49.83,164.99 50.12,164.71 54.12,164.71 54.93,165.52 66.41,165.52 66.64,165.29 69.76,165.29 70.11,165.65 105.82,165.65 v7(107.82,163.64)
ANTCTRL1: length 144.7
  TOP w0.112: v2(17.88,112.73) JNGFF1.61 17.88,118.07 17.32,118.63 v8(17.17,118.63)
  IN1 w0.066: v8(17.17,118.63) 17.17,118.7 17.77,119.3 17.77,120.91 16.54,122.15 16.54,123.79 16.84,124.09 16.84,124.91 16.72,125.03 16.72,128.28 18.64,130.2 18.64,134.88 21.26,137.51 23.97,137.51 25.92,139.46 29.29,139.46 32.6,142.78 32.6,150.92 40.21,158.53 40.21,163.39 41.65,164.82 49.76,164.82 50.05,164.54 54.19,164.54 55,165.35 66.35,165.35 66.57,165.12 69.83,165.12 70.18,165.48 105.75,165.48 107.23,164 v7(107.23,163.64) ; v10(113.14,167.93) 113.12,167.96 113.12,168.52 v8(113.39,168.78)
  IN2 w0.066: v10(113.14,167.93) 113.14,166.12 110.12,163.09 107.77,163.09 v7(107.23,163.64)
ANTCTRL1_L: length 1.2
  TOP w0.112: v2(110.83,169.29) 110.97,169.15 112.01,169.15
AR_DET#: length 8.2
  TOP w0.076: UCPU1.P4 55.93,127.19 55.83,127.09 53.34,127.09
  TOP w0.112: 53.34,127.09 53.14,127.09 52.85,126.8 50.02,126.8 49.84,126.63 49.84,126.08 R5772.1 R5771.2
AUD_PWR_EN: length 35.2
  IN3 w0.066: v5(35.29,136.38) 35.29,135.88 32.42,133.01 22.18,133.01 v5(21.59,133.61) ; v6(21.16,127.4) 22.12,127.4 22.54,127.81 v5(24.51,127.81)
  IN4 w0.066: v5(21.59,133.61) 21.59,131.13 20.98,130.52 20.98,130.11 21.16,129.94 v6(21.16,127.4) ; v1(36.12,137.1) 36.17,137.05 36.17,136.87 35.68,136.38 v5(35.29,136.38)
  BOTTOM w0.112: R218.1 24.97,127.83 RE114.2 RE120.2 ; R109.1 R110.1 35.97,138.27 v2(35.33,138.27) ; v5(35.29,136.38) U13.3
  BOTTOM w0.203: U14.5 20.72,134.39 20.68,134.36 20.68,133.81 20.92,133.57 21.56,133.57 v5(21.59,133.61) 21.58,133.62 21.58,134.33 21.52,134.39 U14.3
AUX_EN_WOWL: length 41.9
  IN4 w0.066: v1(16.4,92.47) 16.8,92.07 16.8,90.78 16.55,90.53 16.55,87.72 16.92,87.34 16.92,83.93 v1(16.64,83.65) ; v1(27.39,109.91) 27.39,109.67 27.65,109.41 27.65,108.9 27.12,108.38 27.12,105.56 27.52,105.16 27.97,105.16 29.58,103.55 29.58,103 29.82,102.76 29.82,102.07 29.18,101.44 29.18,98.7 28.55,98.06 28.55,94.39 28.13,93.97 28.13,92.77 v1(27.71,92.35)
  BOTTOM w0.076: UE3.D3 27.89,110.4 27.4,109.91 v1(27.39,109.91)
  BOTTOM w0.112: v1(27.71,92.35) 27.39,92.03 16.84,92.03 v1(16.4,92.47)
AUX_EN_WOWL_R: length 7.8
  IN4 w0.066: v1(18.54,83) 18.44,83.1 v1(18.44,85.94) 18.44,85.94 18.8,86.3 18.8,87.62 v1(19.38,88.2)
  BOTTOM w0.112: v1(19.38,88.2) 20.14,88.2 R139.2 ; v1(18.44,85.94) 18.48,85.9 U17.3
B+: length 108.4
  TOP w0.508: PD301.2 133.47,133.75 v7(133.28,133.94)
  IN2 w0.254: v3(135.86,134.76) v4(135.46,134.76)
  IN2 w0.508: v3(148.51,124.92) 146.96,124.92 146.23,125.66 144.91,125.66 144.4,125.15 v4(144.4,124.86)
  IN2 w2.032: 50.69,32.9 62.74,44.95 62.74,48.48
  IN3 w0.762: 82.23,80.22 81.79,81.29 81.77,81.35 81.7,81.51 81.6,81.98 81.6,85.04 81.7,85.5 81.88,85.94 82.14,86.33 82.47,86.66 82.86,86.92 83.29,87.1 83.3,87.1 83.73,87.19 83.74,87.2 92.08,87.2 95.87,86.2 111.93,86.2 118.63,92.9 118.63,93.97 119.78,93.97 122.45,91.3 122.45,89.3 123.42,88.33 124.16,88.33
  IN3 w1.524: 112.09,126.01 115.19,122.91 115.19,101.92
  vias: v3(81.66,78.84) v3(81.66,78.51) v3(81.66,78.23) v3(81.94,78.84) v3(81.94,78.23) v3(81.95,78.53) v3(110.87,101.41) v3(110.87,101.03) v4(82.44,78.77) v4(82.44,78.31) v4(82.93,78.78) v4(82.93,78.3) v4(111.25,101.47) v4(111.25,101.03) v4(111.7,101.28) v6(81.92,58.99) v6(81.92,58.69) v6(81.92,58.33) v6(81.92,58.03) v6(82.22,58.99) v6(82.22,58.69) v6(82.19,58.36) v6(82.19,58.03) v6(82.5,58.99) v6(82.5,58.69) v6(82.5,58.38) v6(82.47,58.03) v6(83.62,77.94) v6(83.59,77.69) v6(83.59,77.41) v6(83.59,77.13) v6(83.9,77.94) v6(83.9,77.69) v6(83.9,77.41) v6(83.9,77.13) v6(84.18,77.94) v6(84.2,77.69) v6(84.2,77.41) v6(84.2,77.13) v7(48.3,31.71) v7(48.3,31.13) v7(48.3,30.55) v7(48.88,31.71) v7(48.88,31.13) v7(48.88,30.55) v7(62.1,61.46) v7(62.1,60.87) v7(62.1,60.29) v7(62.69,61.46) v7(62.69,60.87) v7(62.69,60.29) v7(103.3,161.23) v7(103.3,160.66) v7(103.3,160.09) v7(103.3,159.51) v7(103.3,158.94) v7(103.3,158.37) v7(103.87,161.23) v7(103.87,160.66) v7(103.87,160.09) v7(103.87,159.51) v7(103.87,158.94) v7(103.87,158.37) v7(104.44,161.23) v7(104.44,160.67) v7(104.44,160.09) v7(104.44,159.53) v7(104.44,158.94) v7(104.44,158.37) v7(110.24,126.3) v7(110.24,125.67) v7(110.82,126.3) v7(110.82,125.67) v7(122.47,122.81) v7(122.47,122.24) v7(123.04,122.81) v7(123.04,122.24) v7(123.61,122.81) v7(123.61,122.24) v7(123.66,149.01) v7(124.23,149.01) v7(124.82,149.01) v7(124.87,148.45) v7(124.87,88.53) v7(126.94,136.4) v7(127.57,136.4) v7(127.89,131.7) v7(127.89,131.13) v7(139.57,120.84) v7(139.89,120.33) v7(140.21,122.24) v7(140.21,120.84) v7(140.53,120.33) v7(140.65,135.89) v7(140.84,122.24) v7(140.84,120.84) v7(141.22,135.89) v7(141.16,120.33) v7(141.48,122.24) v7(141.48,120.84) v7(141.8,120.33) v7(142.11,122.24) v7(142.11,120.84) v7(142.75,122.24) v7(142.75,120.84) v7(143.38,122.24) v7(143.38,120.84) v7(144.02,122.24) v7(144.02,120.84) v7(144.65,122.24) v8(39.03,37.14) v8(39.01,36.82) v8(39.01,36.46) v8(39.01,36.13) v8(39.34,37.14) v8(39.34,36.81) v8(39.37,36.49) v8(39.37,36.17) v8(39.66,37.14) v8(39.66,36.81) v8(39.69,36.49) v8(39.69,36.17) v9(127.25,136.91)
B+_USH: length 14.5
  TOP w0.112: v7(136.32,88.86) 136.32,88.18 v2(136.37,88.13)
  IN4 w0.508: 124.72,92.37 127.38,92.37 128.13,91.62 128.13,91.16 129.17,90.13 135.69,90.13 136.32,89.5 v7(136.32,88.86)
  vias: v1(124.08,92.06) v1(124.6,92.36)
BASE_SMB_ALERT#: length 136
  IN2 w0.066: v4(74.81,67.44) 74.65,67.27 74.65,59.25 v3(74.55,59.15)
  IN3 w0.066: v5(28.43,118.68) 28.42,118.66 25.04,118.66 24.46,119.24 24.08,119.24 v6(23.67,119.65) 23.66,119.66 21.09,119.66 20.15,118.71 18.7,118.71 17.75,117.77 16.81,117.77 16.1,117.06 11.46,117.06 v6(11.13,117.39) ; v4(74.81,67.44) 74.48,67.77 47.62,67.77 42.56,72.84 21.59,72.84 v6(21.33,73.1)
  IN4 w0.066: v6(23.67,119.65) 23.69,119.66 23.69,121.16 24.07,121.54 v1(24.07,122.28) ; v6(21.33,73.1) 21.38,73.15 21.38,76.38 16.01,81.75 16.01,90.57 15.75,90.83 15.75,91.52 12.21,95.06 12.21,104.07 11.77,104.51 11.77,109.27 11.39,109.65 11.39,111.86 11.61,112.08 11.61,115.48 11.23,115.86 11.23,117.29 v6(11.13,117.39)
  BOTTOM w0.076: UE3.D12 27.93,117.81 28.08,117.97 28.11,117.97 28.37,118.23 28.37,118.61 v5(28.43,118.68)
BASE_SMBCLK: length 108.3
  TOP w0.112: v7(76.64,56.11) 76.46,56.28 75.45,56.28 75.32,56.15 JIO2.7 73.84,56.15 73.71,56.28 73.52,56.28 73.41,56.17 73.41,55.98 73.16,55.73 72.9,55.73 C223.1
  IN2 w0.066: v4(71.02,83.08) 71.23,82.87 74.55,82.87 78.34,79.08 78.34,62.57 77.28,61.52 77.28,56.52 77.07,56.3 76.83,56.3 v7(76.64,56.11)
  IN3 w0.066: v5(31.75,114.9) 30.12,114.9 29.27,114.05 27.74,114.05 27.61,113.92 26.64,113.92 v5(26.33,113.6) ; v4(71.02,83.08) 70.86,82.93 70.64,82.93 70.59,82.99 70.59,83.93 70.17,84.34 55.04,84.34 53.46,85.93 51.74,85.93 51.12,86.55 46.05,86.55 43.08,89.52 42.68,89.52 41.86,90.35 40.65,90.35 39.36,91.64 38.19,91.64 v6(38.15,91.68)
  IN4 w0.066: v6(38.15,91.68) 38.26,91.68 38.34,91.76 38.34,92.57 38.04,92.86 38.04,95.73 37,96.77 37,98.02 35.53,99.49 35.53,103.23 35.28,103.48 35.28,103.49 35.14,103.62 35.14,103.92 34.95,104.12 34.95,106.6 33.82,107.73 33.46,107.73 32.87,108.32 32.87,112 32.18,112.69 32.18,113.52 31.75,113.96 31.75,114.37 31.68,114.43 31.68,114.8 31.75,114.87 v5(31.75,114.9)
  BOTTOM w0.076: RE46.1 32.13,115.81 32.13,115.42 31.75,115.04 v5(31.75,114.9)
BASE_SMBDAT: length 101.7
  TOP w0.112: C222.1 72.9,55.97 73.06,55.97 73.17,56.08 73.17,56.27 73.42,56.52 73.66,56.52 73.79,56.65 JIO2.8 75.32,56.65 75.45,56.52 75.93,56.52 76.09,56.68 v7(76.65,56.68)
  IN2 w0.066: v4(71.02,82.55) 71.14,82.68 74.47,82.68 78.14,79 78.14,62.65 77.09,61.6 77.09,56.6 76.99,56.5 76.83,56.5 v7(76.65,56.68)
  IN3 w0.066: v6(38.16,91.31) 38.2,91.28 39.45,91.28 40.57,90.16 41.78,90.16 42.6,89.33 43,89.33 45.97,86.36 51.04,86.36 51.66,85.74 53.38,85.74 54.96,84.15 70.09,84.15 70.39,83.85 70.39,82.91 70.56,82.74 70.83,82.74 71.02,82.56 v4(71.02,82.55)
  IN4 w0.066: v1(32.64,112.97) 32.64,112.51 33.07,112.08 33.07,108.39 33.54,107.92 33.9,107.92 35.14,106.68 35.14,104.2 35.34,104 35.34,103.7 35.47,103.57 35.47,103.56 35.72,103.31 35.72,99.57 37.2,98.1 37.2,96.85 38.24,95.81 38.24,92.94 38.53,92.65 38.53,91.68 v6(38.16,91.31)
  BOTTOM w0.076: v1(32.64,112.97) 31.33,112.97 30.8,112.43 30.58,112.43 30.48,112.33 29.97,112.33 29.53,112.78 UE3.B6
BAT1_LED#: length 139.5
  TOP w0.112: Q354.1 126.59,92.06 126.46,91.93 v3(126.46,91.12)
  IN2 w0.066: v4(126.06,90.87) 126.21,90.87 v3(126.46,91.12)
  IN3 w0.066: v6(69.28,82.11) 69.02,81.85 66.8,81.85 65.78,82.86 48.28,82.86 46.37,84.77 45.18,84.77 42.2,87.76 39.98,87.76 39.59,88.15 v6(39.45,88.15) ; v6(125.7,90.87) v4(126.06,90.87)
  IN4 w0.066: v6(69.28,82.11) 69.86,82.69 69.86,83.8 70.02,83.96 70.17,83.96 70.96,84.75 74.8,84.75 78.78,88.73 94.3,88.73 94.76,88.28 110.15,88.28 113.98,92.11 122.07,92.11 123.32,90.87 v6(125.7,90.87) ; v1(28.33,117.26) 28.78,117.26 29.79,118.27 29.79,118.53 30.25,118.99 30.25,119.67 30.72,120.14 31.46,120.14 31.86,119.74 31.86,119.71 32.01,119.56 32.01,119.16 32.01,119.02 33.62,117.41 33.62,117.07 34.39,116.3 34.39,114.4 34.93,113.86 34.93,113.35 36.17,112.11 36.17,111.97 36.17,109.49 36.17,109.49 36.17,109.13 36.59,108.71 36.59,108.39 36.59,108.07 36.87,107.79 36.87,105.04 37.23,104.68 37.23,102.44 37.44,102.22 37.44,100.65 39.77,98.33 39.77,98.21 39.77,98.21 39.77,97.85 39.77,97.85 39.77,96.5 39.6,96.32 39.6,93.56 39.7,93.46 39.7,93.11 39.6,93.01 39.6,91.08 38.61,90.1 38.61,89.28 38.98,88.92 38.98,88.59 39.42,88.15 v6(39.45,88.15)
  BOTTOM w0.076: v1(28.33,117.26) 28.26,117.19 28.26,116.6 27.93,116.27 UE3.D10
